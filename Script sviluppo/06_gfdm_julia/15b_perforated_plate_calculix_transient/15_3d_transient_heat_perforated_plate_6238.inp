28441, 3327, 3360, 3361, 5995
28442, 3594, 313, 82, 921
28443, 4026, 4900, 5222, 6132
28444, 5151, 5727, 4116, 5929
28445, 931, 4436, 5365, 6224
28446, 3330, 3453, 3370, 4827
28447, 86, 323, 3598, 3675
28448, 2532, 2530, 2531, 5177
28449, 2241, 3083, 2785, 5107
28450, 4440, 5951, 5374, 6161
28451, 2164, 2165, 5615, 5928
28452, 2728, 3681, 3133, 5048
28453, 5540, 5787, 4759, 6191
28454, 376, 479, 374, 5523
28455, 4372, 6067, 5103, 6218
28456, 531, 745, 1165, 5504
28457, 854, 976, 975, 5398
28458, 4102, 5513, 4654, 5815
28459, 2746, 2574, 2573, 6088
28460, 903, 1067, 1068, 4784
28461, 4955, 6069, 2262, 6206
28462, 4315, 5339, 4634, 6213
28463, 515, 513, 514, 5917
28464, 4019, 5047, 5320, 5895
28465, 197, 2732, 2139, 3710
28466, 2508, 2468, 2466, 6181
28467, 5020, 5404, 4356, 5544
28468, 3113, 3132, 2636, 5583
28469, 5066, 5501, 4575, 6111
28470, 525, 5516, 1113, 6050
28471, 433, 1296, 1225, 4759
28472, 893, 312, 3308, 5653
28473, 2839, 5353, 5218, 5719
28474, 4742, 5511, 5790, 5912
28475, 2776, 2479, 3114, 5929
28476, 1052, 1054, 5617, 5768
28477, 1001, 998, 1161, 5923
28478, 1338, 1002, 777, 5908
28479, 3486, 247, 2973, 5486
28480, 4088, 5948, 5807, 6221
28481, 3464, 3420, 3470, 5339
28482, 1417, 833, 739, 4939
28483, 2925, 2924, 2174, 5335
28484, 18, 3281, 885, 1352
28485, 3469, 3561, 3584, 5125
28486, 1234, 1031, 516, 4894
28487, 513, 512, 511, 5917
28488, 2863, 5737, 5957, 6195
28489, 1057, 1061, 1059, 5784
28490, 3156, 2546, 2717, 5549
28491, 482, 5973, 5217, 6171
28492, 2989, 2997, 2597, 5992
28493, 2309, 5387, 2310, 6113
28494, 3000, 4998, 3150, 5956
28495, 3374, 3430, 3376, 5014
28496, 2732, 2632, 2139, 6123
28497, 4137, 5563, 4628, 5881
28498, 3253, 5453, 3252, 5531
28499, 4654, 5513, 4411, 5815
28500, 3421, 3330, 289, 2113
28501, 817, 789, 773, 4889
28502, 4188, 6021, 5633, 6211
28503, 1299, 331, 1346, 5919
28504, 3960, 5484, 4688, 5986
28505, 5773, 5922, 4424, 6221
28506, 2647, 5026, 2648, 6204
28507, 3019, 2790, 2583, 5334
28508, 165, 3280, 3229, 3142
28509, 4107, 4650, 5659, 5728
28510, 4086, 5674, 4877, 5767
28511, 1129, 588, 529, 6126
28512, 3200, 2619, 3108, 5173
28513, 4031, 5448, 5098, 5856
28514, 5196, 5807, 4088, 5948
28515, 509, 4658, 5369, 6026
28516, 3052, 3175, 2658, 4999
28517, 2520, 2819, 2959, 5483
28518, 4789, 5491, 4026, 6165
28519, 3769, 3839, 3770, 5447
28520, 772, 944, 771, 5458
28521, 4256, 5986, 5484, 6102
28522, 736, 1169, 449, 5642
28523, 2889, 2292, 2331, 5785
28524, 2364, 2366, 2447, 5142
28525, 195, 3817, 3699, 5620
28526, 3748, 3887, 3831, 5171
28527, 5514, 5815, 4411, 5924
28528, 1125, 976, 854, 5398
28529, 4391, 5879, 5685, 6157
28530, 2541, 3219, 2620, 5411
28531, 397, 398, 396, 5506
28532, 4105, 5679, 4669, 5801
28533, 849, 960, 959, 5045
28534, 2936, 2964, 5684, 5937
28535, 2150, 3118, 217, 3605
28536, 3233, 3237, 3236, 5452
28537, 638, 1344, 1384, 4767
28538, 986, 985, 716, 5849
28539, 4286, 5807, 5196, 5948
28540, 4488, 5844, 911, 6127
28541, 589, 534, 618, 5507
28542, 4503, 3960, 5902, 6230
28543, 566, 568, 567, 5181
28544, 521, 1150, 5824, 6225
28545, 2732, 3710, 196, 6123
28546, 893, 325, 1353, 5653
28547, 3706, 31, 332, 3891
28548, 2487, 2490, 2430, 5996
28549, 3423, 3311, 3448, 4956
28550, 4214, 5891, 5138, 6166
28551, 4053, 5483, 4594, 5983
28552, 1208, 5781, 720, 6231
28553, 323, 86, 919, 3675
28554, 532, 520, 533, 5124
28555, 3248, 3249, 5453, 5869
28556, 2261, 2328, 2797, 6069
28557, 4021, 5156, 4873, 6037
28558, 3586, 3521, 3567, 5001
28559, 760, 1184, 880, 5899
28560, 4372, 5636, 4670, 6067
28561, 1299, 3602, 76, 3669
28562, 3541, 3542, 3488, 5437
28563, 4051, 5529, 6008, 6130
28564, 4631, 5490, 4084, 6140
28565, 1098, 1345, 1350, 4842
28566, 4815, 4096, 5467, 6214
28567, 3849, 5400, 3751, 5582
28568, 2411, 2391, 2392, 5679
28569, 3693, 55, 337, 1402
28570, 4069, 4656, 6027, 6217
28571, 1163, 298, 1419, 5595
28572, 4082, 5509, 5135, 6186
28573, 3158, 3118, 2676, 4928
28574, 1272, 1359, 5597, 5821
28575, 2324, 2353, 2298, 5548
28576, 282, 2130, 2715, 5266
28577, 1131, 872, 1305, 5503
28578, 21, 3273, 3227, 1211
28579, 2887, 2105, 186, 6146
28580, 2518, 2543, 5955, 6147
28581, 296, 1364, 835, 4672
28582, 730, 728, 1166, 5710
28583, 3204, 2767, 2637, 5057
28584, 2164, 2163, 2165, 5928
28585, 2200, 2202, 2201, 5499
28586, 3557, 3568, 3535, 5291
28587, 1005, 1004, 1071, 5502
28588, 4288, 5279, 4816, 6169
28589, 4500, 5550, 4887, 5966
28590, 4963, 5687, 4290, 6084
28591, 4899, 5109, 4261, 6085
28592, 305, 879, 1378, 4772
28593, 2163, 5615, 2165, 5928
28594, 3852, 2876, 184, 5727
28595, 679, 611, 1242, 5083
28596, 2540, 2496, 5411, 5982
28597, 4216, 5374, 5951, 6161
28598, 2121, 3216, 3137, 5437
28599, 3509, 3565, 3523, 4781
28600, 3863, 3702, 3875, 5151
28601, 2773, 2769, 2791, 5155
28602, 4060, 5847, 5610, 6007
28603, 1389, 1119, 5171, 5746
28604, 641, 1230, 1154, 5730
28605, 392, 1298, 390, 5872
28606, 3402, 3405, 3403, 4884
28607, 3519, 3537, 3517, 4809
28608, 2985, 2386, 2395, 5436
28609, 2855, 2860, 2960, 5086
28610, 844, 1139, 842, 5939
28611, 4178, 5519, 5124, 6200
28612, 4084, 5107, 5490, 5926
28613, 5124, 5519, 4691, 6200
28614, 1299, 76, 331, 3669
28615, 2262, 2294, 2261, 6069
28616, 4859, 5818, 4819, 5819
28617, 3684, 3622, 5337, 5734
28618, 4169, 4652, 5443, 6199
28619, 2161, 2163, 2162, 5928
28620, 4271, 4965, 4945, 5716
28621, 453, 452, 457, 5828
28622, 3245, 3246, 4830, 5869
28623, 3644, 230, 2115, 3667
28624, 757, 759, 758, 5772
28625, 3469, 3450, 3561, 5125
28626, 3097, 3172, 3584, 5125
28627, 3810, 3812, 3809, 5408
28628, 1345, 5723, 4842, 6035
28629, 2600, 3054, 6044, 6128
28630, 4323, 5580, 4835, 6224
28631, 3278, 3294, 3223, 5495
28632, 735, 453, 458, 5828
28633, 1299, 1346, 5337, 5919
28634, 1035, 1210, 1039, 6025
28635, 2798, 2799, 2449, 5944
28636, 5293, 5829, 4104, 6131
28637, 2761, 3881, 174, 2134
28638, 142, 350, 351, 3334
28639, 4637, 4129, 5480, 6141
28640, 75, 314, 3668, 1299
28641, 926, 5383, 3590, 5563
28642, 2870, 3160, 2623, 6028
28643, 2160, 2387, 3068, 5468
28644, 3816, 201, 3153, 3722
28645, 4157, 5570, 4692, 6025
28646, 1037, 1036, 1035, 6025
28647, 3429, 3445, 3326, 5843
28648, 1108, 5381, 711, 6068
28649, 2709, 2710, 2104, 5368
28650, 3084, 5884, 2785, 6140
28651, 1287, 878, 754, 5305
28652, 4945, 4965, 4307, 5716
28653, 2665, 3016, 2580, 5226
28654, 5029, 5185, 4142, 5874
28655, 319, 92, 3571, 1181
28656, 2596, 3007, 5854, 6066
28657, 2717, 2710, 3156, 5549
28658, 482, 481, 483, 5217
28659, 4114, 5511, 4945, 5786
28660, 872, 879, 305, 4772
28661, 3731, 3729, 3888, 5046
28662, 2252, 2967, 2250, 5803
28663, 3091, 2175, 2177, 5316
28664, 3102, 5310, 3726, 5613
28665, 3159, 5310, 3102, 5613
28666, 4591, 5601, 2867, 6036
28667, 3325, 266, 3149, 3465
28668, 2660, 2153, 2154, 5044
28669, 626, 873, 1193, 5015
28670, 4353, 5411, 5527, 6189
28671, 2606, 2503, 2504, 5647
28672, 2675, 2673, 2571, 5485
28673, 2559, 2560, 2561, 5410
28674, 4739, 5380, 4077, 5896
28675, 2943, 2747, 2573, 5695
28676, 3167, 3069, 2620, 5527
28677, 3456, 321, 141, 3314
28678, 3078, 2802, 2239, 5599
28679, 381, 382, 380, 5894
28680, 4148, 5792, 4492, 6052
28681, 2994, 2424, 2540, 5982
28682, 4150, 5185, 5029, 5874
28683, 4644, 5501, 4044, 6097
28684, 3047, 5622, 2967, 5803
28685, 2494, 2757, 2754, 4837
28686, 947, 3549, 1383, 6004
28687, 4537, 5827, 4420, 6142
28688, 2881, 5579, 3205, 5904
28689, 4925, 4135, 5096, 5762
28690, 2117, 2761, 2651, 5685
28691, 1080, 1084, 5228, 5821
28692, 3011, 2394, 2385, 5025
28693, 3025, 2766, 3026, 5630
28694, 4819, 4148, 6106, 6216
28695, 958, 1113, 1201, 5516
28696, 4659, 5981, 4374, 6145
28697, 3692, 3844, 5818, 5819
28698, 5103, 6188, 4372, 6218
28699, 797, 796, 733, 5576
28700, 58, 296, 3694, 1351
28701, 530, 4592, 6134, 6179
28702, 2772, 2771, 2792, 6087
28703, 3762, 3694, 3763, 5233
28704, 4510, 5438, 4940, 5814
28705, 3747, 3745, 3748, 5062
28706, 5148, 5242, 2327, 6056
28707, 467, 466, 455, 4978
28708, 2982, 2435, 2419, 5432
28709, 2655, 4815, 2656, 6214
28710, 3640, 3638, 4751, 6108
28711, 4336, 5634, 4759, 5872
28712, 3805, 3803, 3804, 5197
28713, 3953, 5887, 5532, 6169
28714, 4072, 5356, 4666, 6133
28715, 4591, 4040, 5601, 6036
28716, 4562, 5395, 4502, 6091
28717, 3564, 3582, 3486, 5486
28718, 4570, 4120, 5658, 6219
28719, 3857, 3817, 3865, 5620
28720, 1035, 6025, 5570, 6065
28721, 3909, 5219, 5200, 6156
28722, 2728, 2647, 3182, 5048
28723, 798, 5537, 1127, 5816
28724, 4692, 5769, 4210, 5997
28725, 113, 322, 894, 5562
28726, 2722, 5416, 2589, 6227
28727, 2505, 2610, 2495, 5431
28728, 4535, 4331, 5941, 6210
28729, 1083, 1328, 5508, 6003
28730, 4534, 5597, 4471, 5821
28731, 1086, 973, 307, 5711
28732, 1190, 1350, 5823, 6023
28733, 3212, 3195, 3700, 6048
28734, 869, 868, 870, 5211
28735, 4038, 5480, 4949, 6085
28736, 3221, 2896, 3131, 5736
28737, 4160, 5280, 5219, 5970
28738, 2366, 2364, 2365, 6178
28739, 917, 902, 1358, 5989
28740, 2609, 2503, 2606, 5407
28741, 380, 378, 379, 5894
28742, 115, 3304, 3420, 1347
28743, 3780, 3784, 3782, 5777
28744, 4215, 5636, 4702, 5794
28745, 3487, 241, 3103, 3562
28746, 1122, 5523, 479, 6060
28747, 1266, 5697, 356, 6017
28748, 2735, 2710, 2717, 4648
28749, 726, 859, 860, 5149
28750, 2258, 2685, 2996, 5942
28751, 3342, 3341, 3343, 5713
28752, 2316, 2317, 2321, 6173
28753, 935, 3463, 140, 5392
28754, 1357, 1300, 348, 5571
28755, 3255, 3293, 163, 2143
28756, 2526, 2525, 2524, 5879
28757, 588, 634, 631, 5120
28758, 2494, 2426, 2441, 5886
28759, 2261, 2262, 6069, 6206
28760, 4075, 5930, 5543, 6034
28761, 5615, 5928, 4122, 6166
28762, 4640, 5415, 4409, 6064
28763, 2973, 247, 2111, 5486
28764, 3111, 2663, 2120, 5375
28765, 340, 1163, 1336, 5595
28766, 3144, 2471, 2581, 5134
28767, 1200, 651, 697, 6236
28768, 4241, 5320, 5698, 6032
28769, 2740, 2529, 5394, 6174
28770, 2896, 2575, 3131, 5736
28771, 3072, 2816, 3073, 6024
28772, 862, 777, 778, 5605
28773, 5329, 6098, 4326, 6185
28774, 4125, 5098, 5448, 5856
28775, 3266, 5669, 3271, 6038
28776, 2760, 3003, 2915, 5242
28777, 893, 3308, 3458, 5653
28778, 4815, 5467, 4266, 6013
28779, 2506, 2733, 2519, 5491
28780, 2612, 5397, 2584, 5792
28781, 2999, 5854, 4721, 6054
28782, 555, 552, 1176, 6238
28783, 2530, 5177, 2968, 6205
28784, 4076, 4563, 5855, 6206
28785, 2741, 5175, 2306, 5959
28786, 645, 564, 562, 5545
28787, 3094, 3095, 3004, 6186
28788, 3660, 3614, 3625, 5133
28789, 3505, 3507, 3506, 5077
28790, 540, 795, 536, 5912
28791, 4035, 4898, 5735, 6098
28792, 3357, 3325, 3455, 5336
28793, 2141, 3483, 5308, 6177
28794, 845, 926, 1380, 5383
28795, 67, 3847, 1300, 5571
28796, 5633, 6021, 4738, 6211
28797, 2980, 3137, 2626, 5437
28798, 2875, 3156, 3096, 5549
28799, 4686, 5772, 4115, 5890
28800, 14, 1297, 3279, 3231
28801, 3742, 4846, 3607, 6183
28802, 2494, 2871, 2757, 5558
28803, 1419, 5595, 298, 6045
28804, 3566, 1178, 94, 1335
28805, 4035, 4990, 4898, 6098
28806, 2382, 2384, 2452, 5378
28807, 1361, 3489, 105, 947
28808, 955, 1070, 1069, 5459
28809, 531, 542, 745, 5504
28810, 348, 1316, 874, 5059
28811, 341, 860, 859, 5588
28812, 3204, 2637, 3183, 5057
28813, 3759, 3708, 3757, 5937
28814, 4046, 4601, 5768, 5914
28815, 1314, 361, 1133, 5935
28816, 969, 971, 967, 5196
28817, 2965, 3138, 3221, 5261
28818, 201, 2098, 3153, 3722
28819, 1173, 5903, 464, 6171
28820, 3806, 3805, 3804, 5773
28821, 2322, 5188, 2335, 6011
28822, 4978, 5347, 4055, 5994
28823, 2518, 2492, 2543, 6147
28824, 3589, 5712, 3197, 5987
28825, 1273, 1275, 1046, 5636
28826, 3914, 4632, 5806, 5931
28827, 2933, 2491, 2574, 6088
28828, 2420, 2391, 2869, 5679
28829, 2374, 2963, 2845, 5406
28830, 1285, 1320, 878, 6110
28831, 3672, 72, 324, 1331
28832, 4899, 5649, 5109, 6085
28833, 5628, 5879, 4391, 6157
28834, 3303, 3286, 3229, 5021
28835, 3133, 2728, 220, 3681
28836, 4715, 5365, 4206, 6132
28837, 2442, 2949, 2234, 5867
28838, 3142, 2143, 2662, 5021
28839, 3571, 1181, 3480, 5426
28840, 346, 1255, 875, 5656
28841, 1113, 525, 1201, 5516
28842, 3444, 3447, 3428, 5776
28843, 3377, 3446, 3430, 6116
28844, 3390, 3322, 3389, 5947
28845, 3082, 2189, 3081, 5351
28846, 4333, 5493, 5435, 5573
28847, 4097, 4837, 5886, 6063
28848, 4097, 5315, 4837, 6063
28849, 3003, 2327, 5242, 6056
28850, 5273, 5986, 4852, 6102
28851, 87, 919, 3675, 3606
28852, 232, 3197, 2125, 5987
28853, 3887, 3709, 3831, 5171
28854, 3549, 947, 105, 6004
28855, 2746, 3185, 2749, 4809
28856, 1032, 1042, 423, 5462
28857, 4322, 6030, 5650, 6152
28858, 4695, 5700, 4147, 6005
28859, 2910, 5619, 4754, 6056
28860, 3779, 3834, 3778, 5758
28861, 3862, 3822, 3861, 5765
28862, 3199, 3129, 2748, 5078
28863, 3112, 4884, 2127, 6144
28864, 736, 1061, 1062, 5784
28865, 3256, 3245, 3244, 5237
28866, 594, 595, 602, 5091
28867, 5166, 5685, 4318, 6157
28868, 2496, 2424, 2425, 5982
28869, 2323, 2324, 2298, 5040
28870, 587, 588, 631, 5120
28871, 2775, 2772, 2776, 5071
28872, 3151, 4934, 2706, 5801
28873, 2405, 2367, 2365, 6178
28874, 3476, 100, 3558, 6045
28875, 4065, 4997, 4828, 5562
28876, 2706, 3151, 2874, 4934
28877, 4167, 5709, 4953, 5981
28878, 3327, 3361, 3362, 5995
28879, 935, 140, 321, 5392
28880, 601, 4975, 651, 6236
28881, 2192, 3022, 3100, 6227
28882, 3060, 6044, 3054, 6128
28883, 451, 462, 461, 5003
28884, 3698, 1099, 48, 5632
28885, 706, 5594, 1128, 6076
28886, 3707, 2140, 203, 3894
28887, 4025, 5045, 5343, 6231
28888, 2912, 5585, 2198, 5901
28889, 3340, 3341, 3339, 5713
28890, 3197, 5712, 2635, 5987
28891, 5258, 5434, 4278, 6107
28892, 1119, 345, 1369, 5171
28893, 391, 1275, 393, 5946
28894, 2628, 3206, 3059, 5694
28895, 3665, 3650, 3666, 4861
28896, 3647, 3648, 3646, 4683
28897, 1087, 529, 5259, 6126
28898, 3250, 3243, 3246, 4830
28899, 486, 487, 488, 5743
28900, 4087, 4553, 5925, 6139
28901, 4088, 5807, 5196, 5922
28902, 3289, 3266, 3271, 6038
28903, 463, 458, 457, 5828
28904, 2885, 3130, 2884, 5763
28905, 3691, 3639, 3644, 5712
28906, 130, 933, 3310, 6116
28907, 3240, 3241, 3239, 4931
28908, 5347, 5994, 4978, 6179
28909, 5407, 5453, 4831, 6170
28910, 2886, 2105, 3074, 5765
28911, 4247, 5670, 5457, 6091
28912, 2111, 3215, 3117, 6201
28913, 1114, 380, 456, 5072
28914, 4237, 5553, 5382, 6047
28915, 459, 447, 364, 6016
28916, 4628, 5589, 4294, 5881
28917, 5240, 5868, 4547, 5953
28918, 1072, 5976, 609, 6229
28919, 3191, 3207, 2638, 5945
28920, 2485, 2514, 2608, 5975
28921, 1024, 1025, 1026, 5493
28922, 3514, 3513, 3512, 4976
28923, 1280, 385, 439, 5804
28924, 962, 1122, 479, 6060
28925, 2882, 5332, 3161, 5904
28926, 2936, 3879, 205, 5937
28927, 4120, 5537, 4712, 5717
28928, 3267, 5194, 3266, 5998
28929, 4082, 4573, 5541, 6186
28930, 1239, 1249, 802, 6021
28931, 4088, 5625, 5196, 5948
28932, 2113, 289, 3421, 2736
28933, 3808, 3810, 3809, 5888
28934, 3335, 3469, 2149, 5125
28935, 4554, 5702, 4108, 5907
28936, 3374, 3376, 3375, 5014
28937, 4520, 5864, 4622, 6110
28938, 2654, 2653, 2650, 6013
28939, 1083, 1318, 1384, 6003
28940, 4141, 5345, 4927, 6020
28941, 3012, 2837, 2841, 5863
28942, 23, 3256, 3290, 1377
28943, 884, 5340, 1352, 5732
28944, 2635, 5712, 4762, 5987
28945, 1258, 1127, 798, 5537
28946, 3693, 54, 3771, 5286
28947, 817, 773, 1329, 4889
28948, 2953, 5707, 2237, 6001
28949, 855, 853, 856, 5831
28950, 3297, 3336, 3466, 5413
28951, 3248, 3275, 3222, 4831
28952, 2997, 2998, 2597, 5992
28953, 3604, 3664, 3629, 5834
28954, 1030, 1172, 1026, 5333
28955, 3247, 4944, 3249, 5869
28956, 4903, 5813, 4099, 5974
28957, 2492, 2477, 2491, 6147
28958, 4154, 5700, 4695, 6005
28959, 187, 3822, 2105, 5765
28960, 592, 1209, 583, 5295
28961, 3141, 2666, 5792, 6052
28962, 4375, 5551, 4663, 5992
28963, 432, 429, 5182, 6145
28964, 4226, 5999, 5177, 6205
28965, 3059, 2576, 2926, 5905
28966, 3417, 3433, 3434, 5646
28967, 4094, 5518, 4806, 5820
28968, 3156, 2875, 2546, 5549
28969, 5061, 5888, 5773, 5922
28970, 471, 1143, 1142, 5968
28971, 914, 328, 913, 5843
28972, 4352, 5844, 4488, 6127
28973, 4025, 5343, 4614, 6231
28974, 2116, 2659, 3101, 6091
28975, 2882, 2884, 2886, 5332
28976, 2475, 2476, 2477, 5379
28977, 5227, 5267, 4140, 6228
28978, 2435, 2434, 2419, 5788
28979, 1204, 1063, 438, 5366
28980, 3536, 3552, 3558, 6045
28981, 498, 1138, 508, 6096
28982, 3224, 3261, 3284, 5326
28983, 507, 498, 508, 6096
28984, 4012, 5866, 5123, 5891
28985, 2286, 2410, 3023, 5300
28986, 1224, 813, 811, 5325
28987, 2243, 5088, 2242, 6168
28988, 3718, 34, 1410, 1393
28989, 3892, 3878, 3871, 6216
28990, 4081, 5604, 5158, 5728
28991, 509, 5369, 508, 6026
28992, 3262, 3260, 3261, 4848
28993, 4125, 4565, 5648, 5856
28994, 4303, 5198, 5332, 5904
28995, 4030, 4754, 5619, 6056
28996, 4298, 5267, 5227, 6228
28997, 3574, 3500, 3497, 4707
28998, 3132, 3894, 2140, 5583
28999, 393, 394, 392, 5946
29000, 703, 648, 693, 5547
29001, 2984, 2820, 2894, 5298
29002, 1166, 5710, 728, 6139
29003, 396, 1110, 394, 5540
29004, 4052, 5323, 5518, 6142
29005, 2942, 2325, 2326, 5482
29006, 3889, 3738, 3737, 5572
29007, 764, 1308, 785, 6160
29008, 847, 1139, 844, 5589
29009, 4508, 3629, 5834, 6159
29010, 2704, 5561, 2703, 5947
29011, 3669, 3602, 3622, 5337
29012, 2105, 5765, 3822, 6146
29013, 3476, 1164, 100, 6045
29014, 658, 633, 657, 6042
29015, 3446, 130, 3310, 6116
29016, 2535, 2598, 2599, 4960
29017, 3777, 3776, 3840, 5094
29018, 1168, 996, 984, 5718
29019, 2674, 2544, 2933, 5056
29020, 2763, 6117, 3112, 6144
29021, 3783, 3779, 3781, 5186
29022, 3414, 134, 304, 5797
29023, 471, 470, 469, 5968
29024, 3537, 2749, 256, 3185
29025, 2389, 2299, 2940, 6036
29026, 2150, 3688, 3173, 5310
29027, 1204, 5366, 438, 5985
29028, 915, 4681, 933, 6116
29029, 3506, 3508, 3509, 5111
29030, 2801, 2800, 2799, 5944
29031, 1283, 886, 887, 5417
29032, 4323, 5365, 4715, 6132
29033, 2481, 3049, 3044, 5871
29034, 703, 1186, 648, 5547
29035, 889, 304, 134, 5797
29036, 4948, 5012, 4557, 6180
29037, 3365, 3472, 3448, 5272
29038, 612, 542, 611, 5658
29039, 557, 558, 559, 5735
29040, 25, 3283, 1340, 5588
29041, 505, 477, 1195, 5533
29042, 2586, 3143, 2634, 5526
29043, 761, 1343, 762, 4715
29044, 2677, 2528, 3106, 5321
29045, 2563, 5491, 4789, 6165
29046, 2893, 187, 2105, 5765
29047, 2905, 2903, 2906, 5115
29048, 4197, 5649, 4899, 6085
29049, 4400, 5810, 4821, 6207
29050, 1338, 777, 862, 5605
29051, 5066, 5192, 4367, 6111
29052, 3154, 3291, 2118, 5669
29053, 1331, 3672, 926, 5383
29054, 2881, 2469, 5579, 5904
29055, 2740, 3015, 2529, 6174
29056, 753, 653, 5829, 6131
29057, 195, 2101, 3817, 5620
29058, 5484, 5986, 3960, 6102
29059, 1139, 606, 1003, 5860
29060, 3075, 2195, 2197, 5004
29061, 1286, 1322, 336, 5758
29062, 1280, 999, 1279, 5122
29063, 1417, 833, 4939, 6150
29064, 1022, 1021, 1229, 5789
29065, 4311, 5812, 4780, 5849
29066, 4290, 5599, 4932, 6084
29067, 1311, 751, 834, 4859
29068, 2344, 2413, 2343, 6133
29069, 2112, 3195, 2730, 6048
29070, 3718, 33, 315, 1410
29071, 3891, 31, 332, 959
29072, 2603, 3051, 2604, 5479
29073, 964, 783, 1217, 5664
29074, 4977, 5519, 4178, 6010
29075, 3390, 3391, 3322, 5947
29076, 3010, 4902, 2731, 6100
29077, 3396, 3398, 3397, 4986
29078, 3239, 4931, 3241, 5934
29079, 2245, 2688, 3092, 5893
29080, 2758, 2948, 2521, 5932
29081, 951, 360, 585, 5143
29082, 3875, 3852, 3801, 5727
29083, 2999, 2889, 2931, 6054
29084, 1151, 440, 450, 5475
29085, 3571, 92, 3480, 1181
29086, 2725, 3178, 3219, 5712
29087, 2887, 186, 3719, 6146
29088, 3709, 67, 345, 5571
29089, 4614, 5343, 722, 6231
29090, 2631, 3037, 2892, 5249
29091, 973, 970, 968, 5625
29092, 2190, 2248, 3022, 5389
29093, 4041, 5011, 5314, 6047
29094, 2846, 2847, 2448, 5681
29095, 1385, 1083, 5508, 6003
29096, 2334, 2335, 2322, 5188
29097, 1206, 1196, 795, 5912
29098, 4288, 5532, 5887, 6169
29099, 4366, 5234, 5015, 6197
29100, 5138, 5891, 4012, 6166
29101, 5035, 5790, 988, 6226
29102, 1035, 1033, 1210, 6065
29103, 4413, 5941, 5758, 6210
29104, 2101, 195, 2729, 5620
29105, 2975, 2981, 2410, 6198
29106, 4153, 5188, 5159, 6011
29107, 867, 868, 869, 5211
29108, 2685, 2918, 2509, 5799
29109, 1405, 5746, 1389, 6217
29110, 1260, 1262, 1007, 6009
29111, 175, 3701, 3881, 2761
29112, 4070, 5520, 4577, 6137
29113, 2923, 2340, 2422, 5748
29114, 1082, 1080, 1084, 5228
29115, 1316, 1356, 874, 5059
29116, 2222, 3012, 2841, 5863
29117, 1360, 326, 917, 5569
29118, 2532, 2533, 2534, 5999
29119, 2623, 2533, 2938, 6028
29120, 753, 655, 653, 6131
29121, 3816, 202, 3707, 6052
29122, 3891, 3823, 32, 959
29123, 808, 1162, 1134, 5043
29124, 4537, 4420, 5937, 6142
29125, 3067, 3064, 2809, 5085
29126, 1151, 435, 5475, 6071
29127, 4173, 5740, 4556, 5853
29128, 353, 355, 4993, 6086
29129, 977, 1150, 553, 6225
29130, 1039, 5603, 4671, 6025
29131, 2895, 2427, 2400, 5224
29132, 2118, 3154, 156, 3291
29133, 2122, 2921, 208, 5665
29134, 919, 87, 349, 3606
29135, 2645, 2644, 2646, 5361
29136, 2327, 2915, 3003, 5242
29137, 3386, 3392, 3431, 5213
29138, 4670, 5636, 4372, 5880
29139, 3249, 3252, 3253, 5453
29140, 3383, 3373, 3371, 5654
29141, 4092, 5747, 5552, 5859
29142, 552, 553, 522, 6225
29143, 5065, 5607, 4048, 5655
29144, 3480, 91, 3572, 1181
29145, 2155, 2577, 2157, 6164
29146, 4530, 5317, 5037, 5961
29147, 2996, 3104, 2186, 4973
29148, 640, 432, 1147, 6145
29149, 4111, 5789, 4706, 5954
29150, 1378, 339, 102, 5722
29151, 2953, 2237, 2957, 6001
29152, 3350, 3450, 3335, 5125
29153, 3308, 117, 312, 893
29154, 722, 5343, 960, 6231
29155, 94, 3477, 3566, 1335
29156, 3359, 3358, 3357, 4905
29157, 3353, 3321, 3356, 5524
29158, 5134, 5905, 4415, 6029
29159, 944, 945, 771, 5313
29160, 3433, 3307, 3438, 5797
29161, 2163, 2161, 3116, 5512
29162, 1016, 408, 411, 5277
29163, 2659, 5670, 3101, 6091
29164, 1394, 1374, 1200, 4768
29165, 5103, 5254, 4372, 6188
29166, 806, 1094, 712, 5782
29167, 1151, 5475, 4738, 6071
29168, 3711, 3829, 3868, 5057
29169, 3597, 3687, 3656, 4929
29170, 1065, 1138, 587, 5289
29171, 2622, 2534, 2533, 6154
29172, 582, 583, 5380, 6051
29173, 353, 355, 775, 4993
29174, 2935, 2165, 2163, 5615
29175, 2300, 2309, 2310, 6113
29176, 610, 609, 1072, 5976
29177, 616, 691, 5358, 5976
29178, 2300, 2310, 2940, 6113
29179, 1387, 937, 342, 5528
29180, 2099, 226, 3645, 5883
29181, 91, 344, 3572, 1181
29182, 2902, 2914, 2903, 5815
29183, 3297, 3277, 3336, 5413
29184, 3790, 3791, 3792, 5260
29185, 308, 62, 3880, 3893
29186, 3274, 158, 2108, 3230
29187, 1208, 929, 708, 5781
29188, 5758, 5941, 4331, 6210
29189, 980, 979, 650, 5896
29190, 1318, 638, 1384, 6023
29191, 4334, 5888, 5061, 5922
29192, 3493, 3561, 3513, 5125
29193, 4363, 5445, 4983, 5521
29194, 2242, 2953, 2252, 5707
29195, 1224, 811, 964, 6046
29196, 1155, 1151, 1239, 6071
29197, 2763, 2795, 2599, 5706
29198, 2510, 2731, 3010, 4902
29199, 776, 1320, 1324, 5791
29200, 4900, 5365, 4206, 5797
29201, 4081, 5604, 5728, 6015
29202, 3805, 3807, 3855, 5773
29203, 599, 5492, 555, 6238
29204, 5271, 5784, 4081, 6134
29205, 3739, 3741, 3881, 5685
29206, 1391, 913, 912, 5843
29207, 3266, 3267, 3264, 5194
29208, 1223, 5865, 591, 6046
29209, 1243, 1052, 1054, 5617
29210, 3173, 3898, 3102, 5310
29211, 2269, 4862, 5640, 5833
29212, 1295, 343, 109, 3491
29213, 1099, 301, 48, 5632
29214, 4573, 5858, 5541, 6186
29215, 2133, 3690, 223, 5670
29216, 2971, 2864, 2538, 5255
29217, 3337, 3459, 3320, 5044
29218, 5384, 5546, 4212, 5930
29219, 4384, 5654, 5222, 6120
29220, 1057, 1062, 5784, 6134
29221, 4369, 5693, 4601, 5914
29222, 3605, 3609, 3661, 5310
29223, 3392, 3384, 3381, 6061
29224, 202, 3816, 3153, 6052
29225, 3048, 2405, 3043, 5221
29226, 3440, 3415, 3442, 5759
29227, 773, 1094, 1329, 5782
29228, 3698, 48, 3815, 5632
29229, 1320, 1248, 5292, 6110
29230, 339, 3538, 102, 5722
29231, 3590, 74, 926, 5563
29232, 652, 600, 1146, 5371
29233, 3308, 3458, 117, 893
29234, 3097, 3584, 3493, 5125
29235, 2719, 5651, 2622, 6154
29236, 4257, 6087, 5136, 6221
29237, 1071, 1254, 1008, 5520
29238, 34, 3718, 3835, 1393
29239, 439, 383, 1282, 5804
29240, 2649, 2941, 2942, 5661
29241, 2936, 5684, 3879, 5937
29242, 2312, 2314, 2313, 5075
29243, 4253, 6129, 4875, 6181
29244, 1006, 1007, 1265, 6009
29245, 2680, 2556, 2578, 5074
29246, 113, 3424, 322, 5562
29247, 5206, 5513, 4167, 5749
29248, 4167, 5969, 5709, 5981
29249, 2115, 2725, 230, 3644
29250, 4637, 5428, 4129, 6141
29251, 3244, 3243, 3241, 5934
29252, 3383, 3425, 3441, 6120
29253, 911, 5844, 901, 6127
29254, 3109, 2919, 2281, 5427
29255, 199, 3204, 3829, 3711
29256, 3838, 3833, 56, 1402
29257, 1412, 1253, 897, 5556
29258, 2354, 2356, 2357, 6105
29259, 1223, 591, 1224, 6046
29260, 3426, 3390, 3389, 6095
29261, 3387, 3389, 3385, 6095
29262, 3229, 3286, 3255, 5021
29263, 547, 549, 5865, 6031
29264, 2523, 2758, 2521, 5932
29265, 2544, 5056, 2674, 6233
29266, 301, 3815, 48, 5632
29267, 3159, 2150, 3102, 5310
29268, 949, 1241, 1246, 5399
29269, 2208, 2210, 2209, 5609
29270, 1297, 14, 342, 3231
29271, 3133, 5048, 3681, 6121
29272, 2257, 2269, 2971, 4862
29273, 4865, 5731, 4280, 5991
29274, 3394, 3393, 3395, 5054
29275, 2354, 2978, 2353, 6105
29276, 2388, 2796, 2595, 4970
29277, 1057, 1159, 1062, 6134
29278, 2870, 2938, 2420, 6028
29279, 3624, 5670, 4576, 6124
29280, 5249, 5977, 4243, 6083
29281, 3267, 3226, 3268, 5340
29282, 3714, 190, 3850, 5667
29283, 198, 3204, 3711, 5704
29284, 4341, 5458, 5001, 6004
29285, 517, 475, 473, 5805
29286, 3254, 3299, 3272, 5116
29287, 2771, 2770, 2769, 6087
29288, 3696, 208, 2921, 5665
29289, 988, 752, 1206, 5035
29290, 3353, 3355, 3354, 5770
29291, 1360, 1088, 905, 4897
29292, 4773, 5872, 4244, 5946
29293, 4215, 5636, 4670, 5880
29294, 1209, 1312, 1077, 4924
29295, 25, 1340, 341, 5588
29296, 1210, 417, 420, 5603
29297, 3334, 3449, 3468, 4942
29298, 2556, 2572, 2578, 5074
29299, 2305, 3018, 2787, 5262
29300, 3027, 2549, 3098, 5135
29301, 3014, 3018, 2285, 5691
29302, 3838, 3769, 3833, 4915
29303, 2897, 3714, 4962, 5667
29304, 2606, 2504, 2607, 5647
29305, 3877, 3812, 3843, 6048
29306, 549, 591, 547, 5865
29307, 4160, 5097, 5280, 5970
29308, 5105, 5430, 4228, 6055
29309, 4056, 5715, 5186, 5941
29310, 2693, 5491, 2563, 6165
29311, 3599, 3608, 3677, 5059
29312, 3771, 54, 930, 5286
29313, 2586, 5028, 2601, 5920
29314, 2668, 2667, 2669, 5297
29315, 5572, 6048, 4902, 6100
29316, 4922, 5836, 4282, 6160
29317, 2211, 2209, 2210, 6112
29318, 3429, 3377, 3445, 5843
29319, 4070, 4577, 5895, 6137
29320, 3568, 3510, 3564, 5577
29321, 946, 343, 1327, 5637
29322, 2631, 3040, 3039, 6083
29323, 4638, 5552, 4092, 5747
29324, 2828, 2826, 2843, 5521
29325, 3584, 3172, 3469, 5125
29326, 2315, 2318, 3036, 5774
29327, 3465, 265, 2694, 5524
29328, 2891, 2850, 2815, 5240
29329, 3701, 175, 2117, 2761
29330, 4705, 5906, 4117, 5996
29331, 3737, 3739, 3701, 5685
29332, 4141, 4927, 5503, 6020
29333, 1108, 791, 711, 5381
29334, 4129, 5406, 4639, 6141
29335, 113, 894, 3333, 5562
29336, 933, 915, 908, 4681
29337, 2828, 2974, 2832, 4983
29338, 4266, 5482, 4732, 6013
29339, 3714, 2897, 190, 5667
29340, 2440, 2377, 2375, 5428
29341, 4186, 5432, 4753, 6207
29342, 3672, 324, 72, 3652
29343, 3577, 2119, 3169, 5764
29344, 2612, 2585, 2584, 5397
29345, 3688, 3846, 3898, 5310
29346, 3284, 153, 3099, 3235
29347, 2295, 2303, 2765, 5775
29348, 3084, 2241, 2785, 5884
29349, 3569, 3522, 3551, 5567
29350, 3175, 3052, 3127, 4999
29351, 2261, 6069, 5855, 6206
29352, 2857, 2961, 2860, 5659
29353, 4017, 5538, 5022, 6014
29354, 2261, 5855, 2249, 6206
29355, 2444, 2407, 2450, 6057
29356, 3593, 3611, 3673, 4928
29357, 2622, 2890, 2534, 6154
29358, 109, 1295, 3491, 3563
29359, 1283, 443, 886, 5417
29360, 3502, 3501, 3503, 5263
29361, 198, 3818, 2139, 5704
29362, 2654, 2947, 2777, 6013
29363, 2927, 3042, 2304, 5566
29364, 3164, 2793, 5418, 5956
29365, 3661, 3846, 3688, 5310
29366, 2731, 3195, 3212, 6048
29367, 4302, 5726, 5084, 6093
29368, 948, 723, 727, 5268
29369, 1064, 1049, 1050, 5425
29370, 3209, 2125, 2635, 5987
29371, 3066, 2539, 3038, 5978
29372, 3128, 3000, 2423, 4998
29373, 2295, 2301, 2303, 5621
29374, 2656, 4815, 5467, 6214
29375, 632, 617, 616, 5358
29376, 3625, 3612, 3593, 6121
29377, 3060, 2929, 2414, 6128
29378, 2233, 2244, 2443, 5568
29379, 3105, 2917, 2930, 5252
29380, 2501, 5862, 2804, 6064
29381, 4206, 5365, 4900, 6132
29382, 1189, 962, 1307, 6060
29383, 924, 925, 331, 5919
29384, 2865, 2243, 2538, 5957
29385, 2568, 2570, 2569, 5602
29386, 1223, 4596, 5865, 6046
29387, 3132, 203, 2140, 3894
29388, 1334, 5758, 1322, 6210
29389, 4157, 4692, 5607, 6025
29390, 2530, 2321, 2531, 6173
29391, 366, 1133, 363, 5935
29392, 4654, 5699, 4102, 5815
29393, 1183, 755, 653, 5829
29394, 325, 118, 3458, 893
29395, 3499, 3502, 3480, 5426
29396, 4636, 5702, 4889, 5907
29397, 992, 1191, 1230, 5454
29398, 2120, 3293, 3222, 5375
29399, 4288, 5887, 5279, 6169
29400, 662, 664, 1303, 6076
29401, 2560, 5294, 2687, 6038
29402, 832, 330, 1341, 5623
29403, 3646, 3596, 3647, 5883
29404, 190, 2103, 3850, 5667
29405, 4291, 5430, 5105, 6055
29406, 2728, 3600, 3681, 5048
29407, 4897, 5650, 4454, 6152
29408, 2518, 5955, 4756, 6147
29409, 3305, 3440, 3437, 6127
29410, 3285, 5528, 3231, 6192
29411, 2913, 5585, 2912, 6092
29412, 3621, 5670, 3624, 6124
29413, 2595, 2867, 2940, 6036
29414, 3135, 2776, 2772, 5071
29415, 3204, 3183, 199, 3829
29416, 1381, 56, 3833, 1402
29417, 1124, 634, 636, 5606
29418, 3287, 316, 16, 1387
29419, 2434, 2493, 2418, 5788
29420, 3726, 3846, 3744, 5310
29421, 1178, 3566, 95, 6151
29422, 2107, 2681, 2674, 4890
29423, 3708, 2110, 205, 5937
29424, 1277, 1034, 1036, 5570
29425, 975, 1130, 524, 5460
29426, 4596, 5664, 4310, 6046
29427, 3621, 3622, 5734, 6124
29428, 3022, 2722, 2589, 6227
29429, 999, 1281, 997, 5536
29430, 2935, 2742, 2934, 5959
29431, 2679, 2995, 2577, 6164
29432, 827, 830, 337, 5286
29433, 1326, 621, 1198, 5027
29434, 2557, 2555, 2590, 5296
29435, 2724, 2115, 2723, 5199
29436, 514, 511, 1118, 5917
29437, 4019, 4984, 5698, 6032
29438, 764, 766, 1308, 5836
29439, 4411, 5513, 5206, 5924
29440, 4062, 5147, 4942, 6192
29441, 3169, 5078, 3482, 5764
29442, 2929, 2600, 3063, 6128
29443, 3761, 3696, 3747, 5665
29444, 3047, 2547, 2967, 5622
29445, 2402, 2454, 2948, 6012
29446, 764, 765, 766, 5836
29447, 3154, 3271, 3291, 5669
29448, 1178, 95, 309, 6151
29449, 1177, 4735, 5673, 6163
29450, 3832, 3837, 3775, 5079
29451, 372, 371, 373, 5342
29452, 4093, 4834, 5488, 6149
29453, 3355, 3356, 3357, 5770
29454, 2206, 2205, 2204, 5476
29455, 3175, 2939, 2658, 5457
29456, 3891, 3706, 3734, 5045
29457, 352, 881, 354, 6086
29458, 1389, 5746, 5171, 6217
29459, 3256, 23, 318, 1377
29460, 1331, 3672, 73, 926
29461, 385, 387, 386, 5584
29462, 3682, 1395, 84, 923
29463, 3191, 2122, 3207, 5665
29464, 2951, 2908, 2593, 5382
29465, 3074, 2887, 2878, 6146
29466, 1005, 1008, 1007, 5051
29467, 3829, 3869, 3868, 5057
29468, 314, 926, 74, 5563
29469, 4019, 5320, 5698, 5895
29470, 3823, 33, 315, 3718
29471, 706, 1128, 1303, 6076
29472, 4420, 5827, 4537, 5937
29473, 2119, 258, 3577, 3169
29474, 2167, 2249, 2166, 5855
29475, 3218, 5048, 3133, 6121
29476, 459, 460, 447, 6016
29477, 1417, 923, 833, 6150
29478, 2541, 2540, 2496, 5411
29479, 4852, 5273, 4335, 5986
29480, 365, 447, 1199, 5575
29481, 3594, 3653, 3642, 5421
29482, 4512, 5928, 5615, 6166
29483, 2651, 2524, 2522, 5013
29484, 3060, 2414, 2344, 6133
29485, 665, 717, 704, 6224
29486, 677, 1209, 592, 5295
29487, 2122, 208, 3883, 5665
29488, 2226, 5747, 2345, 5859
29489, 3271, 156, 3154, 3291
29490, 2732, 2101, 2667, 6123
29491, 315, 32, 3823, 959
29492, 3987, 5586, 4779, 5948
29493, 2970, 2798, 2380, 5362
29494, 2392, 2416, 2412, 5810
29495, 3043, 2406, 2751, 5129
29496, 3156, 2710, 3096, 5549
29497, 2110, 3708, 3132, 5937
29498, 3385, 3386, 3387, 4906
29499, 876, 725, 948, 5364
29500, 1374, 1200, 4768, 6236
29501, 4682, 5721, 4080, 6198
29502, 3225, 341, 24, 3290
29503, 1035, 5570, 1034, 6065
29504, 861, 318, 1377, 5237
29505, 2913, 2912, 3098, 6092
29506, 908, 1354, 1294, 5565
29507, 2560, 2687, 2686, 6038
29508, 2911, 2913, 2974, 5857
29509, 2726, 2727, 3208, 6077
29510, 484, 608, 482, 6171
29511, 4070, 5320, 5047, 5895
29512, 3118, 2126, 218, 3673
29513, 4099, 5813, 4903, 6185
29514, 3692, 3844, 3756, 5818
29515, 298, 3558, 100, 6045
29516, 3577, 3169, 3482, 5764
29517, 5457, 5943, 4247, 6091
29518, 265, 2124, 2694, 5524
29519, 3528, 3546, 3483, 5308
29520, 4950, 5695, 2943, 6235
29521, 1173, 608, 1179, 6171
29522, 3065, 2232, 2211, 6112
29523, 3122, 2578, 3126, 5627
29524, 3504, 3505, 3506, 5077
29525, 2600, 3060, 3054, 6128
29526, 3461, 3354, 3424, 5562
29527, 2871, 2608, 2872, 5558
29528, 398, 1109, 396, 5506
29529, 4619, 5585, 4086, 6092
29530, 3589, 2725, 3197, 5712
29531, 3091, 2247, 2175, 6022
29532, 2779, 5267, 2592, 6155
29533, 2430, 2978, 2357, 6105
29534, 2969, 2625, 2496, 5189
29535, 3048, 2743, 2405, 5221
29536, 530, 1159, 1143, 6134
29537, 2231, 2233, 2230, 5184
29538, 2465, 2546, 2463, 6129
29539, 3890, 3760, 3879, 5684
29540, 3197, 3589, 231, 2725
29541, 3425, 5814, 4900, 6120
29542, 4917, 5754, 4235, 5832
29543, 660, 659, 658, 6042
29544, 3463, 3314, 140, 5392
29545, 361, 362, 363, 5935
29546, 754, 770, 655, 6131
29547, 158, 2687, 2108, 3230
29548, 2792, 2771, 2774, 5418
29549, 308, 1134, 1162, 5043
29550, 3608, 3607, 4846, 6183
29551, 2888, 3114, 2877, 5929
29552, 925, 1325, 1373, 5304
29553, 4083, 5638, 4861, 6194
29554, 2741, 3110, 2306, 5175
29555, 4075, 4750, 5930, 6034
29556, 2999, 2987, 5854, 6054
29557, 4685, 5903, 4143, 5973
29558, 4338, 5510, 5442, 5802
29559, 4779, 5586, 4286, 5948
29560, 777, 1002, 699, 5908
29561, 482, 1173, 464, 6171
29562, 820, 732, 1088, 5650
29563, 140, 3314, 321, 5392
29564, 2541, 2625, 2635, 4762
29565, 2114, 3411, 3149, 5336
29566, 4235, 5832, 4618, 5959
29567, 2716, 2130, 2717, 5266
29568, 501, 499, 493, 5317
29569, 3605, 3688, 2150, 5310
29570, 2616, 2615, 2614, 5474
29571, 4977, 5285, 4564, 6163
29572, 1164, 298, 100, 6045
29573, 3596, 3645, 226, 5883
29574, 2761, 2762, 2651, 5685
29575, 2174, 2175, 2173, 6022
29576, 4592, 5994, 4192, 6179
29577, 4287, 5772, 4686, 5890
29578, 415, 414, 416, 5525
29579, 4026, 4785, 5438, 6132
29580, 4297, 6003, 4767, 6023
29581, 3091, 5316, 3092, 5893
29582, 4326, 5813, 5329, 6185
29583, 434, 1265, 1262, 6009
29584, 936, 316, 884, 5340
29585, 3600, 220, 2728, 3681
29586, 353, 5392, 321, 6086
29587, 3292, 3248, 3249, 5453
29588, 2741, 2306, 2934, 5959
29589, 3248, 3292, 3275, 4831
29590, 3575, 3514, 3512, 4976
29591, 3991, 5726, 5084, 5885
29592, 493, 963, 501, 5317
29593, 3550, 3526, 3547, 4890
29594, 4238, 5425, 4816, 6169
29595, 328, 933, 130, 6116
29596, 364, 362, 995, 4967
29597, 4213, 5123, 5866, 5891
29598, 2140, 3707, 202, 6052
29599, 4647, 5594, 4142, 6060
29600, 902, 916, 300, 5759
29601, 1025, 1031, 1288, 5573
29602, 190, 2897, 2103, 5667
29603, 2999, 2596, 3007, 5854
29604, 3062, 2209, 2232, 6112
29605, 4816, 5425, 4288, 6169
29606, 533, 520, 534, 5124
29607, 2914, 2221, 2222, 5514
29608, 1115, 1116, 1303, 6070
29609, 3608, 4846, 3603, 6209
29610, 682, 1149, 527, 5964
29611, 2589, 2722, 2550, 5416
29612, 3074, 2878, 5965, 6146
29613, 3102, 3898, 3726, 5310
29614, 2846, 2448, 2845, 5681
29615, 1272, 1359, 1078, 5597
29616, 3746, 3726, 3744, 5613
29617, 3207, 2937, 2610, 5684
29618, 3324, 325, 118, 3458
29619, 1151, 1155, 435, 6071
29620, 3542, 3587, 3501, 5263
29621, 3732, 3706, 3885, 5656
29622, 2812, 2811, 2813, 5846
29623, 4157, 5570, 6025, 6065
29624, 501, 963, 1213, 5961
29625, 2405, 2743, 3053, 5990
29626, 3164, 2793, 2774, 5418
29627, 5000, 5093, 4343, 6211
29628, 4344, 5453, 5407, 6170
29629, 2535, 2534, 2598, 5999
29630, 2810, 2807, 2809, 5183
29631, 3097, 3211, 2149, 5125
29632, 3696, 3883, 208, 5665
29633, 4128, 4650, 5728, 6195
29634, 2534, 2890, 2598, 5798
29635, 2430, 2357, 2401, 5996
29636, 5513, 5749, 5206, 5924
29637, 379, 1284, 381, 5894
29638, 1389, 320, 1119, 5746
29639, 2962, 2423, 2302, 5618
29640, 4137, 5031, 5881, 6148
29641, 610, 5677, 5024, 5976
29642, 2830, 2836, 2835, 5312
29643, 2681, 2674, 4890, 6233
29644, 336, 1322, 1334, 5758
29645, 569, 567, 568, 5181
29646, 392, 390, 391, 5946
29647, 871, 873, 769, 5477
29648, 2107, 3180, 2681, 4890
29649, 1278, 1034, 1277, 5779
29650, 2917, 2918, 2685, 5942
29651, 3999, 4709, 6059, 6223
29652, 1087, 1129, 529, 6126
29653, 3666, 3654, 3676, 5638
29654, 2196, 2912, 2198, 5901
29655, 4112, 5330, 5037, 5762
29656, 3465, 3321, 265, 5524
29657, 4130, 5787, 5540, 6191
29658, 2133, 223, 3101, 5670
29659, 2553, 2582, 2554, 5377
29660, 3616, 3614, 3660, 5133
29661, 4088, 5061, 5773, 5922
29662, 586, 1118, 509, 6026
29663, 2140, 202, 3153, 6052
29664, 1175, 1274, 506, 5892
29665, 3690, 3592, 223, 5670
29666, 1019, 1018, 1017, 5701
29667, 2164, 2753, 2162, 5928
29668, 828, 831, 830, 4858
29669, 4897, 5569, 4049, 5714
29670, 328, 130, 3446, 6116
29671, 4562, 6091, 4502, 6204
29672, 371, 445, 373, 5342
29673, 3003, 5242, 5619, 6056
29674, 4902, 6048, 2731, 6100
29675, 567, 5181, 569, 6175
29676, 3305, 3437, 3416, 6127
29677, 2468, 2508, 2991, 5433
29678, 67, 3709, 3847, 5571
29679, 762, 763, 705, 5203
29680, 610, 616, 5677, 5976
29681, 3213, 3096, 2712, 5984
29682, 4688, 5902, 3960, 5986
29683, 3710, 3865, 3817, 6123
29684, 2763, 3112, 2618, 6144
29685, 3099, 2144, 153, 3284
29686, 3589, 232, 3657, 5987
29687, 628, 599, 555, 6238
29688, 4030, 5619, 5242, 6056
29689, 2560, 2558, 3121, 5294
29690, 429, 431, 432, 5182
29691, 553, 554, 1093, 5440
29692, 51, 3830, 927, 6040
29693, 883, 1116, 1115, 6070
29694, 2501, 2517, 2804, 5862
29695, 342, 15, 1387, 3231
29696, 3939, 4738, 6172, 6211
29697, 2994, 2401, 2399, 5191
29698, 4735, 5673, 6163, 6208
29699, 2672, 3124, 2745, 5668
29700, 3590, 3668, 74, 5563
29701, 3590, 926, 3672, 5383
29702, 4592, 4978, 5994, 6179
29703, 1362, 656, 1374, 5539
29704, 2316, 2920, 2313, 5678
29705, 674, 673, 675, 5355
29706, 4026, 5916, 4785, 6132
29707, 423, 1042, 415, 5462
29708, 95, 3566, 3479, 6151
29709, 353, 354, 355, 6086
29710, 4180, 5277, 5210, 6099
29711, 2806, 2446, 2807, 5960
29712, 1128, 1307, 1117, 5594
29713, 2822, 2824, 2823, 5980
29714, 4718, 5849, 5471, 6215
29715, 3082, 3083, 2241, 5107
29716, 1368, 804, 807, 5257
29717, 2975, 2410, 5721, 6198
29718, 3641, 5430, 3670, 5987
29719, 3813, 3836, 3799, 5711
29720, 2454, 2499, 2500, 5915
29721, 4367, 5501, 5066, 6111
29722, 2859, 2961, 5659, 6195
29723, 4122, 5328, 5841, 6166
29724, 3854, 3700, 178, 3195
29725, 2434, 2418, 2419, 5788
29726, 1037, 1039, 1040, 6025
29727, 860, 875, 726, 5149
29728, 759, 918, 936, 5614
29729, 4122, 5841, 5138, 6166
29730, 4070, 5047, 5279, 6137
29731, 3154, 5669, 2686, 6038
29732, 821, 5569, 917, 5989
29733, 4822, 5541, 4153, 5858
29734, 3592, 3624, 3621, 5670
29735, 2287, 3014, 2285, 5691
29736, 2882, 3161, 2881, 5904
29737, 2171, 2173, 3087, 5230
29738, 2170, 2172, 2171, 5800
29739, 1178, 5666, 3566, 6151
29740, 3092, 3091, 2177, 5316
29741, 3727, 3730, 3732, 5656
29742, 944, 772, 947, 5458
29743, 3455, 3408, 3359, 5839
29744, 1397, 897, 1253, 5556
29745, 931, 5365, 761, 6224
29746, 375, 1290, 5612, 6122
29747, 1188, 416, 414, 5525
29748, 4173, 5288, 5249, 6135
29749, 2815, 2850, 3073, 5240
29750, 5358, 5677, 616, 5976
29751, 3753, 3751, 3752, 5582
29752, 2532, 2535, 2968, 5999
29753, 1135, 63, 3695, 3880
29754, 4942, 5528, 4062, 6192
29755, 5084, 5726, 4302, 5885
29756, 322, 895, 894, 5562
29757, 4060, 5498, 5306, 5847
29758, 353, 4993, 5392, 6086
29759, 3515, 3516, 3482, 5078
29760, 4194, 5304, 5899, 5952
29761, 3629, 3628, 3595, 6159
29762, 4044, 5501, 5282, 6097
29763, 3321, 2124, 265, 5524
29764, 3017, 2341, 2339, 5817
29765, 2381, 2379, 2456, 6222
29766, 3545, 6004, 3489, 6103
29767, 2243, 2240, 2242, 5088
29768, 3197, 2635, 2125, 5987
29769, 1358, 1068, 821, 5989
29770, 4136, 4691, 5519, 6200
29771, 1229, 1021, 1027, 5789
29772, 1346, 925, 1373, 5919
29773, 3243, 3245, 3246, 4830
29774, 2616, 2617, 2615, 5474
29775, 3717, 3827, 3804, 5451
29776, 3282, 3272, 3289, 5116
29777, 4128, 5957, 5737, 6195
29778, 5347, 5913, 4055, 5994
29779, 3323, 3367, 3368, 5016
29780, 4128, 5737, 4650, 6195
29781, 421, 419, 416, 5709
29782, 4413, 5723, 5941, 6210
29783, 1119, 1369, 1389, 5171
29784, 668, 625, 623, 5870
29785, 1081, 5228, 1082, 6003
29786, 4982, 5678, 4089, 6173
29787, 2406, 3039, 3040, 5977
29788, 2280, 2932, 2326, 5660
29789, 2445, 2542, 2548, 5509
29790, 2246, 2255, 2254, 5517
29791, 519, 1066, 520, 5840
29792, 356, 1266, 358, 5697
29793, 2664, 2983, 2146, 5639
29794, 2360, 2361, 2362, 5756
29795, 3235, 3297, 3177, 5413
29796, 812, 1364, 810, 5058
29797, 5217, 5973, 4143, 6171
29798, 3807, 3809, 3811, 5888
29799, 4659, 5969, 4167, 5981
29800, 920, 446, 5496, 6196
29801, 375, 1290, 377, 5612
29802, 1225, 747, 746, 5634
29803, 3482, 3577, 258, 3169
29804, 751, 752, 780, 5564
29805, 2769, 2770, 2135, 5136
29806, 2226, 2345, 2223, 5859
29807, 3314, 3344, 3341, 5392
29808, 3844, 3878, 3758, 6216
29809, 3180, 2681, 4890, 6177
29810, 3388, 3319, 3385, 5176
29811, 2631, 3039, 3037, 5249
29812, 3471, 3329, 3462, 5958
29813, 2963, 2374, 2376, 5406
29814, 3648, 3659, 3646, 6194
29815, 1268, 1264, 1153, 5693
29816, 1065, 793, 1138, 5289
29817, 2861, 2863, 2859, 5737
29818, 2836, 3080, 3079, 5469
29819, 3853, 3719, 3862, 6146
29820, 4319, 5590, 5546, 5796
29821, 991, 1362, 972, 5539
29822, 3621, 3623, 3622, 6124
29823, 878, 1287, 445, 5305
29824, 2115, 2724, 3178, 5199
29825, 3134, 2706, 2874, 4934
29826, 2132, 3201, 2723, 4929
29827, 3008, 2342, 2597, 5795
29828, 3152, 3061, 3147, 5811
29829, 3536, 3557, 3535, 5291
29830, 3681, 5048, 3625, 6121
29831, 956, 501, 1213, 5961
29832, 2622, 3162, 2890, 6154
29833, 2725, 3589, 231, 3644
29834, 3205, 2881, 2469, 5579
29835, 2831, 3090, 2827, 5751
29836, 3551, 3575, 3491, 5637
29837, 2948, 2303, 2301, 5621
29838, 3668, 314, 74, 5563
29839, 3080, 2421, 3079, 5469
29840, 3401, 3398, 3428, 5776
29841, 113, 3333, 3424, 5562
29842, 2850, 2891, 2958, 5868
29843, 2254, 2255, 2259, 5517
29844, 809, 952, 790, 5204
29845, 3162, 2622, 5651, 6154
29846, 2762, 3106, 2526, 5879
29847, 3491, 3575, 3512, 5637
29848, 95, 3479, 309, 6151
29849, 2791, 2768, 2112, 5331
29850, 866, 867, 865, 5360
29851, 2101, 2729, 2669, 5620
29852, 3750, 3751, 3749, 5400
29853, 2311, 2310, 2309, 5387
29854, 4338, 5958, 4593, 6164
29855, 3163, 2749, 256, 3474
29856, 3293, 3222, 162, 2120
29857, 3339, 3337, 3338, 4820
29858, 2718, 2128, 2719, 5651
29859, 880, 1406, 5638, 5899
29860, 414, 413, 412, 5157
29861, 920, 1220, 787, 5496
29862, 2863, 2859, 5737, 6195
29863, 1237, 1238, 829, 5424
29864, 4535, 5941, 5723, 6210
29865, 3866, 3865, 3710, 6123
29866, 4091, 5246, 5302, 6161
29867, 3866, 3867, 3840, 5897
29868, 5422, 5600, 4131, 6006
29869, 774, 1124, 5606, 6213
29870, 556, 549, 548, 6031
29871, 722, 960, 849, 6231
29872, 5404, 5457, 4356, 5943
29873, 969, 972, 971, 5196
29874, 2633, 3040, 2630, 6083
29875, 3112, 6117, 4884, 6144
29876, 3165, 2665, 2664, 5639
29877, 3644, 2725, 3589, 5712
29878, 794, 1197, 1205, 5373
29879, 51, 3716, 3830, 6040
29880, 2981, 2907, 2410, 6198
29881, 3887, 3748, 3745, 5062
29882, 436, 1271, 1270, 5103
29883, 2913, 2911, 2912, 5585
29884, 3358, 3359, 3464, 4905
29885, 2936, 205, 2110, 5937
29886, 297, 1323, 880, 5638
29887, 17, 316, 3287, 1352
29888, 2392, 2412, 2411, 5810
29889, 3247, 3251, 3249, 4944
29890, 3133, 3681, 219, 6121
29891, 1049, 620, 1050, 5425
29892, 974, 1086, 1312, 5461
29893, 2268, 2267, 2976, 5822
29894, 664, 666, 706, 6076
29895, 1300, 3895, 1371, 6183
29896, 3665, 3666, 3648, 6194
29897, 3666, 3676, 3659, 6194
29898, 2138, 5114, 3712, 6039
29899, 3222, 3250, 3246, 5375
29900, 3785, 3787, 3788, 5550
29901, 3149, 2114, 267, 3411
29902, 710, 659, 707, 5900
29903, 731, 1136, 729, 5850
29904, 3759, 3892, 3707, 5583
29905, 408, 1016, 406, 5277
29906, 5252, 5671, 4402, 5940
29907, 2741, 2568, 3110, 5755
29908, 3281, 19, 306, 3223
29909, 484, 482, 483, 5217
29910, 2169, 2170, 2171, 5800
29911, 2830, 2825, 2829, 5626
29912, 3590, 3615, 3616, 5383
29913, 3128, 3126, 2578, 5627
29914, 1336, 1419, 1094, 5595
29915, 891, 5365, 304, 5797
29916, 3966, 5674, 4969, 6191
29917, 3240, 3300, 3283, 5780
29918, 3580, 3628, 215, 3686
29919, 2626, 5437, 3216, 5862
29920, 3738, 3736, 3737, 5166
29921, 3540, 3539, 3484, 5261
29922, 1185, 671, 637, 5156
29923, 2645, 3218, 3158, 6121
29924, 3368, 3383, 3371, 6120
29925, 333, 1120, 968, 5451
29926, 3597, 3656, 3649, 4929
29927, 5218, 5353, 4048, 5719
29928, 2789, 2570, 2742, 5225
29929, 2765, 2294, 2295, 5775
29930, 2269, 2270, 2271, 5640
29931, 2099, 3125, 226, 5883
29932, 1230, 1239, 802, 6021
29933, 3783, 3781, 3851, 5186
29934, 1074, 1086, 307, 5711
29935, 2292, 2299, 2331, 5785
29936, 2732, 2667, 2632, 6123
29937, 2894, 2950, 2984, 5587
29938, 3189, 2118, 155, 3291
29939, 62, 308, 3880, 1134
29940, 1150, 521, 522, 6225
29941, 509, 507, 508, 5369
29942, 4137, 6058, 5031, 6148
29943, 5136, 6087, 4439, 6221
29944, 2738, 2686, 2118, 5669
29945, 25, 3225, 3283, 5588
29946, 4192, 5994, 5347, 6179
29947, 4036, 5677, 5358, 5976
29948, 3273, 1244, 20, 5495
29949, 3006, 2345, 2226, 5747
29950, 1413, 809, 824, 5666
29951, 3252, 3278, 3254, 5531
29952, 3897, 346, 28, 1386
29953, 2647, 3133, 3218, 5048
29954, 2902, 2903, 2442, 5699
29955, 2264, 2253, 2263, 5346
29956, 897, 1397, 1327, 5556
29957, 2636, 2582, 2553, 5377
29958, 2780, 3069, 3167, 5527
29959, 1361, 3489, 6004, 6103
29960, 232, 2125, 3657, 5987
29961, 2775, 2776, 2888, 5929
29962, 567, 565, 566, 5757
29963, 815, 828, 827, 5852
29964, 3590, 73, 3672, 926
29965, 582, 581, 580, 5380
29966, 2319, 2960, 2944, 5742
29967, 545, 546, 547, 5130
29968, 1299, 1346, 857, 5337
29969, 763, 785, 962, 6160
29970, 16, 3287, 1387, 3270
29971, 2514, 2513, 2515, 5975
29972, 2918, 3105, 2464, 5671
29973, 3770, 3768, 3769, 5447
29974, 959, 960, 332, 5045
29975, 741, 743, 742, 5500
29976, 740, 1177, 614, 5673
29977, 3141, 2140, 2666, 6052
29978, 884, 316, 1352, 5340
29979, 2631, 2617, 2630, 6083
29980, 2614, 2612, 3166, 6074
29981, 4038, 4949, 5760, 6085
29982, 2766, 2613, 3026, 5630
29983, 694, 823, 1167, 5338
29984, 539, 544, 545, 5738
29985, 3115, 2700, 2581, 5134
29986, 570, 568, 646, 5645
29987, 2499, 3002, 2621, 5464
29988, 3749, 3751, 3849, 5400
29989, 3763, 3765, 3762, 5233
29990, 3101, 223, 3592, 5670
29991, 422, 5969, 1100, 5981
29992, 3075, 2238, 2849, 5497
29993, 3257, 3302, 3279, 4942
29994, 352, 353, 321, 6086
29995, 2999, 2931, 2987, 6054
29996, 3735, 3733, 3740, 5284
29997, 3157, 2890, 2097, 5798
29998, 759, 757, 950, 5772
29999, 4074, 5641, 5409, 5936
30000, 2770, 2772, 2775, 6087
30001, 918, 882, 936, 5614
30002, 4198, 5790, 5035, 6226
30003, 2206, 2204, 2894, 5476
30004, 1300, 3847, 3895, 6183
30005, 2682, 2986, 2562, 5535
30006, 259, 3573, 3169, 2145
30007, 3687, 3640, 3656, 5971
30008, 3679, 3643, 5178, 5971
30009, 3279, 3296, 3257, 4942
30010, 3603, 3608, 3607, 4846
30011, 3811, 3877, 3854, 5331
30012, 1177, 5673, 1202, 6163
30013, 3410, 3324, 3458, 5653
30014, 4423, 5945, 5665, 6081
30015, 596, 1215, 539, 5160
30016, 3466, 3297, 147, 3336
30017, 914, 915, 328, 6116
30018, 3307, 3433, 3417, 5646
30019, 4351, 5965, 4615, 6146
30020, 3387, 3440, 3426, 6095
30021, 305, 1305, 872, 6103
30022, 823, 1214, 1167, 5338
30023, 3640, 3639, 3638, 6108
30024, 3685, 167, 3607, 3895
30025, 3004, 2549, 2542, 6186
30026, 399, 1269, 401, 5232
30027, 1381, 835, 1402, 4915
30028, 3084, 2785, 2784, 6140
30029, 2779, 2756, 2592, 5267
30030, 3594, 3642, 3674, 5421
30031, 4447, 5673, 4735, 6208
30032, 698, 720, 1208, 5781
30033, 1202, 747, 1293, 5285
30034, 616, 1072, 691, 5976
30035, 3510, 3509, 3508, 5111
30036, 2719, 3162, 2622, 5651
30037, 3133, 219, 2126, 6121
30038, 464, 481, 482, 5973
30039, 5465, 5652, 4087, 5925
30040, 2367, 2368, 2366, 6178
30041, 4110, 4730, 5873, 6235
30042, 367, 687, 369, 5864
30043, 3760, 5827, 3757, 5937
30044, 594, 602, 1333, 5091
30045, 3828, 3714, 3859, 4962
30046, 1405, 1389, 836, 6217
30047, 3593, 218, 2126, 3673
30048, 3003, 5619, 2910, 6056
30049, 2416, 2417, 2412, 6207
30050, 4112, 5775, 5036, 6174
30051, 2269, 2271, 2332, 5833
30052, 5453, 5531, 4344, 5875
30053, 753, 1287, 754, 6131
30054, 943, 5723, 1334, 6210
30055, 1202, 5673, 5285, 6163
30056, 3469, 262, 2149, 3172
30057, 1257, 1404, 826, 6213
30058, 2390, 2389, 2433, 5487
30059, 3031, 2824, 2833, 5052
30060, 4102, 5749, 5513, 5924
30061, 3086, 3084, 2784, 6140
30062, 3325, 3149, 3411, 5336
30063, 3382, 3328, 3381, 5368
30064, 3151, 2869, 5679, 5801
30065, 1268, 1243, 1054, 5914
30066, 3225, 25, 341, 5588
30067, 1142, 517, 473, 5805
30068, 790, 977, 714, 5686
30069, 4225, 5225, 5832, 5959
30070, 2481, 3044, 2413, 5356
30071, 3610, 3677, 3608, 6209
30072, 3290, 3256, 3244, 5237
30073, 3581, 236, 3467, 3348
30074, 4471, 6153, 5198, 6167
30075, 472, 474, 476, 5501
30076, 3651, 3682, 84, 923
30077, 3099, 3235, 3177, 5413
30078, 2456, 2882, 2881, 5904
30079, 2574, 2491, 2573, 6088
30080, 4039, 5526, 4929, 5920
30081, 3837, 3834, 3783, 5715
30082, 3585, 3549, 3567, 6004
30083, 3953, 5119, 5887, 6169
30084, 850, 848, 846, 5881
30085, 1012, 1013, 645, 5144
30086, 4048, 5655, 5607, 6158
30087, 3277, 147, 3297, 3336
30088, 2844, 2225, 2217, 5951
30089, 3842, 3738, 3812, 5572
30090, 2265, 2282, 2327, 5148
30091, 3621, 3619, 3620, 5734
30092, 2920, 2530, 2968, 6205
30093, 1130, 478, 524, 5460
30094, 2785, 3083, 2786, 5490
30095, 312, 1347, 116, 5339
30096, 1111, 1172, 1030, 5333
30097, 3691, 5712, 3589, 5987
30098, 656, 601, 651, 6236
30099, 2221, 2219, 2222, 5514
30100, 2160, 2159, 2161, 5287
30101, 4128, 5255, 5957, 6195
30102, 1203, 932, 709, 5750
30103, 3036, 2318, 2833, 5774
30104, 2245, 2181, 3086, 6090
30105, 4088, 5773, 5197, 6221
30106, 460, 492, 493, 5167
30107, 715, 699, 1002, 5908
30108, 3742, 3743, 3724, 4846
30109, 3573, 3482, 259, 3169
30110, 2512, 2982, 3009, 5705
30111, 803, 899, 1355, 5131
30112, 2243, 2242, 2250, 6168
30113, 2350, 2349, 2351, 5740
30114, 4703, 5877, 4181, 6112
30115, 2340, 2923, 2320, 5456
30116, 2412, 2417, 2418, 6207
30117, 177, 3700, 3212, 3195
30118, 443, 377, 1290, 5612
30119, 1071, 1064, 1254, 5520
30120, 2692, 3203, 2131, 5995
30121, 609, 589, 1067, 6229
30122, 5171, 5746, 4069, 6217
30123, 2241, 3084, 2185, 5884
30124, 2826, 2828, 2827, 5521
30125, 5171, 4069, 6027, 6217
30126, 3849, 3751, 3753, 5582
30127, 5404, 5943, 3948, 6058
30128, 2862, 2866, 3056, 5729
30129, 3166, 2098, 2637, 6074
30130, 3820, 3700, 3843, 6048
30131, 1228, 702, 938, 5311
30132, 860, 5588, 1340, 5780
30133, 1284, 1283, 982, 6104
30134, 4950, 5873, 5695, 6235
30135, 1320, 687, 1248, 6110
30136, 582, 584, 583, 6051
30137, 3095, 2913, 3098, 6092
30138, 3709, 3887, 3743, 5571
30139, 2294, 2328, 2261, 6069
30140, 2230, 2957, 2237, 6001
30141, 2351, 2349, 2393, 5740
30142, 4077, 5354, 5896, 6051
30143, 2136, 2876, 2877, 5727
30144, 3299, 3269, 3272, 5998
30145, 973, 1086, 974, 5461
30146, 2867, 2498, 2433, 5601
30147, 785, 1123, 1122, 6072
30148, 2859, 2961, 2857, 5659
30149, 3895, 3607, 3685, 6183
30150, 4254, 4819, 6106, 6216
30151, 3494, 3628, 215, 3580
30152, 3075, 2849, 2848, 5497
30153, 2150, 216, 3173, 3688
30154, 560, 558, 1009, 5644
30155, 5487, 5601, 4040, 6036
30156, 2451, 2552, 2998, 5551
30157, 2932, 2777, 2326, 5660
30158, 3897, 148, 3845, 3298
30159, 176, 3212, 3820, 6100
30160, 2787, 2543, 3024, 5955
30161, 3847, 1300, 5571, 6183
30162, 3701, 176, 3820, 6100
30163, 5116, 5294, 4236, 6038
30164, 4036, 5024, 5677, 5976
30165, 1100, 1101, 1112, 5981
30166, 5665, 5945, 4479, 6081
30167, 3692, 3893, 1330, 5818
30168, 3129, 2145, 2748, 5078
30169, 1131, 742, 872, 5503
30170, 851, 848, 850, 5881
30171, 290, 2736, 2737, 5958
30172, 2261, 2166, 2249, 5855
30173, 378, 1117, 376, 5185
30174, 3041, 2957, 2443, 5692
30175, 2748, 5078, 3169, 5764
30176, 811, 812, 810, 5058
30177, 3693, 337, 54, 5286
30178, 15, 1387, 3231, 3270
30179, 1368, 318, 1309, 6043
30180, 4688, 5361, 5902, 5986
30181, 3811, 3854, 3876, 5331
30182, 2462, 2460, 2461, 5247
30183, 2681, 2141, 3108, 6177
30184, 3032, 2794, 2604, 5238
30185, 2646, 2648, 2647, 5026
30186, 4033, 5766, 4943, 6182
30187, 3596, 226, 3125, 5883
30188, 3113, 2110, 3132, 5937
30189, 3317, 3450, 3350, 5385
30190, 3898, 3173, 3688, 5310
30191, 3602, 3684, 3622, 5337
30192, 2138, 3124, 3088, 5114
30193, 1392, 1388, 863, 5117
30194, 2226, 2223, 2224, 5859
30195, 900, 911, 901, 6127
30196, 2458, 2453, 2403, 6176
30197, 3037, 2359, 2351, 5853
30198, 3763, 3767, 3766, 6082
30199, 4096, 5566, 5467, 6214
30200, 1375, 350, 143, 3468
30201, 4733, 5904, 4303, 6222
30202, 2212, 2211, 2210, 5877
30203, 3273, 20, 3223, 5495
30204, 2201, 2203, 3071, 5648
30205, 1286, 3716, 51, 6040
30206, 3758, 3878, 3892, 6216
30207, 290, 2737, 3329, 5958
30208, 820, 731, 732, 4869
30209, 1148, 1182, 1041, 5265
30210, 3364, 3367, 3362, 5814
30211, 4034, 5409, 5641, 5936
30212, 1215, 540, 537, 5790
30213, 3325, 3149, 267, 3411
30214, 582, 583, 581, 5380
30215, 3436, 3432, 3422, 5714
30216, 4401, 5728, 5659, 6195
30217, 1161, 1043, 1001, 5923
30218, 1207, 1152, 1180, 5244
30219, 2228, 2911, 2974, 5857
30220, 994, 797, 733, 5576
30221, 4247, 5457, 5404, 5943
30222, 4003, 5206, 5749, 5924
30223, 4192, 5913, 5347, 5994
30224, 4247, 5943, 5404, 6058
30225, 490, 1087, 529, 5259
30226, 5123, 4012, 5891, 6166
30227, 2507, 2468, 2991, 5433
30228, 2331, 2389, 2390, 5487
30229, 3169, 2748, 2145, 5078
30230, 4756, 5955, 4275, 6147
30231, 2802, 2801, 3081, 5778
30232, 2612, 2613, 2585, 5397
30233, 3645, 2099, 5883, 6077
30234, 3155, 3112, 2127, 6144
30235, 2590, 3091, 3092, 5893
30236, 446, 1218, 1302, 6196
30237, 2396, 3135, 2404, 5851
30238, 2682, 2634, 3125, 5883
30239, 3033, 2290, 2415, 5991
30240, 3089, 2590, 2555, 5296
30241, 843, 845, 844, 5939
30242, 509, 508, 586, 6026
30243, 3401, 3399, 3397, 5921
30244, 4015, 5070, 5970, 6029
30245, 3296, 3468, 144, 3449
30246, 4278, 5940, 5258, 6107
30247, 900, 327, 911, 6127
30248, 3106, 3057, 2677, 5321
30249, 932, 757, 709, 5750
30250, 116, 3308, 312, 5339
30251, 1132, 368, 504, 5212
30252, 2813, 2811, 2362, 5846
30253, 425, 1100, 422, 5969
30254, 406, 405, 407, 5210
30255, 317, 107, 1367, 5567
30256, 1400, 860, 1340, 5780
30257, 718, 1017, 1016, 5809
30258, 2174, 2924, 2176, 5335
30259, 3281, 306, 19, 885
30260, 465, 466, 1174, 5446
30261, 3349, 3317, 3350, 5385
30262, 1376, 5421, 313, 6150
30263, 473, 474, 472, 5501
30264, 2452, 2384, 2781, 5378
30265, 2785, 2786, 2783, 5490
30266, 2361, 2363, 2362, 5756
30267, 2563, 2693, 2733, 5491
30268, 474, 475, 1187, 6097
30269, 3315, 3443, 3419, 5141
30270, 3245, 3247, 3246, 5869
30271, 3139, 2467, 4875, 6129
30272, 4110, 5873, 4950, 6235
30273, 693, 1162, 808, 4806
30274, 1399, 1341, 330, 5623
30275, 3241, 3240, 3225, 5588
30276, 2313, 2315, 2316, 5678
30277, 4073, 5022, 5538, 6014
30278, 1033, 1035, 1034, 6065
30279, 3204, 198, 2139, 5704
30280, 2586, 2601, 2602, 5920
30281, 3689, 88, 349, 1372
30282, 2779, 2592, 2516, 6155
30283, 4128, 5728, 5604, 6015
30284, 1375, 1297, 350, 4942
30285, 1147, 444, 453, 5307
30286, 733, 730, 1166, 5710
30287, 436, 1273, 1047, 6067
30288, 3347, 3472, 3453, 5442
30289, 3757, 3754, 3756, 5827
30290, 4070, 5895, 5047, 6137
30291, 3093, 2397, 2404, 5087
30292, 3843, 5572, 3889, 6100
30293, 2291, 2287, 2289, 5616
30294, 1376, 313, 923, 6150
30295, 542, 541, 611, 5658
30296, 5309, 5724, 4177, 6143
30297, 432, 640, 429, 6145
30298, 4046, 5768, 5617, 5914
30299, 107, 3551, 1367, 5567
30300, 2515, 2910, 3003, 5619
30301, 1000, 1276, 437, 5794
30302, 3372, 3379, 3316, 5266
30303, 1149, 682, 791, 5964
30304, 5695, 5873, 4730, 6235
30305, 3226, 17, 3287, 1352
30306, 800, 978, 799, 5002
30307, 4143, 5973, 5903, 6171
30308, 433, 1298, 392, 5872
30309, 666, 705, 1189, 5733
30310, 2669, 2670, 2668, 5297
30311, 3276, 3845, 148, 3298
30312, 3584, 239, 3561, 3469
30313, 2487, 3063, 2600, 5906
30314, 4055, 5913, 5110, 5994
30315, 3008, 2998, 2552, 5551
30316, 1286, 51, 927, 6040
30317, 1405, 320, 1389, 5746
30318, 3712, 3826, 3858, 5114
30319, 2553, 2551, 3113, 5629
30320, 1048, 1013, 1271, 6218
30321, 3479, 3579, 3509, 6151
30322, 2269, 2268, 2270, 5640
30323, 4841, 3991, 5726, 6078
30324, 889, 329, 890, 5646
30325, 939, 940, 1132, 5592
30326, 697, 708, 819, 5049
30327, 4284, 5892, 4836, 6062
30328, 1178, 1413, 5666, 6151
30329, 1081, 1080, 1082, 5228
30330, 1214, 863, 778, 5845
30331, 926, 314, 1380, 5563
30332, 2975, 2410, 2284, 5721
30333, 5138, 5841, 4122, 6094
30334, 609, 610, 590, 5024
30335, 4318, 5572, 4902, 6100
30336, 2767, 2139, 2629, 5704
30337, 2261, 2249, 2262, 6206
30338, 3466, 294, 3177, 3451
30339, 1331, 845, 1416, 5383
30340, 2977, 2308, 3076, 5731
30341, 3617, 3616, 3618, 4968
30342, 4247, 5734, 4630, 6124
30343, 3896, 171, 3848, 3188
30344, 1055, 1057, 1056, 5271
30345, 3573, 3515, 3482, 5078
30346, 3861, 3790, 3792, 5260
30347, 167, 3742, 3607, 3895
30348, 3130, 3187, 2898, 5763
30349, 2628, 3059, 2926, 5694
30350, 743, 741, 1222, 5500
30351, 2148, 3848, 171, 3188
30352, 1150, 954, 624, 5824
30353, 4068, 5600, 5422, 6006
30354, 824, 1335, 1178, 5666
30355, 3230, 3282, 3289, 6038
30356, 4048, 5607, 4876, 6158
30357, 1177, 740, 1202, 5673
30358, 1258, 612, 1127, 5537
30359, 60, 3841, 3692, 5819
30360, 2377, 2376, 2375, 6141
30361, 3409, 3308, 3464, 5339
30362, 442, 641, 1154, 5730
30363, 3450, 3561, 239, 3469
30364, 3679, 3683, 3665, 5178
30365, 3348, 3581, 236, 3511
30366, 317, 3473, 107, 5567
30367, 3822, 3862, 3719, 6146
30368, 1063, 1204, 1227, 5366
30369, 2756, 2426, 2494, 5886
30370, 1297, 1396, 350, 4942
30371, 880, 1406, 297, 5638
30372, 2132, 3125, 2634, 5526
30373, 1330, 3692, 5818, 5819
30374, 3583, 3689, 212, 3560
30375, 749, 751, 1311, 5820
30376, 3234, 3298, 27, 1321
30377, 3879, 3760, 3708, 5937
30378, 3154, 3271, 5669, 6038
30379, 2147, 3171, 3159, 5613
30380, 3234, 1321, 26, 5780
30381, 2653, 2659, 2652, 6091
30382, 1191, 1154, 1230, 6033
30383, 575, 573, 574, 6019
30384, 1338, 319, 1414, 5426
30385, 480, 525, 1113, 6050
30386, 1419, 298, 1329, 6045
30387, 5109, 5649, 4038, 6085
30388, 2147, 3159, 3102, 5613
30389, 610, 1072, 616, 5976
30390, 4955, 4076, 6069, 6206
30391, 2837, 2839, 2841, 5353
30392, 915, 744, 1354, 5153
30393, 1216, 1212, 483, 5471
30394, 3688, 170, 3898, 3846
30395, 2503, 2609, 2755, 5407
30396, 85, 323, 1395, 3682
30397, 982, 1283, 980, 6104
30398, 3059, 5336, 2624, 5905
30399, 3877, 3700, 3854, 6048
30400, 921, 313, 922, 5421
30401, 2275, 2276, 2277, 6089
30402, 3558, 3552, 3476, 6045
30403, 1072, 609, 1349, 6229
30404, 1264, 737, 1153, 5693
30405, 170, 3688, 3661, 3846
30406, 2596, 2972, 3007, 6066
30407, 3240, 3283, 5588, 5780
30408, 3787, 3785, 3784, 5550
30409, 2638, 2610, 2505, 5431
30410, 360, 361, 359, 5675
30411, 998, 999, 997, 5536
30412, 3279, 1375, 13, 3296
30413, 629, 1190, 1350, 5823
30414, 803, 1310, 5131, 6202
30415, 2704, 2703, 2102, 5947
30416, 752, 781, 780, 5564
30417, 1326, 776, 1324, 5791
30418, 1345, 943, 1259, 5723
30419, 835, 965, 1402, 4915
30420, 4034, 5641, 5328, 5936
30421, 3568, 3565, 3510, 5577
30422, 2144, 2739, 3189, 5326
30423, 1216, 985, 986, 5849
30424, 3657, 3604, 3671, 5834
30425, 4618, 5832, 5225, 5959
30426, 3728, 151, 3896, 3295
30427, 3454, 3423, 3448, 4956
30428, 2107, 3163, 255, 3547
30429, 2897, 2137, 3130, 4962
30430, 20, 1244, 306, 5495
30431, 467, 469, 468, 6179
30432, 3253, 3252, 3254, 5531
30433, 2634, 5526, 3125, 5883
30434, 3257, 3296, 144, 3449
30435, 3469, 262, 3335, 2149
30436, 177, 3700, 3820, 3212
30437, 3210, 2791, 2112, 5331
30438, 427, 438, 435, 5985
30439, 3663, 1371, 3685, 6183
30440, 3064, 2207, 3062, 5341
30441, 2512, 2461, 2982, 5705
30442, 480, 463, 525, 6050
30443, 3742, 3607, 3895, 6183
30444, 2515, 3003, 2591, 5619
30445, 2233, 2234, 2244, 5568
30446, 2859, 2864, 2961, 6195
30447, 2682, 3127, 2986, 5535
30448, 2486, 2851, 2348, 5270
30449, 2152, 3177, 294, 3451
30450, 1288, 532, 1233, 5519
30451, 3711, 3867, 3818, 5704
30452, 2704, 2102, 2718, 5947
30453, 1404, 893, 1353, 5653
30454, 1315, 1413, 309, 6151
30455, 2628, 2926, 2497, 5694
30456, 615, 614, 610, 5677
30457, 3560, 3689, 212, 3662
30458, 766, 767, 768, 5837
30459, 1142, 1058, 1158, 5327
30460, 2229, 2240, 3006, 5552
30461, 901, 902, 300, 5759
30462, 337, 930, 54, 5286
30463, 2144, 3198, 3119, 5326
30464, 2886, 2893, 2105, 5765
30465, 783, 781, 1217, 6226
30466, 3625, 3600, 3660, 5048
30467, 624, 521, 1150, 5824
30468, 3701, 2117, 176, 6100
30469, 1036, 1034, 1035, 5570
30470, 1158, 1053, 1051, 6041
30471, 389, 437, 391, 5359
30472, 3033, 2293, 2290, 5991
30473, 20, 306, 3223, 5495
30474, 767, 769, 768, 5837
30475, 2506, 2467, 2468, 6181
30476, 3489, 3545, 3567, 6004
30477, 3049, 2481, 3052, 5871
30478, 2492, 2518, 2477, 6147
30479, 2700, 3144, 5134, 6237
30480, 1141, 771, 945, 5313
30481, 3688, 2150, 216, 3605
30482, 1266, 356, 681, 6017
30483, 476, 477, 478, 5282
30484, 3310, 3430, 3446, 6116
30485, 3301, 3277, 3235, 5413
30486, 3608, 3663, 3607, 6183
30487, 3835, 3814, 35, 6190
30488, 1311, 1162, 749, 5820
30489, 3679, 3643, 3683, 5178
30490, 3777, 3693, 3771, 5286
30491, 151, 3728, 3236, 3295
30492, 920, 1218, 446, 6196
30493, 1175, 510, 619, 5450
30494, 3830, 3716, 3832, 6040
30495, 4051, 6008, 5214, 6130
30496, 879, 1306, 339, 5722
30497, 1118, 728, 514, 6139
30498, 464, 480, 481, 5973
30499, 1124, 826, 695, 6213
30500, 711, 713, 1108, 6068
30501, 1417, 818, 1376, 6150
30502, 2601, 2586, 2482, 5028
30503, 3760, 3757, 3708, 5937
30504, 5214, 6008, 4452, 6130
30505, 629, 571, 1190, 5823
30506, 2644, 2645, 2643, 5361
30507, 5395, 6058, 4137, 6148
30508, 3815, 3780, 3698, 5632
30509, 2865, 2538, 2863, 5957
30510, 1401, 890, 329, 5646
30511, 107, 3473, 3551, 5567
30512, 2154, 2123, 2155, 5949
30513, 116, 1347, 3420, 5339
30514, 2873, 2486, 2806, 5898
30515, 2747, 3055, 3199, 5695
30516, 2282, 2266, 2283, 5911
30517, 3220, 2694, 3115, 5524
30518, 2907, 2842, 3034, 5719
30519, 1191, 992, 551, 5454
30520, 3297, 3177, 152, 3235
30521, 3715, 3861, 3822, 5765
30522, 1220, 920, 446, 5496
30523, 486, 485, 487, 5743
30524, 1095, 1096, 1328, 5508
30525, 821, 917, 1358, 5989
30526, 2950, 2843, 2984, 5587
30527, 2198, 2912, 2911, 5585
30528, 3897, 28, 346, 3727
30529, 2105, 2887, 3074, 6146
30530, 3022, 2589, 3100, 6227
30531, 3544, 3489, 104, 6103
30532, 3684, 3619, 3622, 5734
30533, 2117, 3212, 176, 6100
30534, 3232, 3259, 3258, 5147
30535, 1112, 422, 1100, 5981
30536, 1231, 613, 488, 6062
30537, 889, 891, 304, 5797
30538, 3280, 166, 3295, 3123
30539, 1009, 1011, 560, 5644
30540, 2358, 2351, 2359, 5853
30541, 943, 1345, 1334, 5723
30542, 3489, 1361, 104, 6103
30543, 2499, 2510, 2500, 5915
30544, 2354, 2353, 2324, 5548
30545, 1066, 729, 1136, 5850
30546, 3248, 3247, 3249, 5869
30547, 4969, 5674, 4130, 6191
30548, 2132, 2634, 3143, 5526
30549, 3606, 88, 349, 3689
30550, 3467, 111, 1370, 3452
30551, 1031, 1025, 1022, 5573
30552, 13, 1297, 1375, 3279
30553, 409, 407, 430, 5752
30554, 3346, 3343, 3345, 5510
30555, 1208, 720, 849, 6231
30556, 1319, 1382, 953, 5725
30557, 798, 1127, 1261, 5816
30558, 1355, 1088, 796, 5650
30559, 538, 544, 539, 5738
30560, 3538, 3555, 3478, 5722
30561, 1321, 3298, 27, 1386
30562, 3670, 3641, 3635, 5430
30563, 3609, 3608, 3603, 6209
30564, 3593, 219, 3681, 6121
30565, 2252, 3047, 2967, 5803
30566, 3814, 310, 35, 6190
30567, 3520, 3567, 3521, 5001
30568, 2700, 3144, 2581, 5134
30569, 1203, 627, 526, 5741
30570, 4073, 5130, 5865, 6031
30571, 3852, 3874, 3801, 5727
30572, 2200, 2201, 2199, 5499
30573, 627, 550, 526, 5741
30574, 906, 302, 907, 5141
30575, 2842, 2839, 3034, 5719
30576, 2659, 3148, 3101, 5670
30577, 2620, 2540, 2541, 5411
30578, 3096, 2709, 2712, 5984
30579, 1276, 1000, 1001, 5794
30580, 3667, 3639, 3687, 5199
30581, 3547, 3163, 255, 3474
30582, 2379, 2381, 2380, 5910
30583, 644, 1004, 1005, 5502
30584, 891, 931, 304, 5365
30585, 3880, 1135, 63, 1134
30586, 3283, 3234, 26, 5780
30587, 402, 401, 403, 5993
30588, 3636, 3638, 3637, 6108
30589, 1364, 864, 810, 5591
30590, 5659, 5728, 4650, 6195
30591, 3884, 3695, 3750, 5746
30592, 2469, 2385, 2383, 5579
30593, 2251, 2243, 2250, 6168
30594, 2818, 2210, 2208, 5609
30595, 2479, 3135, 2396, 5851
30596, 2736, 290, 3421, 5958
30597, 3352, 3351, 3350, 5082
30598, 2687, 2560, 3121, 5294
30599, 2116, 2652, 2659, 6091
30600, 3483, 2141, 253, 6177
30601, 1416, 843, 1356, 5393
30602, 3872, 2901, 192, 6039
30603, 458, 1173, 735, 5903
30604, 862, 778, 863, 5845
30605, 1261, 685, 798, 5816
30606, 2490, 2603, 2536, 5848
30607, 301, 1099, 1097, 5632
30608, 2141, 2966, 3200, 5308
30609, 602, 1291, 991, 5367
30610, 1178, 309, 1413, 6151
30611, 1296, 1110, 1111, 5787
30612, 2131, 3203, 2690, 5995
30613, 3835, 35, 1393, 6190
30614, 5812, 5849, 4311, 6215
30615, 3468, 350, 143, 3334
30616, 2466, 2464, 3105, 5671
30617, 3726, 3746, 3886, 5613
30618, 461, 1106, 452, 5554
30619, 1340, 26, 1321, 5780
30620, 547, 5865, 5130, 6031
30621, 4122, 5841, 4966, 6094
30622, 253, 3526, 3483, 6177
30623, 2312, 2977, 2421, 5933
30624, 240, 3174, 3103, 3580
30625, 2712, 2709, 2711, 5984
30626, 3549, 1383, 105, 947
30627, 338, 3841, 60, 5819
30628, 3175, 3148, 2939, 5457
30629, 4144, 5849, 5812, 6215
30630, 2352, 2432, 2429, 5560
30631, 2540, 2424, 2496, 5982
30632, 3729, 3731, 3730, 5046
30633, 2942, 2326, 2947, 5482
30634, 4086, 5585, 5857, 6092
30635, 3082, 2187, 2189, 5351
30636, 3670, 3691, 3589, 5987
30637, 3712, 192, 2138, 6039
30638, 1039, 1210, 420, 5603
30639, 3735, 3737, 3736, 5166
30640, 3224, 3189, 155, 3291
30641, 323, 85, 3598, 3682
30642, 3684, 3668, 3617, 5563
30643, 2449, 2799, 2800, 5944
30644, 2937, 3723, 206, 5684
30645, 922, 313, 1376, 5421
30646, 387, 388, 386, 5584
30647, 3271, 3154, 157, 6038
30648, 1317, 342, 937, 5528
30649, 583, 584, 592, 6051
30650, 1292, 607, 1202, 6163
30651, 1111, 1110, 1109, 5787
30652, 2992, 2440, 2375, 5428
30653, 1272, 1078, 1076, 5597
30654, 116, 3420, 3308, 5339
30655, 521, 495, 496, 5967
30656, 435, 440, 1151, 5475
30657, 625, 598, 623, 5870
30658, 2618, 3155, 2628, 6144
30659, 2149, 3172, 3097, 5125
30660, 917, 821, 820, 5569
30661, 1250, 1373, 1325, 5304
30662, 2322, 2335, 2336, 6011
30663, 3427, 3392, 3381, 6061
30664, 69, 3685, 3663, 1371
30665, 2982, 2419, 2954, 5432
30666, 2484, 2485, 2441, 5363
30667, 3692, 3893, 61, 1330
30668, 3047, 3051, 2603, 5479
30669, 2673, 2675, 2679, 5485
30670, 3466, 3177, 3297, 5413
30671, 2804, 2626, 3216, 5862
30672, 2985, 2781, 2386, 5436
30673, 3283, 1340, 5588, 5780
30674, 2647, 2728, 3133, 5048
30675, 2407, 2444, 2307, 6057
30676, 3700, 3877, 3843, 6048
30677, 3180, 3526, 253, 6177
30678, 2387, 2752, 3068, 5468
30679, 774, 1124, 636, 5606
30680, 3692, 1330, 60, 5819
30681, 308, 1311, 1330, 5818
30682, 3076, 2308, 3033, 5731
30683, 495, 462, 496, 5967
30684, 1231, 488, 491, 6062
30685, 3094, 3004, 2409, 5858
30686, 1017, 718, 1157, 5809
30687, 3188, 3295, 166, 3123
30688, 2617, 2629, 2630, 5624
30689, 2920, 2968, 2388, 6205
30690, 3239, 3241, 3242, 5934
30691, 3042, 2927, 2778, 5566
30692, 1300, 3895, 68, 1371
30693, 646, 1043, 570, 5645
30694, 3870, 3816, 3871, 6052
30695, 774, 1257, 1124, 6213
30696, 2624, 2581, 2576, 5905
30697, 2129, 2702, 2713, 5176
30698, 3843, 3889, 3820, 6100
30699, 671, 794, 673, 6037
30700, 3139, 2465, 2467, 6129
30701, 3663, 348, 1371, 6183
30702, 2266, 2975, 2284, 5721
30703, 2454, 2402, 2453, 6012
30704, 2456, 2881, 3205, 5904
30705, 3198, 3099, 2152, 5413
30706, 3548, 3586, 3559, 5220
30707, 704, 705, 666, 5733
30708, 1128, 706, 1307, 5594
30709, 2657, 2655, 2656, 6214
30710, 2703, 2704, 2705, 5561
30711, 2215, 2520, 2844, 5983
30712, 3196, 2621, 3002, 5464
30713, 2880, 2878, 2879, 5965
30714, 3562, 240, 3103, 3580
30715, 3516, 3522, 3518, 5402
30716, 430, 1263, 409, 5752
30717, 2490, 2536, 2430, 5848
30718, 1081, 1082, 1083, 6003
30719, 1409, 1327, 343, 5637
30720, 3006, 3029, 2345, 5747
30721, 2157, 2577, 2995, 6164
30722, 3593, 2126, 219, 6121
30723, 2709, 2104, 2708, 5368
30724, 704, 931, 761, 6224
30725, 3373, 3383, 3445, 5654
30726, 3679, 3656, 3643, 5971
30727, 2819, 2520, 2818, 5483
30728, 2806, 2486, 2350, 5898
30729, 2274, 2276, 2275, 6089
30730, 2429, 2502, 2511, 6199
30731, 2316, 2321, 2530, 6173
30732, 3686, 235, 3174, 3664
30733, 2211, 2212, 2220, 5877
30734, 2120, 2663, 3179, 5375
30735, 3078, 2239, 3077, 5599
30736, 3265, 3271, 3266, 5669
30737, 1076, 1078, 1077, 5597
30738, 3041, 2443, 3032, 5692
30739, 3681, 3625, 3593, 6121
30740, 2949, 2246, 2234, 5867
30741, 2566, 3110, 2568, 5755
30742, 321, 353, 935, 5392
30743, 782, 864, 1339, 5591
30744, 3495, 3496, 3490, 5598
30745, 394, 1110, 433, 5540
30746, 2319, 2944, 2275, 5742
30747, 3138, 2965, 2142, 5261
30748, 3177, 3099, 152, 3235
30749, 846, 847, 844, 5589
30750, 2764, 3109, 2281, 5427
30751, 567, 569, 1256, 6175
30752, 564, 563, 562, 5545
30753, 290, 3329, 3421, 5958
30754, 3256, 318, 22, 6043
30755, 2138, 192, 2901, 6039
30756, 1266, 585, 358, 5697
30757, 3053, 2367, 2405, 5990
30758, 2338, 2989, 2597, 5463
30759, 3094, 2409, 3035, 5858
30760, 1340, 3283, 26, 5780
30761, 3124, 2672, 2671, 5668
30762, 3003, 2910, 2327, 6056
30763, 2686, 3154, 2118, 5669
30764, 3272, 3282, 3254, 5116
30765, 964, 1217, 596, 5664
30766, 5773, 5888, 4424, 5922
30767, 2377, 2378, 2376, 6141
30768, 3544, 104, 305, 6103
30769, 1385, 1083, 1328, 5508
30770, 5480, 5649, 4197, 6085
30771, 3894, 3759, 3707, 5583
30772, 338, 834, 1339, 5819
30773, 909, 907, 910, 5771
30774, 540, 1215, 988, 5790
30775, 3065, 2862, 3056, 5729
30776, 2236, 3071, 2203, 5648
30777, 3847, 3895, 68, 1300
30778, 3008, 2790, 2342, 5795
30779, 447, 1219, 1199, 5575
30780, 5855, 6069, 4076, 6206
30781, 659, 633, 658, 6042
30782, 1225, 746, 787, 5634
30783, 2511, 2502, 2558, 6199
30784, 2773, 2791, 3196, 5155
30785, 1028, 1278, 1027, 5954
30786, 3639, 3691, 3637, 6108
30787, 3153, 2666, 2140, 6052
30788, 2882, 2886, 3161, 5332
30789, 871, 769, 825, 5477
30790, 4038, 5649, 5480, 6085
30791, 2214, 2216, 2539, 5950
30792, 2736, 2577, 2737, 5958
30793, 3858, 3837, 3783, 5715
30794, 422, 419, 421, 5709
30795, 111, 347, 1370, 3452
30796, 3680, 3623, 3624, 6124
30797, 2154, 2155, 2156, 5949
30798, 4127, 5724, 5309, 6143
30799, 1313, 898, 895, 4997
30800, 2242, 2237, 2953, 5707
30801, 2487, 2488, 3063, 5906
30802, 3561, 3493, 3584, 5125
30803, 354, 681, 356, 6017
30804, 1060, 1052, 1243, 5617
30805, 2750, 2740, 2529, 5394
30806, 904, 901, 911, 5844
30807, 3482, 3517, 3577, 5764
30808, 3712, 3872, 192, 6039
30809, 3152, 3147, 2900, 5811
30810, 3308, 3409, 3410, 5653
30811, 2369, 2370, 2368, 5662
30812, 1154, 1191, 462, 6033
30813, 4472, 5899, 5304, 5952
30814, 1354, 744, 1073, 5153
30815, 308, 1330, 3893, 5818
30816, 3180, 253, 2141, 6177
30817, 534, 589, 535, 5507
30818, 2214, 2215, 2216, 5950
30819, 310, 1393, 35, 6190
30820, 3335, 3450, 3469, 5125
30821, 2902, 2442, 2231, 5699
30822, 1245, 801, 1249, 5633
30823, 3714, 3850, 3873, 5667
30824, 2962, 2302, 2296, 5618
30825, 3473, 3569, 3551, 5567
30826, 1340, 860, 341, 5588
30827, 1177, 1202, 607, 6163
30828, 698, 1208, 708, 5781
30829, 2379, 2380, 2378, 5910
30830, 2778, 2656, 2777, 5467
30831, 2428, 3116, 2161, 5512
30832, 3029, 2863, 2861, 5737
30833, 2333, 2967, 2547, 5622
30834, 803, 1310, 899, 5131
30835, 2990, 3038, 2539, 5978
30836, 3364, 3425, 3367, 5814
30837, 616, 691, 632, 5358
30838, 686, 978, 1267, 6193
30839, 755, 753, 653, 5829
30840, 1332, 909, 910, 5771
30841, 1027, 1023, 1028, 5954
30842, 613, 1232, 1221, 5997
30843, 3592, 3690, 3624, 5670
30844, 5650, 6030, 4454, 6152
30845, 104, 1361, 305, 6103
30846, 3635, 3641, 3633, 5430
30847, 3287, 3268, 3226, 5340
30848, 458, 464, 1173, 5903
30849, 3757, 3760, 3754, 5827
30850, 3356, 3321, 3465, 5524
30851, 4136, 6010, 5076, 6200
30852, 3664, 235, 3174, 2151
30853, 3582, 3525, 3486, 5486
30854, 2682, 3125, 2099, 5883
30855, 3544, 3545, 3489, 6103
30856, 2863, 2864, 2859, 6195
30857, 2144, 3119, 2739, 5326
30858, 2910, 2909, 2327, 6056
30859, 972, 1362, 1374, 5539
30860, 926, 845, 1331, 5383
30861, 2605, 2701, 3112, 6117
30862, 628, 555, 1176, 6238
30863, 2698, 2697, 2696, 5357
30864, 2640, 2638, 2639, 5945
30865, 1221, 1232, 1105, 5997
30866, 724, 960, 722, 5343
30867, 2420, 2868, 2336, 5472
30868, 2757, 2871, 2872, 5558
30869, 3596, 3646, 3645, 5883
30870, 2977, 2312, 2309, 5933
30871, 298, 1164, 1329, 6045
30872, 3880, 3755, 3752, 5043
30873, 373, 1289, 375, 6122
30874, 2802, 3081, 2239, 5778
30875, 879, 339, 1378, 5722
30876, 2180, 2179, 2178, 6080
30877, 838, 837, 836, 6217
30878, 2553, 2552, 2551, 5629
30879, 1017, 1018, 528, 5701
30880, 2999, 2987, 2596, 5854
30881, 3102, 3173, 211, 3898
30882, 3173, 3102, 2150, 5310
30883, 1350, 1190, 1318, 6023
30884, 1372, 3583, 89, 1301
30885, 3039, 2406, 2361, 5977
30886, 2114, 3149, 3059, 5336
30887, 3272, 3267, 3266, 5998
30888, 3285, 3231, 3302, 6192
30889, 3495, 3497, 3496, 5598
30890, 3663, 348, 69, 1371
30891, 2304, 2268, 2976, 5822
30892, 2282, 2283, 2305, 5911
30893, 2520, 2215, 2213, 5983
30894, 2611, 2754, 3117, 6201
30895, 2873, 2810, 3056, 5663
30896, 2941, 2408, 2942, 5661
30897, 3237, 3233, 3238, 5452
30898, 822, 1347, 1257, 5339
30899, 3151, 2869, 2411, 5679
30900, 957, 817, 1306, 5702
30901, 3197, 2725, 2635, 5712
30902, 602, 991, 990, 5367
30903, 1307, 962, 479, 6060
30904, 3010, 2731, 2117, 6100
30905, 3831, 3884, 3750, 5746
30906, 2592, 2517, 2516, 6155
30907, 2519, 3139, 2467, 4875
30908, 3763, 3764, 3767, 6082
30909, 1294, 907, 908, 5565
30910, 931, 891, 761, 5365
30911, 2225, 2219, 2217, 5951
30912, 736, 449, 441, 5642
30913, 3021, 2262, 2249, 6206
30914, 3342, 3459, 3339, 5713
30915, 969, 968, 970, 5625
30916, 3154, 2686, 2687, 6038
30917, 3611, 3610, 3609, 6209
30918, 2650, 2652, 2648, 6204
30919, 3154, 2687, 157, 6038
30920, 2509, 2918, 2462, 5799
30921, 2336, 2335, 2337, 6011
30922, 870, 943, 1322, 6210
30923, 2122, 3191, 2921, 5665
30924, 3181, 2973, 2111, 5486
30925, 479, 1122, 374, 5523
30926, 3201, 3143, 2602, 5920
30927, 1194, 786, 883, 5635
30928, 1223, 1224, 964, 6046
30929, 2636, 3132, 2140, 5583
30930, 1237, 557, 559, 5735
30931, 573, 575, 638, 6019
30932, 3881, 3701, 3739, 5685
30933, 3629, 3671, 3604, 5834
30934, 3399, 3400, 3397, 5921
30935, 927, 869, 1286, 6040
30936, 3256, 22, 3227, 6043
30937, 803, 961, 1310, 6202
30938, 2934, 2742, 2741, 5959
30939, 427, 1204, 438, 5985
30940, 2666, 2612, 2584, 5792
30941, 471, 469, 1143, 5968
30942, 3325, 3411, 3455, 5336
30943, 3090, 2833, 2827, 5751
30944, 1118, 1166, 728, 6139
30945, 2586, 2602, 3143, 5920
30946, 3151, 2705, 2869, 5801
30947, 1319, 953, 756, 5725
30948, 418, 1243, 1268, 5914
30949, 60, 1330, 338, 5819
30950, 1345, 1098, 1097, 6035
30951, 1081, 1083, 1384, 6003
30952, 3249, 3253, 3292, 5453
30953, 2413, 2344, 2414, 6133
30954, 2340, 2339, 2341, 5817
30955, 839, 838, 840, 6027
30956, 2733, 2506, 2563, 5491
30957, 2458, 3176, 3002, 6176
30958, 2821, 2822, 2823, 5980
30959, 2917, 2685, 2258, 5942
30960, 3726, 3102, 211, 3898
30961, 2870, 2623, 2938, 6028
30962, 3621, 3622, 3619, 5734
30963, 3732, 3885, 3727, 5656
30964, 41, 42, 334, 3704
30965, 301, 47, 48, 3815
30966, 3451, 3466, 3336, 5413
30967, 3717, 39, 38, 1120
30968, 519, 520, 515, 5840
30969, 672, 671, 673, 6037
30970, 401, 402, 400, 5993
30971, 1392, 919, 1388, 5117
30972, 3473, 1383, 106, 3549
30973, 884, 1352, 885, 5732
30974, 1272, 1084, 1359, 5821
30975, 2599, 2795, 2796, 5706
30976, 3492, 89, 3583, 1301
30977, 40, 41, 1074, 3813
30978, 3271, 157, 3230, 6038
30979, 2180, 2181, 2179, 6080
30980, 42, 43, 1085, 3824
30981, 183, 182, 2109, 3702
30982, 4136, 5519, 6010, 6200
30983, 39, 40, 307, 3836
30984, 5471, 5849, 4144, 6215
30985, 3395, 3432, 3436, 5714
30986, 37, 38, 333, 3827
30987, 3707, 3871, 3816, 6052
30988, 206, 3723, 3879, 5684
30989, 830, 930, 337, 5286
30990, 2923, 2422, 2853, 5748
30991, 3085, 2245, 3086, 6090
30992, 3847, 3709, 3743, 5571
30993, 638, 1318, 1190, 6023
30994, 3149, 2624, 3059, 5336
30995, 3410, 3458, 3308, 5653
30996, 710, 1180, 659, 5900
30997, 713, 1201, 1108, 6068
30998, 1338, 1181, 319, 5426
30999, 3463, 3344, 3314, 5392
31000, 3218, 3133, 2126, 6121
31001, 1257, 1347, 312, 5339
31002, 3406, 3410, 3407, 5444
31003, 3219, 2635, 2725, 5712
31004, 2110, 3113, 2964, 5937
31005, 3480, 3502, 3571, 5426
31006, 2610, 2937, 2936, 5684
31007, 3817, 3857, 3699, 5620
31008, 2456, 3146, 2883, 6222
31009, 3781, 3780, 3782, 5777
31010, 943, 1334, 1322, 6210
31011, 2898, 2103, 2897, 5667
31012, 3097, 261, 3584, 3172
31013, 3605, 3661, 3688, 5310
31014, 273, 272, 2707, 3400
31015, 3843, 3812, 3738, 5572
31016, 3309, 122, 121, 905
31017, 849, 720, 722, 6231
31018, 889, 134, 135, 3307
31019, 285, 286, 3366, 2691
31020, 773, 712, 1094, 5782
31021, 1099, 48, 49, 3698
31022, 1277, 619, 1278, 5779
31023, 2130, 282, 281, 3379
31024, 336, 49, 50, 3778
31025, 3756, 3755, 3893, 5818
31026, 2705, 3151, 2706, 5801
31027, 3809, 3807, 3808, 5888
31028, 3898, 3846, 3726, 5310
31029, 3543, 250, 251, 2100
31030, 2936, 2964, 2610, 5684
31031, 3835, 3810, 3814, 6190
31032, 3250, 3222, 3293, 5375
31033, 540, 1206, 795, 5912
31034, 3601, 2726, 225, 6077
31035, 3046, 2108, 3184, 6170
31036, 4178, 6010, 5519, 6200
31037, 2526, 2524, 2762, 5879
31038, 2654, 2650, 2947, 6013
31039, 181, 182, 3821, 2922
31040, 425, 422, 424, 5969
31041, 2594, 2544, 2674, 6233
31042, 345, 1300, 1357, 5571
31043, 3587, 3503, 3501, 5263
31044, 2715, 2130, 2716, 5266
31045, 1051, 1121, 1158, 6041
31046, 1383, 106, 317, 3473
31047, 1080, 1359, 1084, 5821
31048, 3007, 2972, 2788, 6066
31049, 37, 36, 3703, 966
31050, 3681, 3600, 3625, 5048
31051, 1274, 1231, 506, 5892
31052, 732, 796, 1088, 5650
31053, 2518, 2543, 2787, 5955
31054, 3414, 3438, 3307, 5797
31055, 318, 1211, 22, 6043
31056, 1273, 436, 395, 6067
31057, 914, 913, 1391, 5843
31058, 2573, 2476, 2943, 6235
31059, 2224, 2914, 2902, 5815
31060, 764, 785, 763, 6160
31061, 1286, 50, 51, 3716
31062, 35, 36, 310, 3814
31063, 3807, 3805, 3806, 5773
31064, 327, 126, 127, 3416
31065, 278, 277, 2129, 3319
31066, 279, 278, 2708, 3382
31067, 3315, 128, 127, 906
31068, 2793, 2792, 2774, 5418
31069, 43, 44, 303, 3705
31070, 2704, 3160, 2705, 5561
31071, 3227, 22, 1211, 6043
31072, 2485, 2513, 2514, 5975
31073, 1374, 656, 1200, 6236
31074, 1062, 1061, 1057, 5784
31075, 2943, 2476, 2474, 6235
31076, 173, 174, 3741, 2134
31077, 348, 1300, 1371, 6183
31078, 3641, 3670, 3657, 5987
31079, 3584, 3493, 261, 3097
31080, 309, 95, 96, 3479
31081, 2656, 2927, 2657, 6214
31082, 3577, 3537, 257, 3185
31083, 300, 124, 125, 3415
31084, 276, 275, 2102, 3322
31085, 3566, 3579, 3479, 6151
31086, 367, 369, 368, 5864
31087, 3136, 2138, 2901, 6039
31088, 3145, 2692, 2693, 6165
31089, 816, 1310, 961, 6202
31090, 328, 130, 131, 3446
31091, 2936, 2110, 2964, 5937
31092, 3216, 2626, 3137, 5437
31093, 3228, 159, 160, 3046
31094, 2808, 2807, 2446, 5960
31095, 3059, 2624, 2576, 5905
31096, 3893, 308, 61, 1330
31097, 591, 1223, 547, 5865
31098, 2887, 186, 185, 3719
31099, 2626, 2804, 2517, 5862
31100, 3055, 2747, 2943, 5695
31101, 3830, 52, 51, 927
31102, 3590, 3672, 3615, 5383
31103, 569, 629, 1256, 6175
31104, 3483, 3526, 3527, 6177
31105, 180, 181, 3720, 2135
31106, 195, 194, 2729, 3699
31107, 3483, 252, 253, 2141
31108, 3850, 190, 191, 2103
31109, 2730, 3195, 2731, 6048
31110, 3161, 3074, 2880, 5965
31111, 2101, 196, 195, 3817
31112, 299, 52, 53, 3713
31113, 184, 183, 2876, 3852
31114, 2694, 2124, 3115, 5524
31115, 280, 279, 2104, 3328
31116, 3004, 3095, 2549, 6186
31117, 100, 298, 99, 3558
31118, 2687, 3230, 157, 6038
31119, 457, 458, 453, 5828
31120, 383, 439, 385, 5804
31121, 185, 184, 2136, 3874
31122, 281, 280, 2735, 3378
31123, 3235, 3277, 3297, 5413
31124, 1398, 1306, 817, 5702
31125, 3645, 3655, 3601, 6077
31126, 1159, 530, 1062, 6134
31127, 3826, 193, 194, 3088
31128, 1416, 1356, 324, 5393
31129, 1317, 1396, 342, 5528
31130, 2664, 2146, 3165, 5639
31131, 2936, 2937, 206, 5684
31132, 189, 190, 3714, 2897
31133, 372, 1122, 1123, 6072
31134, 3539, 248, 249, 2142
31135, 2614, 3166, 2637, 6074
31136, 187, 186, 2105, 3822
31137, 1095, 46, 47, 3825
31138, 3895, 3685, 1371, 6183
31139, 1187, 477, 474, 6097
31140, 3668, 3590, 3617, 5563
31141, 3770, 3840, 3867, 5897
31142, 2164, 2162, 2163, 5928
31143, 3313, 124, 123, 916
31144, 275, 274, 2718, 3391
31145, 3489, 3567, 3549, 6004
31146, 511, 514, 513, 5917
31147, 2772, 2770, 2771, 6087
31148, 3092, 2688, 2590, 5893
31149, 78, 79, 297, 3654
31150, 3712, 192, 193, 2138
31151, 375, 1289, 1290, 6122
31152, 3285, 3258, 3260, 6192
31153, 302, 128, 129, 3419
31154, 2732, 197, 196, 3710
31155, 54, 53, 3771, 930
31156, 3569, 3518, 3522, 5402
31157, 3692, 3841, 3844, 5819
31158, 3851, 3872, 3712, 6039
31159, 3000, 3150, 3164, 5956
31160, 225, 2099, 3645, 6077
31161, 2401, 2487, 2430, 5996
31162, 3217, 2748, 2119, 5764
31163, 139, 138, 3312, 934
31164, 98, 340, 97, 3475
31165, 687, 1320, 1285, 6110
31166, 2173, 2175, 2247, 6022
31167, 1178, 1413, 824, 5666
31168, 188, 189, 3828, 2137
31169, 335, 45, 46, 3697
31170, 547, 548, 549, 6031
31171, 3701, 3820, 3889, 6100
31172, 262, 263, 3335, 2149
31173, 305, 103, 104, 3544
31174, 2940, 2867, 2389, 6036
31175, 3872, 191, 192, 2901
31176, 917, 820, 1360, 5569
31177, 1336, 1163, 1419, 5595
31178, 965, 814, 827, 5852
31179, 270, 271, 3306, 2701
31180, 885, 758, 884, 5732
31181, 3277, 146, 147, 3336
31182, 22, 23, 318, 3256
31183, 101, 102, 339, 3538
31184, 469, 467, 530, 6179
31185, 207, 206, 2937, 3723
31186, 3398, 3444, 3428, 5776
31187, 380, 379, 381, 5894
31188, 1048, 1271, 1047, 6218
31189, 3695, 64, 63, 1135
31190, 287, 288, 3360, 2690
31191, 3407, 3405, 3406, 5444
31192, 28, 29, 346, 3727
31193, 3601, 225, 3645, 6077
31194, 87, 88, 349, 3606
31195, 2890, 3157, 2598, 5798
31196, 66, 65, 3831, 1119
31197, 2605, 3112, 2763, 6117
31198, 3644, 3589, 3691, 5712
31199, 3273, 21, 20, 1244
31200, 2466, 2468, 2467, 6181
31201, 3310, 130, 129, 933
31202, 880, 1325, 1406, 5899
31203, 1385, 1328, 1096, 5508
31204, 900, 125, 126, 3305
31205, 276, 277, 3388, 2702
31206, 1037, 1035, 1039, 6025
31207, 2150, 217, 216, 3605
31208, 2546, 2465, 3139, 6129
31209, 328, 915, 933, 6116
31210, 1217, 781, 988, 6226
31211, 616, 615, 610, 5677
31212, 393, 392, 391, 5946
31213, 1393, 310, 928, 6190
31214, 168, 167, 3742, 3607
31215, 3255, 163, 164, 2143
31216, 326, 122, 123, 3422
31217, 2128, 274, 273, 3331
31218, 3256, 3227, 3288, 6043
31219, 142, 143, 350, 3334
31220, 3629, 3630, 3631, 6159
31221, 2123, 292, 291, 3418
31222, 150, 151, 3728, 3236
31223, 3046, 3184, 2609, 6170
31224, 3484, 249, 250, 2965
31225, 3425, 3383, 3368, 6120
31226, 2681, 2594, 2674, 6233
31227, 3145, 2693, 2563, 6165
31228, 283, 282, 2715, 3316
31229, 172, 173, 3721, 3057
31230, 179, 180, 3876, 2768
31231, 2921, 209, 208, 3696
31232, 3180, 2141, 2681, 6177
31233, 717, 1391, 931, 6224
31234, 3101, 3148, 2133, 5670
31235, 3333, 3461, 3424, 5562
31236, 912, 132, 133, 3326
31237, 283, 284, 3369, 2714
31238, 363, 1133, 361, 5935
31239, 1267, 1192, 686, 6193
31240, 2869, 2391, 2411, 5679
31241, 1332, 904, 911, 5844
31242, 114, 322, 113, 3424
31243, 2748, 3169, 2119, 5764
31244, 3847, 3742, 3895, 6183
31245, 3696, 3761, 3883, 5665
31246, 3308, 3420, 3464, 5339
31247, 1096, 1097, 1098, 6035
31248, 347, 111, 112, 3452
31249, 332, 30, 31, 3706
31250, 946, 1415, 317, 5567
31251, 171, 172, 3848, 2148
31252, 924, 77, 78, 3591
31253, 251, 252, 3546, 2966
31254, 2726, 2099, 225, 6077
31255, 3162, 2719, 2128, 5651
31256, 3640, 3643, 3656, 5971
31257, 2366, 2365, 2367, 6178
31258, 2126, 3158, 3218, 6121
31259, 3879, 2936, 206, 5684
31260, 3628, 215, 214, 3494
31261, 2152, 294, 293, 3451
31262, 1091, 44, 45, 3819
31263, 2893, 188, 187, 3715
31264, 1262, 1265, 1007, 6009
31265, 236, 237, 3348, 3511
31266, 304, 133, 134, 3414
31267, 284, 285, 3323, 2106
31268, 2357, 2978, 2354, 6105
31269, 66, 67, 345, 3709
31270, 3257, 144, 145, 3449
31271, 3339, 3341, 3342, 5713
31272, 3845, 148, 149, 3276
31273, 1340, 1321, 1400, 5780
31274, 3701, 175, 176, 2117
31275, 3144, 3214, 2478, 6237
31276, 3283, 3225, 3240, 5588
31277, 3271, 3265, 3291, 5669
31278, 1346, 331, 925, 5919
31279, 899, 119, 120, 3412
31280, 3854, 178, 179, 2112
31281, 3389, 3387, 3426, 6095
31282, 2929, 3060, 2600, 6128
31283, 1124, 1257, 826, 6213
31284, 140, 141, 321, 3314
31285, 2132, 228, 227, 3649
31286, 2630, 2629, 2632, 5624
31287, 880, 1184, 1325, 5899
31288, 3429, 132, 131, 913
31289, 754, 655, 753, 6131
31290, 2579, 2501, 2804, 6064
31291, 553, 1150, 522, 6225
31292, 1303, 664, 706, 6076
31293, 842, 843, 844, 5939
31294, 3205, 2469, 2383, 5579
31295, 2209, 2211, 2232, 6112
31296, 315, 32, 33, 3823
31297, 234, 235, 3664, 2151
31298, 3223, 3294, 3273, 5495
31299, 3300, 3234, 3283, 5780
31300, 69, 70, 348, 3663
31301, 1173, 482, 608, 6171
31302, 3212, 2117, 2731, 6100
31303, 1163, 98, 99, 3553
31304, 100, 101, 1164, 3476
31305, 2139, 2767, 3204, 5704
31306, 2534, 2535, 2532, 5999
31307, 3321, 264, 265, 2124
31308, 329, 135, 136, 3417
31309, 286, 287, 3327, 2131
31310, 225, 226, 3645, 2099
31311, 810, 864, 782, 5591
31312, 3596, 226, 227, 3125
31313, 3267, 3272, 3269, 5998
31314, 269, 268, 2695, 3318
31315, 3141, 2666, 2584, 5792
31316, 2107, 255, 254, 3547
31317, 3243, 3242, 3241, 5934
31318, 1369, 840, 838, 6027
31319, 3692, 3756, 3893, 5818
31320, 3409, 3359, 3407, 5839
31321, 3583, 6, 3689, 1372
31322, 3099, 3177, 2152, 5413
31323, 3898, 3173, 10, 3688
31324, 246, 247, 3525, 2111
31325, 1408, 928, 310, 6190
31326, 3469, 3584, 12, 3172
31327, 3480, 92, 91, 1181
31328, 2631, 2630, 3040, 6083
31329, 3164, 3150, 2793, 5956
31330, 2116, 222, 221, 3658
31331, 2097, 272, 271, 3399
31332, 353, 352, 354, 6086
31333, 2983, 243, 242, 3524
31334, 3895, 3685, 4, 1371
31335, 3467, 1370, 7, 3581
31336, 257, 3577, 3185, 2119
31337, 81, 330, 80, 3588
31338, 2, 1375, 3468, 3296
31339, 60, 338, 59, 3841
31340, 2776, 3114, 2888, 5929
31341, 3311, 137, 136, 888
31342, 3723, 3890, 3879, 5684
31343, 3580, 11, 3174, 3686
31344, 3601, 224, 225, 2726
31345, 3485, 245, 246, 2980
31346, 1382, 306, 1244, 5495
31347, 221, 220, 2728, 3600
31348, 58, 296, 57, 3694
31349, 24, 25, 341, 3225
31350, 2880, 3074, 2878, 5965
31351, 2146, 242, 241, 3487
31352, 1323, 79, 80, 3650
31353, 169, 170, 3661, 3846
31354, 946, 317, 1367, 5567
31355, 2453, 2458, 3002, 6176
31356, 120, 121, 295, 3413
31357, 815, 827, 814, 5852
31358, 8, 3177, 3297, 3466
31359, 2456, 2379, 3146, 6222
31360, 2153, 293, 292, 3320
31361, 3590, 74, 73, 926
31362, 9, 3896, 3295, 3188
31363, 112, 113, 894, 3333
31364, 3359, 3408, 3407, 5839
31365, 201, 200, 2098, 3722
31366, 3630, 3629, 3595, 6159
31367, 3298, 3897, 3, 1386
31368, 2618, 3112, 3155, 6144
31369, 3560, 212, 213, 3662
31370, 1330, 834, 338, 5819
31371, 3137, 245, 244, 3541
31372, 3561, 239, 238, 3450
31373, 1361, 1305, 305, 6103
31374, 3610, 3608, 3609, 6209
31375, 3102, 211, 210, 3726
31376, 3843, 3738, 3889, 5572
31377, 96, 97, 1171, 3523
31378, 76, 75, 3602, 1299
31379, 3692, 61, 60, 1330
31380, 3492, 90, 89, 1301
31381, 241, 240, 3103, 3562
31382, 3651, 84, 83, 923
31383, 3486, 247, 248, 2973
31384, 161, 162, 3222, 2120
31385, 3847, 68, 67, 1300
31386, 3589, 3657, 3670, 5987
31387, 74, 75, 314, 3668
31388, 3659, 3648, 3666, 6194
31389, 656, 651, 1200, 6236
31390, 3191, 2638, 2640, 5945
31391, 288, 289, 3330, 2113
31392, 160, 161, 3275, 3013
31393, 238, 237, 3481, 3317
31394, 2648, 2652, 3182, 6204
31395, 3356, 3355, 3353, 5770
31396, 71, 70, 3599, 1316
31397, 312, 116, 117, 3308
31398, 232, 233, 3657, 2125
31399, 3215, 2611, 3117, 6201
31400, 168, 169, 3603, 3724
31401, 3621, 3624, 3623, 6124
31402, 3477, 94, 93, 1335
31403, 3595, 214, 213, 3490
31404, 2804, 3140, 2579, 6064
31405, 223, 222, 3101, 3592
31406, 289, 290, 3421, 2736
31407, 3421, 3329, 3471, 5958
31408, 2140, 203, 202, 3707
31409, 324, 71, 72, 3652
31410, 318, 1368, 1211, 6043
31411, 269, 270, 3403, 2127
31412, 82, 81, 3653, 921
31413, 256, 257, 3537, 3185
31414, 108, 109, 343, 3491
31415, 2114, 268, 267, 3411
31416, 3230, 3289, 3271, 6038
31417, 2885, 3187, 3130, 5763
31418, 2723, 229, 228, 3597
31419, 198, 197, 2139, 3818
31420, 54, 55, 337, 3693
31421, 158, 157, 2687, 3230
31422, 3281, 19, 18, 885
31423, 260, 261, 3493, 3097
31424, 146, 145, 3332, 3232
31425, 836, 1389, 838, 6217
31426, 3280, 165, 166, 3123
31427, 107, 317, 106, 3473
31428, 717, 931, 704, 6224
31429, 3234, 27, 26, 1321
31430, 150, 149, 3233, 3725
31431, 1067, 1349, 609, 6229
31432, 1295, 109, 110, 3563
31433, 157, 156, 3154, 3271
31434, 3637, 3638, 3639, 6108
31435, 2737, 291, 290, 3329
31436, 3208, 2099, 2726, 6077
31437, 30, 29, 3885, 1255
31438, 205, 204, 2110, 3708
31439, 3180, 254, 253, 3526
31440, 2144, 154, 153, 3284
31441, 59, 58, 3762, 1351
31442, 1370, 110, 7, 3581
31443, 3304, 115, 114, 892
31444, 2147, 210, 209, 3886
31445, 1367, 107, 108, 3551
31446, 3895, 4, 68, 1371
31447, 3489, 105, 104, 1361
31448, 3227, 22, 21, 1211
31449, 3663, 3685, 3607, 6183
31450, 267, 266, 3149, 3325
31451, 141, 142, 351, 3456
31452, 3478, 103, 102, 1378
31453, 240, 11, 3174, 3580
31454, 313, 82, 83, 3594
31455, 244, 243, 2121, 3488
31456, 10, 170, 3898, 3688
31457, 3226, 18, 17, 1352
31458, 935, 139, 140, 3463
31459, 2122, 208, 207, 3883
31460, 3689, 212, 6, 3583
31461, 3457, 263, 264, 2696
31462, 342, 14, 15, 3231
31463, 3302, 3258, 3285, 6192
31464, 331, 76, 77, 3669
31465, 156, 155, 2118, 3291
31466, 1417, 1376, 923, 6150
31467, 1375, 2, 13, 3296
31468, 12, 239, 3584, 3469
31469, 3246, 3247, 3248, 5869
31470, 35, 34, 3835, 1393
31471, 90, 91, 344, 3572
31472, 2700, 3214, 3144, 6237
31473, 233, 234, 3604, 2721
31474, 19, 20, 306, 3223
31475, 230, 229, 2115, 3667
31476, 3183, 200, 199, 3829
31477, 57, 56, 3833, 1381
31478, 7, 236, 3467, 3581
31479, 2108, 159, 158, 3274
31480, 3482, 258, 259, 3169
31481, 1297, 13, 14, 3279
31482, 4, 167, 3685, 3895
31483, 1387, 15, 16, 3270
31484, 3573, 259, 260, 2145
31485, 3580, 215, 11, 3686
31486, 153, 152, 3099, 3235
31487, 266, 265, 2694, 3465
31488, 223, 224, 3690, 2133
31489, 3295, 166, 9, 3188
31490, 316, 16, 17, 3287
31491, 3173, 10, 211, 3898
31492, 118, 119, 325, 3324
31493, 311, 137, 138, 3423
31494, 3173, 216, 10, 3688
31495, 6, 88, 3689, 1372
31496, 105, 106, 1383, 3549
31497, 3177, 152, 8, 3297
31498, 3577, 257, 258, 2119
31499, 231, 230, 2725, 3644
31500, 3584, 261, 12, 3172
31501, 3298, 3, 27, 1386
31502, 3583, 89, 6, 1372
31503, 3468, 144, 2, 3296
31504, 3177, 8, 294, 3466
31505, 12, 262, 3469, 3172
31506, 3458, 118, 117, 893
31507, 3896, 151, 9, 3295
31508, 65, 320, 64, 3884
31509, 3297, 147, 8, 3466
31510, 3229, 164, 165, 3142
31511, 3896, 9, 171, 3188
31512, 3, 148, 3897, 3298
31513, 143, 2, 1375, 3468
31514, 11, 235, 3174, 3686
31515, 86, 323, 85, 3598
31516, 28, 3, 3897, 1386
31517, 3204, 199, 198, 3711
31518, 3838, 56, 55, 1402
31519, 7, 111, 1370, 3467
31520, 32, 31, 3891, 959
31521, 3685, 69, 4, 1371
31522, 94, 95, 1178, 3566
31523, 174, 175, 3881, 2761
31524, 256, 255, 3163, 3474
31525, 26, 25, 3283, 1340
31526, 204, 203, 3132, 3894
31527, 2936, 206, 205, 3879
31528, 155, 154, 3189, 3224
31529, 61, 62, 308, 3893
31530, 92, 93, 319, 3571
31531, 3153, 202, 201, 3816
31532, 219, 218, 2126, 3593
31533, 3118, 218, 217, 3673
31534, 176, 177, 3820, 3212
31535, 3420, 116, 115, 1347
31536, 3880, 63, 62, 1134
31537, 73, 72, 3672, 1331
31538, 231, 232, 3589, 3197
31539, 34, 33, 3718, 1410
31540, 3133, 220, 219, 3681
31541, 3700, 177, 178, 3195
31542, 86, 87, 919, 3675
31543, 24, 23, 3290, 1377
31544, 3293, 162, 163, 3179
31545, 1395, 84, 85, 3682
31546, 6175, 942, 1259, 1256
31547, 6175, 1259, 942, 4202
31548, 4890, 3163, 3107, 2107
31549, 4890, 3107, 3163, 4389
31550, 6180, 690, 5355, 4557
31551, 6180, 5355, 690, 4780
31552, 2504, 5647, 2740, 2607
31553, 2504, 2740, 5647, 4340
31554, 5394, 2740, 5647, 2607
31555, 5394, 5647, 2740, 4340
31556, 5669, 4722, 4236, 4417
31557, 5669, 4236, 4722, 5410
31558, 4864, 4462, 5941, 4056
31559, 4864, 5941, 4462, 3983
31560, 5186, 5941, 4462, 4056
31561, 5186, 4462, 5941, 3983
31562, 4915, 3693, 3839, 4395
31563, 4915, 3839, 3693, 3838
31564, 669, 4507, 670, 1342
31565, 670, 4507, 669, 4398
31566, 5455, 4198, 3968, 5423
31567, 5455, 3968, 4198, 5035
31568, 5004, 2194, 4932, 2195
31569, 5004, 4932, 2194, 4223
31570, 5263, 3500, 4138, 3501
31571, 5263, 4138, 3500, 4707
31572, 5276, 4343, 5093, 4188
31573, 5276, 5093, 4343, 4712
31574, 5717, 3973, 4916, 5193
31575, 5717, 4916, 3973, 4101
31576, 5131, 3413, 3444, 3412
31577, 5131, 3444, 3413, 4454
31578, 627, 4856, 5750, 700
31579, 5750, 4856, 627, 4185
31580, 4731, 5155, 5418, 2773
31581, 4731, 5418, 5155, 4257
31582, 2771, 5418, 5155, 2773
31583, 2771, 5155, 5418, 4257
31584, 5750, 700, 756, 709
31585, 5750, 756, 700, 4856
31586, 5736, 4611, 5766, 4090
31587, 5766, 4611, 5736, 4457
31588, 5766, 4914, 5736, 4090
31589, 5736, 4914, 5766, 4457
31590, 5554, 451, 4678, 452
31591, 5554, 4678, 451, 5003
31592, 5259, 5120, 6126, 529
31593, 5259, 6126, 5120, 4109
31594, 2812, 5085, 4526, 3067
31595, 4526, 5085, 2812, 4888
31596, 4526, 2817, 2812, 3067
31597, 2812, 2817, 4526, 4888
31598, 5247, 4262, 2459, 4788
31599, 5317, 4523, 494, 5167
31600, 5317, 494, 4523, 4679
31601, 4934, 2703, 5801, 4397
31602, 4934, 5801, 2703, 2706
31603, 4834, 5660, 4823, 2280
31604, 4823, 5660, 4834, 4093
31605, 803, 6030, 5650, 796
31606, 5650, 6030, 803, 5131
31607, 5666, 715, 809, 824
31608, 5666, 809, 715, 5204
31609, 5668, 6039, 4056, 5114
31610, 4056, 6039, 5668, 4804
31611, 5740, 3025, 2347, 2349
31612, 5740, 2347, 3025, 4430
31613, 3900, 4715, 4282, 4689
31614, 3900, 4282, 4715, 4785
31615, 5291, 3534, 3540, 3535
31616, 5291, 3540, 3534, 4090
31617, 5495, 5531, 4944, 4124
31618, 4944, 5531, 5495, 3294
31619, 5946, 3979, 4244, 4773
31620, 5946, 4244, 3979, 4963
31621, 5445, 4086, 3941, 4877
31622, 5445, 3941, 4086, 4983
31623, 5137, 5245, 5396, 4467
31624, 5396, 5245, 5137, 4105
31625, 5552, 3947, 5088, 4638
31626, 5552, 5088, 3947, 4321
31627, 5342, 5214, 6122, 4106
31628, 5342, 6122, 5214, 4452
31629, 5238, 4154, 2993, 4736
31630, 5238, 2993, 4154, 4798
31631, 4720, 5803, 3944, 4166
31632, 4720, 3944, 5803, 4273
31633, 5000, 3944, 5803, 4166
31634, 5000, 5803, 3944, 4273
31635, 5734, 4562, 4968, 3620
31636, 5734, 4968, 4562, 5395
31637, 5515, 5161, 5488, 4044
31638, 5515, 5488, 5161, 4823
31639, 4872, 4559, 5170, 3950
31640, 4872, 5170, 4559, 4072
31641, 5785, 4721, 4165, 4382
31642, 5785, 4165, 4721, 5616
31643, 5125, 3573, 3515, 3493
31644, 5125, 3515, 3573, 5078
31645, 5727, 3798, 5038, 3801
31646, 5727, 5038, 3798, 4116
31647, 5710, 5652, 4699, 4322
31648, 5710, 4699, 5652, 4087
31649, 4583, 5529, 5829, 3943
31650, 5829, 5529, 4583, 5293
31651, 5652, 4699, 3917, 4087
31652, 5652, 3917, 4699, 5118
31653, 5363, 2329, 4237, 4838
31654, 5363, 4237, 2329, 2484
31655, 3825, 335, 4410, 1095
31656, 3825, 4410, 335, 3697
31657, 5729, 4991, 2862, 4251
31658, 5729, 2862, 4991, 3045
31659, 2854, 2862, 4991, 4251
31660, 2854, 4991, 2862, 3045
31661, 5230, 3122, 2680, 3087
31662, 5230, 2680, 3122, 4299
31663, 5371, 698, 719, 652
31664, 5371, 719, 698, 4464
31665, 4593, 3343, 5713, 3462
31666, 4593, 5713, 3343, 4506
31667, 5245, 5376, 5137, 4105
31668, 6049, 4257, 4408, 5418
31669, 6049, 4408, 4257, 5586
31670, 3543, 5261, 3534, 3484
31671, 3534, 5261, 3543, 4606
31672, 5929, 5972, 4870, 3987
31673, 4870, 5972, 5929, 4116
31674, 5241, 5411, 4936, 3992
31675, 4936, 5411, 5241, 4353
31676, 4248, 4031, 4992, 4913
31677, 4248, 4992, 4031, 5993
31678, 5093, 5276, 5162, 3946
31679, 5162, 5276, 5093, 4188
31680, 4735, 5245, 4447, 3914
31681, 4447, 5245, 4735, 5024
31682, 4743, 3025, 5630, 2398
31683, 4743, 5630, 3025, 4430
31684, 5184, 2229, 6001, 2230
31685, 5184, 6001, 2229, 5552
31686, 6115, 4125, 6136, 4028
31687, 6136, 4125, 6115, 5098
31688, 6136, 5254, 6115, 4028
31689, 6115, 5254, 6136, 5098
31690, 5667, 2901, 2899, 2103
31691, 5667, 2899, 2901, 4462
31692, 5589, 1145, 848, 847
31693, 5589, 848, 1145, 4294
31694, 5054, 4327, 4049, 4378
31695, 5054, 4049, 4327, 5683
31696, 5077, 6151, 3506, 3579
31697, 3506, 6151, 5077, 4139
31698, 4626, 5150, 4866, 3982
31699, 4866, 5150, 4626, 4269
31700, 3094, 4983, 2831, 2832
31701, 5300, 5691, 2287, 2286
31702, 2287, 5691, 5300, 4289
31703, 3872, 5667, 3786, 3850
31704, 3786, 5667, 3872, 4462
31705, 5433, 2565, 4789, 4616
31706, 5433, 4789, 2565, 2507
31707, 4277, 501, 499, 1146
31708, 4277, 499, 501, 5317
31709, 4978, 454, 465, 455
31710, 4978, 465, 454, 4719
31711, 6080, 6187, 4517, 4207
31712, 4517, 6187, 6080, 4850
31713, 6037, 4427, 794, 5373
31714, 6037, 794, 4427, 5156
31715, 984, 5536, 4899, 997
31716, 4899, 5536, 984, 4123
31717, 4908, 5020, 5544, 3950
31718, 5544, 5020, 4908, 4356
31719, 5740, 2347, 2348, 2349
31720, 5740, 2348, 2347, 4561
31721, 4796, 3492, 344, 3572
31722, 4796, 344, 3492, 4539
31723, 4968, 3678, 3620, 4562
31724, 4968, 3620, 3678, 3618
31725, 5391, 6130, 5121, 4051
31726, 5121, 6130, 5391, 4233
31727, 5425, 1060, 5617, 1050
31728, 5425, 5617, 1060, 4288
31729, 6077, 2727, 3127, 4576
31730, 6077, 3127, 2727, 3208
31731, 5611, 4068, 6006, 4347
31732, 5611, 6006, 4068, 5422
31733, 4113, 5421, 6108, 4751
31734, 4113, 6108, 5421, 3674
31735, 3638, 6108, 5421, 4751
31736, 3638, 5421, 6108, 3674
31737, 5539, 1198, 1348, 1362
31738, 5539, 1348, 1198, 5027
31739, 5014, 3372, 5266, 3375
31740, 5014, 5266, 3372, 4641
31741, 5679, 2874, 4934, 4821
31742, 5679, 4934, 2874, 3151
31743, 4286, 4257, 5948, 5586
31744, 5948, 4257, 4286, 5807
31745, 5616, 5691, 4145, 4721
31746, 4145, 4979, 5616, 4721
31747, 5957, 3947, 5088, 4407
31748, 5957, 5088, 3947, 4638
31749, 6093, 4147, 4524, 4610
31750, 6093, 4524, 4147, 6005
31751, 5579, 2382, 5378, 2383
31752, 5579, 5378, 2382, 4536
31753, 5427, 2930, 4278, 3109
31754, 5427, 4278, 2930, 5252
31755, 2508, 4278, 2930, 3109
31756, 2508, 2930, 4278, 5252
31757, 5014, 3377, 4641, 3374
31758, 5014, 4641, 3377, 4422
31759, 6089, 2279, 2989, 4252
31760, 6089, 2989, 2279, 2276
31761, 5079, 3857, 3856, 3775
31762, 5079, 3856, 3857, 4435
31763, 4892, 985, 5500, 1222
31764, 4892, 5500, 985, 4311
31765, 5162, 5187, 5201, 4133
31766, 5201, 5187, 5162, 4117
31767, 5894, 5185, 5072, 378
31768, 5894, 5072, 5185, 4150
31769, 4827, 3361, 5272, 3370
31770, 4827, 5272, 3361, 4242
31771, 1015, 5232, 434, 1269
31772, 434, 5232, 1015, 4569
31773, 5351, 5926, 4466, 3998
31774, 4466, 5926, 5351, 5107
31775, 5952, 4309, 4630, 4001
31776, 5952, 4630, 4309, 5304
31777, 5046, 5628, 4487, 4000
31778, 4487, 5628, 5046, 5284
31779, 5962, 4160, 4021, 4881
31780, 5962, 4021, 4160, 5280
31781, 5755, 5150, 5602, 4269
31782, 5755, 5602, 5150, 4225
31783, 5618, 2403, 4998, 2423
31784, 5618, 4998, 2403, 4935
31785, 5387, 4808, 3916, 4511
31786, 5387, 3916, 4808, 5017
31787, 5230, 2680, 2247, 3087
31788, 5230, 2247, 2680, 4664
31789, 5405, 6118, 3917, 4883
31790, 3917, 6118, 5405, 4221
31791, 4957, 1044, 5636, 1045
31792, 4957, 5636, 1044, 4702
31793, 2673, 4242, 2690, 2627
31794, 2673, 2690, 4242, 4827
31795, 6163, 533, 1233, 607
31796, 6163, 1233, 533, 4178
31797, 5639, 3140, 6064, 2664
31798, 5639, 6064, 3140, 4640
31799, 5263, 3578, 3500, 3501
31800, 5263, 3500, 3578, 4640
31801, 5991, 5785, 2289, 4165
31802, 5311, 5268, 5961, 4135
31803, 5311, 5961, 5268, 938
31804, 5645, 1156, 4957, 4184
31805, 5645, 4957, 1156, 646
31806, 691, 4651, 5771, 1411
31807, 5771, 4651, 691, 4482
31808, 6026, 5289, 508, 793
31809, 6026, 508, 5289, 4270
31810, 4716, 6150, 4595, 4113
31811, 4595, 6150, 4716, 818
31812, 4431, 4215, 3979, 5164
31813, 3979, 4215, 4431, 5359
31814, 5725, 5257, 1382, 953
31815, 5725, 1382, 5257, 4124
31816, 4727, 4144, 489, 5373
31817, 4727, 489, 4144, 5471
31818, 1212, 489, 4144, 5373
31819, 1212, 4144, 489, 5471
31820, 6097, 536, 475, 1187
31821, 6097, 475, 536, 4644
31822, 590, 5673, 4447, 614
31823, 4447, 5673, 590, 4735
31824, 2285, 5300, 2284, 2286
31825, 2284, 5300, 2285, 4711
31826, 5570, 5655, 5274, 4157
31827, 5274, 5655, 5570, 3927
31828, 5679, 5806, 5810, 4105
31829, 5810, 5806, 5679, 4552
31830, 5575, 364, 6016, 4213
31831, 5575, 6016, 364, 447
31832, 5337, 1137, 5919, 1346
31833, 5337, 5919, 1137, 5031
31834, 5757, 563, 603, 565
31835, 5757, 603, 563, 4179
31836, 4896, 5745, 5200, 4109
31837, 5200, 5745, 4896, 4382
31838, 5117, 3633, 5105, 4291
31839, 5117, 5105, 3633, 3632
31840, 5562, 347, 896, 894
31841, 5562, 896, 347, 4582
31842, 5208, 5614, 6101, 3904
31843, 6101, 5614, 5208, 4115
31844, 2875, 5247, 2459, 2460
31845, 2459, 5247, 2875, 4262
31846, 4998, 5676, 3902, 4581
31847, 3902, 5676, 4998, 4761
31848, 6123, 3776, 4348, 5094
31849, 6123, 4348, 3776, 3865
31850, 5236, 4348, 3776, 5094
31851, 5236, 3776, 4348, 3865
31852, 5657, 4761, 5676, 4146
31853, 5657, 5676, 4761, 4061
31854, 5731, 5933, 5387, 4152
31855, 5321, 3202, 2148, 2677
31856, 5321, 2148, 3202, 4448
31857, 4467, 5376, 5245, 4187
31858, 5245, 5376, 4467, 5137
31859, 5552, 2227, 5184, 4654
31860, 5552, 5184, 2227, 2229
31861, 5889, 6164, 5023, 4803
31862, 5023, 6164, 5889, 4593
31863, 4000, 5934, 5021, 4312
31864, 5021, 5934, 4000, 4931
31865, 5486, 3510, 3564, 3582
31866, 5486, 3564, 3510, 4521
31867, 5618, 5627, 4989, 2962
31868, 4989, 5627, 5618, 4161
31869, 3736, 5045, 3823, 3734
31870, 3823, 5045, 3736, 4469
31871, 4894, 5917, 4691, 4196
31872, 4691, 5917, 4894, 513
