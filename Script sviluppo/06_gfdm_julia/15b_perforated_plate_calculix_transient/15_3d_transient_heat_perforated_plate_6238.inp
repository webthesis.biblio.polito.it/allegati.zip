4159, 0.78065571476901, 0.65247385135981, 0.032819110684837
4160, 0.43279887233796, 0.55754924310432, 0.066208729808024
4161, 0.81441306094541, 0.17075282631425, 0.067303620521282
4162, 0.81441306094541, 0.17075282631425, 0.032696379478718
4163, 0.85260107289551, 0.80308711386454, 0.033789988570151
4164, 0.52461707657247, 0.57190380284555, 0.032658235076432
4165, 0.52461707657247, 0.57190380284555, 0.067341764923569
4166, 0.66697732361982, 0.71233077653299, 0.067350641800488
4167, 0.63154732884042, 0.63921422710591, 0.034416561530654
4168, 0.840896210241, 0.47891604826685, 0.067235878120967
4169, 0.77587698816986, 0.077106738350361, 0.066819870392196
4170, 0.78064753552314, 0.65248480115933, 0.067379416596134
4171, 0.7385235357595, 0.47091208637752, 0.032804479662315
4172, 0.87248296022633, 0.077910736393631, 0.06522847051487
4173, 0.83880454742566, 0.56710990571014, 0.067119204447538
4174, 0.80726062388349, 0.49632136240168, 0.033285684657335
4175, 0.66353302437602, 0.40625056021954, 0.032565474944975
4176, 0.56144129959786, 0.5358971853015, 0.032420835285245
4177, 0.70960510367328, 0.31234193709973, 0.066336839419562
4178, 0.62645284295251, 0.44231842788113, 0.032420847491382
4179, 0.84069721512307, 0.4788993986085, 0.032673030501909
4180, 0.71841296684458, 0.56817169200757, 0.032711645167531
4181, 0.71841296684458, 0.56817169200757, 0.067288354832469
4182, 0.63231632966258, 0.85841944777157, 0.067819826653536
4183, 0.81083962393501, 0.43694496862497, 0.067242350359174
4184, 0.81083962393501, 0.43694496862497, 0.032757649640826
4185, 0.77521898376506, 0.07700316370219, 0.032881157834396
4186, 0.63421654280033, 0.3626395832521, 0.066842308892285
4187, 0.59465948805066, 0.40445186932094, 0.033220886533858
4188, 0.63007382591376, 0.74801193669023, 0.03239695252556
4189, 0.67035189787569, 0.3254577166707, 0.066938314664752
4190, 0.8733536954816, 0.50116695085544, 0.067210755119376
4191, 0.81186087811221, 0.22906243314072, 0.067335071011371
4192, 0.74767124083395, 0.69943084287759, 0.034245648256686
4193, 0.36996904165659, 0.56650624883005, 0.066744199943129
4194, 0.72845164696606, 0.79597143525173, 0.032460101571109
4195, 0.82998930713281, 0.033233117014956, 0.032797778099146
4196, 0.59434977657856, 0.48940695899873, 0.0339780264848
4197, 0.83237077810752, 0.36905039909116, 0.032499138335718
4198, 0.85165542250958, 0.63665104440073, 0.03295855389167
4199, 0.49935143028383, 0.79290798820404, 0.065951897920886
4200, 0.85800394632238, 0.80433038058323, 0.067118940953728
4201, 0.39414080371725, 0.5411402517342, 0.066184130326414
4202, 0.86140890219093, 0.43083031030159, 0.032379129587261
4203, 0.86264858325759, 0.42991001671467, 0.06694349838543
4204, 0.68652915299387, 0.61512079941576, 0.034037978988104
4205, 0.76359007186872, 0.17659258832716, 0.067614277639365
4206, 0.64027643332857, 0.19063715980016, 0.033140537905894
4207, 0.73762453519314, 0.28290682222767, 0.067557606200525
4208, 0.80988707293021, 0.28784176250565, 0.066690939093738
4209, 0.38104086680504, 0.5879975087595, 0.03354482447512
4210, 0.57098267473822, 0.60747779683691, 0.032820296839293
4211, 0.56243996853371, 0.69023159159237, 0.033566895936091
4212, 0.71528484058963, 0.36680270375153, 0.033000213579617
4213, 0.77006480844535, 0.13570794837329, 0.032704175016133
4214, 0.73619544933259, 0.12060290488797, 0.03257630075868
4215, 0.76101799429919, 0.40522492144374, 0.032921103748589
4216, 0.63758070984207, 0.60046973862338, 0.066194816533766
4217, 0.71687343296144, 0.72984801319446, 0.067239321177699
4218, 0.49694137119563, 0.50938758776025, 0.031966608410562
4219, 0.45980192404905, 0.73169676760923, 0.031943867167055
4220, 0.85997596415472, 0.7281653953101, 0.067414902147699
4221, 0.49999357126973, 0.47294006191553, 0.032012953219612
4222, 0.69702476532067, 0.17305378153521, 0.03319062509396
4223, 0.72018147162483, 0.41774352175118, 0.066768529320606
4224, 0.90135301819132, 0.79810714759492, 0.064204510531945
4225, 0.69625184336266, 0.1723054821322, 0.067290481784332
4226, 0.53636106339625, 0.46979723403641, 0.067947655463519
4227, 0.47006469118011, 0.56632610813133, 0.066605989681327
4228, 0.587685407844, 0.87952996355753, 0.066806565966607
4229, 0.42644126312863, 0.59779865557989, 0.032452451120342
4230, 0.86960619339794, 0.15280340992802, 0.03258900846938
4231, 0.58877609458341, 0.8301544089761, 0.032853382308445
4232, 0.49880355909072, 0.65661245875359, 0.0671467020181
4233, 0.77470927075908, 0.25931939235891, 0.033251436006043
4234, 0.79757608097184, 0.34661988042148, 0.067761909950291
4235, 0.73025953564701, 0.16990040933196, 0.067018192278121
4236, 0.7417181714978, 0.032381189676831, 0.067029602430881
4237, 0.52844757564932, 0.72417502027256, 0.067622340010996
4238, 0.80223849389802, 0.60842078455747, 0.032490778454528
4239, 0.76578219278352, 0.76326924220495, 0.03210009368119
4240, 0.52710786843818, 0.7615763895148, 0.031740073904583
4241, 0.7809924289196, 0.53223962901054, 0.033372501807199
4242, 0.64842546434806, 0.16074326741939, 0.067960938426959
4243, 0.85958621121313, 0.53386337370971, 0.066841299209761
4244, 0.71932625573538, 0.41632636050363, 0.032935341102766
4245, 0.66995805462604, 0.79180889029263, 0.066636262723139
4246, 0.67238294320762, 0.031818904397492, 0.067974016631395
4247, 0.78273207485347, 0.81401000177467, 0.063526881103923
4248, 0.70284387066585, 0.50545628487616, 0.03156790653439
4249, 0.68406836272702, 0.612597488343, 0.067020404319067
4250, 0.76913864087058, 0.30875254006787, 0.032723052782787
4251, 0.75317164873552, 0.60772295295298, 0.067508274232155
4252, 0.81495067529196, 0.69223635251522, 0.067546477229664
4253, 0.6605850607677, 0.26909023423741, 0.066935043506038
4254, 0.90685990059189, 0.64146375382726, 0.033080006060552
4255, 0.53579697775079, 0.81693890599883, 0.032786113464083
4256, 0.88378964910275, 0.75198981183581, 0.066442613655441
4257, 0.88642812520323, 0.20832584211123, 0.065988982129311
4258, 0.84150322851432, 0.29877421534036, 0.067678191893258
4259, 0.8217715877373, 0.72897130441951, 0.032137537281237
4260, 0.58041908186657, 0.44309130311757, 0.032738571667698
4261, 0.83262165796387, 0.33257092108777, 0.032468220739538
4262, 0.63224009171309, 0.30700203015278, 0.067010502041984
4263, 0.52045465345241, 0.60477104885889, 0.032432018544725
4264, 0.72438414721312, 0.79293191635992, 0.067621924264791
4265, 0.53596685703807, 0.51583831023954, 0.067619215081223
4266, 0.80135668269366, 0.75838163124734, 0.067976764761759
4267, 0.64734887474492, 0.68589533947741, 0.032525193131963
4268, 0.81070441421026, 0.40389736372755, 0.032726206458286
4269, 0.68469289061453, 0.20305186552256, 0.0672235606718
4270, 0.53545339830495, 0.51596884274004, 0.032222221313104
4271, 0.80451419433454, 0.62970700325481, 0.067391364007841
4272, 0.5953220594474, 0.49624537823479, 0.067967782719187
4273, 0.66241792335518, 0.7449069996984, 0.06750680344116
4274, 0.66520634844122, 0.84484045805877, 0.032443524363185
4275, 0.45509780811839, 0.64307982261315, 0.067933043050896
4276, 0.74915977654429, 0.70113251963002, 0.067116703712046
4277, 0.84032400949445, 0.12613622475704, 0.032050047225544
4278, 0.69058635123045, 0.25539450939229, 0.068499394969879
4279, 0.80375658491905, 0.40472322379932, 0.067221643243818
4280, 0.55778971999331, 0.56832029678809, 0.067697569992677
4281, 0.90314085760184, 0.15859270530351, 0.067625686002978
4282, 0.68417916639552, 0.2031676793316, 0.032636272338956
4283, 0.70727263071351, 0.082264748638062, 0.068715050628503
4284, 0.55788190399352, 0.5684163958648, 0.032263451391503
4285, 0.59890788021328, 0.3102858848842, 0.068343025442195
4286, 0.87003754759211, 0.20854851612303, 0.035147102508348
4287, 0.74232295144968, 0.0711129063269, 0.031103959296268
4288, 0.76802378460637, 0.59647020276435, 0.032088011383779
4289, 0.52014647360028, 0.60420426134382, 0.067713285658853
4290, 0.75606735557495, 0.42014073710815, 0.06771840057918
4291, 0.59104116840211, 0.87790467639191, 0.033265608227068
4292, 0.7479483643976, 0.22662123486931, 0.067453447635744
4293, 0.78412660889472, 0.56023168235965, 0.068659740370355
4294, 0.81470981628637, 0.77959504356179, 0.032372663049395
4295, 0.73604036936083, 0.34094306573101, 0.032219974331258
4296, 0.90779414101744, 0.26796344171744, 0.03178155401133
4297, 0.88393868380334, 0.38822057356114, 0.032096960367362
4298, 0.54916106784386, 0.76951553706609, 0.067604474924158
4299, 0.79130269008377, 0.19367729552928, 0.067870815325903
4300, 0.58726055904693, 0.82964835506948, 0.06785242016453
4301, 0.60606196005728, 0.57238435933476, 0.068010028554622
4302, 0.58726375410865, 0.77980394288677, 0.067834404008907
4303, 0.8740581237024, 0.34553253393329, 0.06819914899991
4304, 0.84024597476944, 0.25127662979277, 0.068430257911247
4305, 0.79127261248529, 0.19366997234044, 0.03214740041086
4306, 0.71214292286145, 0.75492666373947, 0.032501281152709
4307, 0.81424610746589, 0.63877565897591, 0.031083689055615
4308, 0.63616736072921, 0.31077522426192, 0.031292716416543
4309, 0.76424833152467, 0.79576173760951, 0.031012003526704
4310, 0.86645650547685, 0.60740074368261, 0.031833271915664
4311, 0.48100913899298, 0.64012726913538, 0.032246693396863
4312, 0.86522389846328, 0.032495280436282, 0.067009961675103
4313, 0.8691264066954, 0.03541382072566, 0.033608416489137
4314, 0.68338957807451, 0.07128482874351, 0.032672886113056
4315, 0.44727230300363, 0.4958998774292, 0.032316487721743
4316, 0.43593379334226, 0.6910343780671, 0.067967222302432
4317, 0.87238628823567, 0.51076873340456, 0.03268016572159
4318, 0.90582672816361, 0.10937062856763, 0.066855904737438
4319, 0.68245604389627, 0.36251587009603, 0.030801463415818
4320, 0.89405566398621, 0.58105409541516, 0.031668420510305
4321, 0.64706546628972, 0.68692591545128, 0.067965493531884
4322, 0.52845689100275, 0.45714383307234, 0.031412169276174
4323, 0.65092081894064, 0.23091217119384, 0.032615763313915
4324, 0.86705784258857, 0.70319430075525, 0.032817325295378
4325, 0.85232446514673, 0.39748080314349, 0.032285466334596
4326, 0.82299906269445, 0.52461172791991, 0.031235534626724
4327, 0.54637551581263, 0.419909297955, 0.067713260470207
4328, 0.81000159246237, 0.058054723837386, 0.030512171166483
4329, 0.78752621195188, 0.46450439641632, 0.03069939811927
4330, 0.81965895154779, 0.13655329331716, 0.069578205118145
4331, 0.90757096125321, 0.46240708642377, 0.031550026765656
4332, 0.89965101333538, 0.78864989851023, 0.032279705289037
4333, 0.64701722170746, 0.50541053209737, 0.031983108251983
4334, 0.9085117073961, 0.1687057303395, 0.032352510696835
4335, 0.84765220146786, 0.77409421919566, 0.068839490478962
4336, 0.695306434763, 0.39222583693299, 0.031368200732793
4337, 0.78451030602963, 0.10739176438149, 0.030863225895415
4338, 0.65685396685932, 0.11380473023746, 0.067663957270061
4339, 0.67529668481076, 0.43933042633532, 0.030991864417045
4340, 0.82635510111133, 0.068910161557038, 0.069440843388844
4341, 0.41225885665392, 0.64973319276234, 0.032430071379073
4342, 0.73497025785072, 0.52024631916588, 0.068387979922908
4343, 0.66189932815698, 0.74397518615055, 0.031822689753158
4344, 0.78228447988667, 0.031041485782619, 0.068884014711739
4345, 0.64088707924973, 0.27904264032147, 0.031503832474484
4346, 0.69889239320831, 0.71024419970947, 0.031428916322554
4347, 0.6395616899029, 0.52219711741471, 0.068248808933665
4348, 0.90662901853894, 0.51136280604158, 0.067202278375829
4349, 0.90929636732605, 0.03091403258831, 0.030872809476293
4350, 0.8727423783226, 0.068157395491948, 0.030808671624599
4351, 0.90667188159491, 0.32007413925588, 0.067228588052972
4352, 0.5584767550242, 0.3668294596089, 0.033200283652344
4353, 0.61871969861047, 0.82501247418184, 0.069257825363657
4354, 0.55702255801496, 0.4212202331564, 0.030824583598173
4355, 0.79768932693347, 0.29375065146182, 0.031738392374139
4356, 0.76144681474054, 0.78541958191257, 0.068724738742062
4357, 0.74099682372662, 0.54047050807182, 0.030285697894802
4358, 0.79361414794559, 0.4831029770135, 0.068901500567751
4359, 0.71939455878167, 0.45506959688721, 0.06878388988078
4360, 0.6189852954337, 0.82076536924789, 0.031405620599044
4361, 0.67648825559648, 0.35649885146017, 0.068496694110182
4362, 0.77782374053987, 0.37800025681487, 0.031297532752065
4363, 0.68180381342437, 0.48279971804981, 0.068592592192075
4364, 0.74686599432365, 0.64741427161784, 0.030199133216217
4365, 0.72971781819355, 0.83076225196762, 0.069837915768602
4366, 0.70005454496717, 0.11732343411546, 0.031506274828698
4367, 0.77584837198011, 0.68556545025927, 0.030454152123526
4368, 0.86894833628264, 0.39762633486286, 0.068581739519952
4369, 0.71451459366754, 0.60104032687186, 0.030449779008973
4370, 0.49812719802925, 0.47825458982887, 0.068261699242646
4371, 0.68421781833291, 0.64390797131548, 0.069935465839326
4372, 0.76497768273347, 0.44214500852497, 0.031409944185569
4373, 0.65645084178715, 0.55868544870822, 0.03089722502021
4374, 0.60047238584126, 0.64114388134842, 0.03106754967506
4375, 0.84292473733391, 0.67758774489781, 0.069181858489221
4376, 0.6086489659108, 0.72707969093507, 0.058666237928265
4377, 0.60069767619716, 0.6715004272337, 0.069564762437937
4378, 0.51320017703978, 0.42300424139003, 0.069927140282756
4379, 0.83930061973383, 0.25987622878342, 0.031469607426232
4380, 0.6911214162695, 0.54061332916427, 0.069041946430489
4381, 0.78457751879341, 0.52879444166516, 0.069352098137071
4382, 0.49876542905383, 0.55482983416635, 0.069645492278929
4383, 0.84777872887274, 0.77216421186458, 0.030933557672975
4384, 0.62232391924238, 0.23378629875831, 0.069848483149042
4385, 0.87525168038052, 0.55559752113105, 0.031820536385187
4386, 0.62369683543614, 0.27648791099111, 0.070172596152333
4387, 0.88699439458887, 0.59539670718445, 0.069133627118875
4388, 0.72794992291199, 0.15120771949799, 0.031012943814901
4389, 0.40639952186782, 0.64521430850139, 0.070090605580452
4390, 0.68977705014435, 0.8250561101795, 0.031554354209966
4391, 0.90820146673354, 0.071495942171906, 0.068513521592568
4392, 0.85970936697053, 0.29645243339113, 0.030201755379762
4393, 0.82884186835288, 0.53744527154555, 0.070483746932408
4394, 0.65699041273182, 0.10986992113956, 0.030817183701893
4395, 0.90810883204846, 0.55293519737277, 0.034073110886095
4396, 0.86783007194022, 0.34593620210428, 0.031340386370543
4397, 0.5562107231046, 0.36864515897038, 0.06771973746858
4398, 0.44373555258239, 0.5475956472731, 0.030113661077466
4399, 0.56650329224408, 0.80912754136941, 0.030029387908042
4400, 0.63677670498875, 0.39316537731625, 0.069298041032389
4401, 0.73314220496443, 0.67492793570494, 0.069878060374504
4402, 0.68346802666113, 0.29584158286344, 0.069488212906916
4403, 0.87814405576266, 0.30669626934582, 0.069998461774299
4404, 0.65584149751986, 0.23858770842342, 0.068444858158535
4405, 0.53549049923678, 0.39158217493421, 0.071645486624501
4406, 0.74751273858917, 0.73177657427208, 0.070095941974877
4407, 0.69362776804557, 0.69722273208833, 0.070304753262626
4408, 0.86513229114208, 0.231628131398, 0.069028955113353
4409, 0.55090227398352, 0.85646459660553, 0.068566125738411
4410, 0.90956041165528, 0.36725073786282, 0.03042784341318
4411, 0.63667002538142, 0.63073553329566, 0.071076475462233
4412, 0.68715713422077, 0.12391983368825, 0.06883124068442
4413, 0.90885016695973, 0.43108181798317, 0.030925730584971
4414, 0.56096283870296, 0.65990229374157, 0.029941351134825
4415, 0.41379429143156, 0.51888124020618, 0.070569802114394
4416, 0.61865839416264, 0.4765994647981, 0.070416976384232
4417, 0.71002475389776, 0.030406296659998, 0.06931836704354
4418, 0.8373544094322, 0.44868748019618, 0.043031524971995
4419, 0.84899443473376, 0.1277843799578, 0.069550476966593
4420, 0.90112330465498, 0.67504277893143, 0.068221253674139
4421, 0.8748401514607, 0.67358028642691, 0.029757862150838
4422, 0.61249911251529, 0.26291905924197, 0.03097730410541
4423, 0.9097037392104, 0.73474107805843, 0.068840362516805
4424, 0.91000588988066, 0.18886042930367, 0.060889161257834
4425, 0.6395769864511, 0.60954237745846, 0.029056855993081
4426, 0.79544828579736, 0.10160067082756, 0.071588759034279
4427, 0.47629777797518, 0.56986721302624, 0.029123081651313
4428, 0.90805183178819, 0.51712139387738, 0.030878955141991
4429, 0.47492208844866, 0.6869685208089, 0.071048252128492
4430, 0.84275337175333, 0.59735589982735, 0.069420742483317
4431, 0.74611838952938, 0.37302813797572, 0.028673772944647
4432, 0.64260209778066, 0.36387009181733, 0.029112866577725
4433, 0.90960443353417, 0.35083253294764, 0.06998641786881
4434, 0.70801023843758, 0.22181010390162, 0.028547081229203
4435, 0.90874046907678, 0.47981884722306, 0.069810082936386
4436, 0.62129849202194, 0.22975281298505, 0.028093053189372
4437, 0.47969102675086, 0.46044725911371, 0.051361230676854
4438, 0.52784926681676, 0.65251891162255, 0.069973222652939
4439, 0.91029913492066, 0.22826590811371, 0.070971983445899
4440, 0.66519905547578, 0.5894587630214, 0.071111532681265
4441, 0.69427276161948, 0.67497875450686, 0.028189449395463
4442, 0.46816200993204, 0.51707295207769, 0.028372371493281
4443, 0.64564137800284, 0.16073485243876, 0.029624709460768
4444, 0.56845190374221, 0.85351007333934, 0.029633338039066
4445, 0.76261990969195, 0.026581862049229, 0.034300536652522
4446, 0.87699993597879, 0.26031581615359, 0.03104459315118
4447, 0.63602666515253, 0.39399010590212, 0.030201155019478
4448, 0.91158839461086, 0.028699822666359, 0.071286029038719
4449, 0.53537214401983, 0.39149562005237, 0.028096854113043
4450, 0.4730416084084, 0.51866283465837, 0.071753437988286
4451, 0.64134794996842, 0.55200996627299, 0.071678270201084
4452, 0.77057928509368, 0.22901178492277, 0.029749982981049
4453, 0.5899318019236, 0.52560041317797, 0.070238479588506
4454, 0.49711039432353, 0.43935285964041, 0.02974008506249
4455, 0.46184637105538, 0.59451274074783, 0.071631391709135
4456, 0.61089107670775, 0.55180469083187, 0.02860781435364
4457, 0.4841122321088, 0.71594673053562, 0.072119345332145
4458, 0.7187253513913, 0.31617617598485, 0.028896573278405
4459, 0.80625101617899, 0.56623091730708, 0.028280089333928
4460, 0.87068027456803, 0.48077641071886, 0.0286735381212
4461, 0.76517405279304, 0.48470639493544, 0.030040186558265
4462, 0.91014067557376, 0.42339226621055, 0.070749139249695
4463, 0.67468461995982, 0.39263762085808, 0.07092145379967
4464, 0.87222758358919, 0.12324661043833, 0.028303882960364
4465, 0.8491145159002, 0.17132987382626, 0.071437683316187
4466, 0.74714671426889, 0.33327889779589, 0.07152506344648
4467, 0.58747569941228, 0.37515278045517, 0.029011707184639
4468, 0.51259075499514, 0.68997112584181, 0.027872117142375
4469, 0.9093753514038, 0.11234722765689, 0.028972949555552
4470, 0.82716887452238, 0.69079722532487, 0.028209735266878
4471, 0.88139337029592, 0.31889960381632, 0.030256921368387
4472, 0.74591463491767, 0.82984120360127, 0.027666642424871
4473, 0.39055921644521, 0.61666198502044, 0.030006429917433
4474, 0.837546971769, 0.20708240513995, 0.029034989911595
4475, 0.70565525381879, 0.028605026744588, 0.030232408625229
4476, 0.60742284807271, 0.72581982677514, 0.029333057498581
4477, 0.74203817824756, 0.19732258419967, 0.070256041715063
4478, 0.87490023133071, 0.55951132995184, 0.070397238200078
4479, 0.90995301338754, 0.76862175344654, 0.069298965817253
4480, 0.65556836631963, 0.8412261857888, 0.072313231867623
4481, 0.76197390013853, 0.26617313278261, 0.071952742481589
4482, 0.60140338335865, 0.3487478258644, 0.031790363001354
4483, 0.87854101824701, 0.12171791190407, 0.070585249935517
4484, 0.59338772691922, 0.78877641500302, 0.027774129414853
4485, 0.5199152026799, 0.73335374340678, 0.028874047432486
4486, 0.91085625558217, 0.72787596056017, 0.029748123758474
4487, 0.90340849891749, 0.06023268769843, 0.029916109608712
4488, 0.56907741885073, 0.33960124793913, 0.027705797575771
4489, 0.60694423794835, 0.34979661289743, 0.069780524271889
4490, 0.57670156725954, 0.3303789703565, 0.070410397184922
4491, 0.40724167325647, 0.51962198798876, 0.026155540210494
4492, 0.91007455390047, 0.61390068857258, 0.069950942634282
4493, 0.46137176523923, 0.59779275351729, 0.027393681254778
4494, 0.91011142105354, 0.54096663668956, 0.069844219587638
4495, 0.43245860195774, 0.62517687685695, 0.071153830740393
4496, 0.77388088285242, 0.58746354031319, 0.071224703878383
4497, 0.6060122067166, 0.60829391888329, 0.072917958109605
4498, 0.74666205338407, 0.37640646910529, 0.071897121254094
4499, 0.58743503516014, 0.45055025878054, 0.072787756471273
4500, 0.9102543742441, 0.4016641726655, 0.034019933546438
4501, 0.61534583183085, 0.77348976222719, 0.071889850092377
4502, 0.80250049584366, 0.79208720625181, 0.072704154305126
4503, 0.87851274496974, 0.80788680150998, 0.046536057780466
4504, 0.88008673703623, 0.47276183781901, 0.072098547902917
4505, 0.78364014182983, 0.73188030384147, 0.072787810512223
4506, 0.65781888063296, 0.082084851219202, 0.042318205937913
4507, 0.4159684197083, 0.55700230255049, 0.02892103919467
4508, 0.55649086229981, 0.89826503791938, 0.070195295506483
4509, 0.64363677642049, 0.33565565156559, 0.071172448906023
4510, 0.6362053215612, 0.1870273740397, 0.071704749543629
4511, 0.55656000638266, 0.49649912071862, 0.073010573022824
4512, 0.75264925600648, 0.11835180062938, 0.071933191285855
4513, 0.87982201726832, 0.63273204335123, 0.02723429629913
4514, 0.56922900848801, 0.61805645652168, 0.071377339294044
4515, 0.9104489304298, 0.23440330411736, 0.02905634881849
4516, 0.52997937023676, 0.68858374450793, 0.071529568587641
4517, 0.71921674605211, 0.26051420401119, 0.071020004183541
4518, 0.7959027382545, 0.26310957472463, 0.07234196284456
4519, 0.66611763901703, 0.50663384966361, 0.072675910070665
4520, 0.7723132915139, 0.16815451190801, 0.026968431152282
4521, 0.47935493999568, 0.77139244175086, 0.068563647163785
4522, 0.45226092927318, 0.4828517733663, 0.072924204334935
4523, 0.7997562868127, 0.14683238111699, 0.027637307341114
4524, 0.56147775859033, 0.75618532301945, 0.027711482005924
4525, 0.74626397469791, 0.56219568556019, 0.07253270915684
4526, 0.75867629126289, 0.50395169628069, 0.071703648822192
4527, 0.70282154087414, 0.81971345205907, 0.071373298916923
4528, 0.84259409911457, 0.45031290215242, 0.071472218112059
4529, 0.46763821348391, 0.47470771793886, 0.028311584475306
4530, 0.81164290701283, 0.099532784088323, 0.028007225407816
4531, 0.83708146327986, 0.039876615816642, 0.070761845036997
4532, 0.67610344350743, 0.15112824964486, 0.070672815870772
4533, 0.55326496184474, 0.72509928309523, 0.02720647750215
4534, 0.91052127320997, 0.31835445761521, 0.031277218554979
4535, 0.88111495696662, 0.45143432324838, 0.027461065471344
4536, 0.82642418565556, 0.32278734569048, 0.071942151275815
4537, 0.90935840032935, 0.70435850215907, 0.065293694015939
4538, 0.44733687828936, 0.53332393373653, 0.072136703395429
4539, 0.553095262619, 0.90199698283086, 0.029228506507831
4540, 0.48102023355426, 0.63493505195145, 0.06005656689342
4541, 0.5446607428669, 0.78463973115519, 0.026564372194721
4542, 0.48663441863388, 0.74346521430256, 0.029248801544951
4543, 0.77464841628197, 0.36367392425205, 0.071262702217799
4544, 0.6936984361742, 0.47172825824244, 0.027416161911402
4545, 0.74777352014412, 0.45289165923839, 0.071661745797986
4546, 0.87677970184784, 0.25896223120763, 0.070976668990038
4547, 0.78325872411729, 0.44176203358856, 0.0726831544009
4548, 0.51461565993001, 0.83653821790521, 0.028614412701148
4549, 0.64865308406324, 0.65811442065931, 0.026447047950025
4550, 0.75991825222594, 0.73587870346899, 0.027686610988819
4551, 0.79919915298522, 0.062969630055708, 0.073653922103456
4552, 0.60880137488491, 0.41705554246949, 0.073640724753248
4553, 0.57554158712299, 0.46999117095088, 0.026632750037437
4554, 0.46421554908825, 0.68046782547, 0.027309859715423
4555, 0.66380835757029, 0.31450627593205, 0.027194210189299
4556, 0.81130376184583, 0.56619298729488, 0.073407309389876
4557, 0.429157976569, 0.62532398120798, 0.027934755786093
4558, 0.68494146669392, 0.14716617125881, 0.028021411186227
4559, 0.72618574189189, 0.75571643017736, 0.073214958084021
4560, 0.7601900117091, 0.2997022213274, 0.072192443935518
4561, 0.81579894746179, 0.60457782166914, 0.073303050998491
4562, 0.81496142334005, 0.81653095472421, 0.074225864231658
4563, 0.77015745993833, 0.15012471346842, 0.074023771059334
4564, 0.64914813997562, 0.42859165648912, 0.041304496341412
4565, 0.71960033212249, 0.49738121357073, 0.073757139160334
4566, 0.67731581116724, 0.51552419216655, 0.026173956024045
4567, 0.58062101609979, 0.69163454483143, 0.073057639510037
4568, 0.7155341935917, 0.065837615568941, 0.026012024162611
4569, 0.76217874284528, 0.51247335304841, 0.026407416443556
4570, 0.70282532349297, 0.78622213638878, 0.026534189142917
4571, 0.65558239463788, 0.46931893899088, 0.026258234752858
4572, 0.54522858018385, 0.61613411600009, 0.026623384881065
4573, 0.6638311359232, 0.4417563427416, 0.072843413457132
4574, 0.83462079592924, 0.73928459037323, 0.072311062767027
4575, 0.78575109491986, 0.7220987828126, 0.027502589172026
4576, 0.75633945690975, 0.82935448274855, 0.073668885723011
4577, 0.75145908469034, 0.56626244620859, 0.026432165591516
4578, 0.69380731996961, 0.28178683399671, 0.026666292516822
4579, 0.69177822364978, 0.050975751612222, 0.073435361523885
4580, 0.86565268670783, 0.66158110924266, 0.072681960655896
4581, 0.82992340217738, 0.20894290204254, 0.073263113536909
4582, 0.35428922892045, 0.56019608033108, 0.027168546438893
4583, 0.8009049783882, 0.26645495312241, 0.026459319403061
4584, 0.68368311530739, 0.57528099358603, 0.027022111302193
4585, 0.63788334159034, 0.80091843206359, 0.026696560127458
4586, 0.45312395209152, 0.67009342945485, 0.073711294420138
4587, 0.76365364414537, 0.6256653043773, 0.026095773874606
4588, 0.65356132431571, 0.81344981269718, 0.072854440875187
4589, 0.81876745968466, 0.65569387398186, 0.074084168967929
4590, 0.52521383290159, 0.80241332680371, 0.074009280828336
4591, 0.51231960018337, 0.50341682127392, 0.0742381373056
4592, 0.72181377511603, 0.6932514385058, 0.026404034273837
4593, 0.65708511611006, 0.085928475331463, 0.072963944566542
4594, 0.69156088433866, 0.57111665757254, 0.072883297344397
4595, 0.61012155287836, 0.84644765407471, 0.026242047655915
4596, 0.83925813478925, 0.60596739573458, 0.026431419048479
4597, 0.73699804180119, 0.095613090288263, 0.07450272636805
4598, 0.76958713499283, 0.33614118794447, 0.026776519383025
4599, 0.62951351521883, 0.58409800733169, 0.02602522329422
4600, 0.85240649168314, 0.096282044855612, 0.074424920662902
4601, 0.71789455834485, 0.62801927631545, 0.025891113784926
4602, 0.84867313392524, 0.72343352040123, 0.027522419960772
4603, 0.68412354066729, 0.33368559776968, 0.026018227675727
4604, 0.48792405721052, 0.44675261770523, 0.074048434374092
4605, 0.54681909660212, 0.82549219444236, 0.073210224172801
4606, 0.45098397930396, 0.72825233904425, 0.073022371046079
4607, 0.78394824680997, 0.61307746448772, 0.075000299668523
4608, 0.57246820090447, 0.75912172642366, 0.057735320371269
4609, 0.70332898069305, 0.3523183604637, 0.073906032278045
4610, 0.58814442041382, 0.7619956354647, 0.026400629449624
4611, 0.49552185212254, 0.74393577516116, 0.072811704099918
4612, 0.39646109691425, 0.57182851422593, 0.074402720846069
4613, 0.5200720022607, 0.53772973660232, 0.026746159123879
4614, 0.87550327204501, 0.095582758623452, 0.02631333802061
4615, 0.91242660119386, 0.29335021502158, 0.073313646165035
4616, 0.69153783259038, 0.2285869323605, 0.074434587698187
4617, 0.57616707482016, 0.85295161702071, 0.057381122279475
4618, 0.72039000527932, 0.14425992604697, 0.072413956626371
4619, 0.69618821383562, 0.42831889753878, 0.074947578396347
4620, 0.85439074234032, 0.57290584542349, 0.026367992717906
4621, 0.76095990942636, 0.28273057596713, 0.02645239582441
4622, 0.76332874365262, 0.19406953065414, 0.025588276140254
4623, 0.88083178549267, 0.63733962383317, 0.073809651411298
4624, 0.7897520984018, 0.060193850679714, 0.04840139168343
4625, 0.53171178552677, 0.44291566892578, 0.067651777450881
4626, 0.71091382100909, 0.20819667121243, 0.074081127974098
4627, 0.55614599285107, 0.59447471170791, 0.075041702951355
4628, 0.82648054055252, 0.80334168623249, 0.025988399515364
4629, 0.82583925152126, 0.23646635767939, 0.026292750717963
4630, 0.76987518594255, 0.82179052368527, 0.039837104912228
4631, 0.79629774504359, 0.31060392378493, 0.07334047004921
4632, 0.60326345358412, 0.42964619718159, 0.039351278976679
4633, 0.76373120586901, 0.63207288732888, 0.073710900387002
4634, 0.43438773209616, 0.51897371247641, 0.026077835752318
4635, 0.55472293205824, 0.72592899314598, 0.073861187789187
4636, 0.44085108437824, 0.71334485770224, 0.026176339017447
4637, 0.84897026872906, 0.36534862372404, 0.073455814952652
4638, 0.67722892791733, 0.66990185939102, 0.073512605918282
4639, 0.81548291166231, 0.36837389905231, 0.073242829549841
4640, 0.52360683644327, 0.85219513099079, 0.072716238709934
4641, 0.60938905705385, 0.25366557844136, 0.057080347121084
4642, 0.52112677022764, 0.53756590441261, 0.073488793425191
4643, 0.61429540130157, 0.51452092263582, 0.074026038600607
4644, 0.80149147606586, 0.67737616223436, 0.026948226331366
4645, 0.79734309670048, 0.15096276862316, 0.073408917406678
4646, 0.8777728262677, 0.37215857307682, 0.073269731735691
4647, 0.68596782524586, 0.24319279017948, 0.026916781416051
4648, 0.59698318954018, 0.28309304494701, 0.073108903710718
4649, 0.73172534043375, 0.19636996421144, 0.026836610872445
4650, 0.71478089766753, 0.6456240583516, 0.074507094382896
4651, 0.61437112064566, 0.32579439613723, 0.025885458479961
4652, 0.76051688635725, 0.057008479815204, 0.075229640497486
4653, 0.71963559673149, 0.3911840055907, 0.072875539404844
4654, 0.62895054962916, 0.65645567689221, 0.073387355577347
4655, 0.66487438942778, 0.53691296282474, 0.073855476227175
4656, 0.87848187117728, 0.76550892845219, 0.026993373238975
4657, 0.66096354671907, 0.18581030696195, 0.075443613807057
4658, 0.56633401323579, 0.49896056355346, 0.024735644065266
4659, 0.6180721103039, 0.66070281293304, 0.025432247135902
4660, 0.70543542659786, 0.53170349432617, 0.026116543803614
4661, 0.79308483969723, 0.32002659525857, 0.026593364595766
4662, 0.74065696894603, 0.75480526027454, 0.026658513537569
4663, 0.85231954094117, 0.70276082592257, 0.073373033405765
4664, 0.77716992478649, 0.21655634240175, 0.073228338996639
4665, 0.74013827888482, 0.59320744714501, 0.026824139779943
4666, 0.69690308069276, 0.79023570846097, 0.074901190228336
4667, 0.64377628569104, 0.46258107012287, 0.073448854705827
4668, 0.56261015013139, 0.44034465973475, 0.074119050886831
4669, 0.57148835786679, 0.40481734686375, 0.072889424536317
4670, 0.74402625036025, 0.42525879022352, 0.026001893291156
4671, 0.59663973293837, 0.60749377557561, 0.024557695867074
4672, 0.91371655577698, 0.59921883866603, 0.025988514491123
4673, 0.66125064804655, 0.6307419106383, 0.024732389202419
4674, 0.66004021329604, 0.056909912366767, 0.02705855639726
4675, 0.91313504898892, 0.5922036937179, 0.053733442520268
4676, 0.67669079123855, 0.76679556301131, 0.073864826778171
4677, 0.84520617814343, 0.41029286525694, 0.073314502450889
4678, 0.58777687073876, 0.69402621453883, 0.025875405897248
4679, 0.82628384672399, 0.14790669704746, 0.026015448554542
4680, 0.84964132598472, 0.52408273281325, 0.026595186635324
4681, 0.59390322296923, 0.28856485421847, 0.025505585654465
4682, 0.56105477421597, 0.64321104361235, 0.075058550614534
4683, 0.70841538307098, 0.84280478965068, 0.059430704927054
4684, 0.5011765146603, 0.81785699781015, 0.074636636634544
4685, 0.52885719375876, 0.66639134410082, 0.026175471286018
4686, 0.75793387200094, 0.050743386568462, 0.024430907503229
4687, 0.70202342789378, 0.64948596967482, 0.026440543375578
4688, 0.88489714834837, 0.77800798250313, 0.074474651440722
4689, 0.66803096364493, 0.18058671237151, 0.02388953442025
4690, 0.74153310692513, 0.2463236010344, 0.024744330169584
4691, 0.60687849140511, 0.46784434220125, 0.024846075655005
4692, 0.5788697013501, 0.58320842734441, 0.025282814293025
4693, 0.75982708707978, 0.67786869963778, 0.075340019765774
4694, 0.75599717328045, 0.093055867403637, 0.024523932293455
4695, 0.56540438928352, 0.71996614175597, 0.05022305196849
4696, 0.79767313204212, 0.67202574441361, 0.073713353336358
4697, 0.81825463529895, 0.75432181765046, 0.024353401941505
4698, 0.55549701377276, 0.45288807828053, 0.024512077723134
4699, 0.52931797904491, 0.49121364843866, 0.025235729981138
4700, 0.83642383679006, 0.05998819667045, 0.026487076699781
4701, 0.62036419216926, 0.87359637005771, 0.049739200337631
4702, 0.78603720864855, 0.41209093906882, 0.026403805947937
4703, 0.73578576787354, 0.58731188761414, 0.073814560076234
4704, 0.89564297291134, 0.40041873389238, 0.073717634358807
4705, 0.64638037329985, 0.77630665170619, 0.075442800882834
4706, 0.6174850205802, 0.5187593224883, 0.025035080509824
4707, 0.53550655207412, 0.87687505113788, 0.057860422649443
4708, 0.5908025269465, 0.80472341064797, 0.076047279867754
4709, 0.8322224704466, 0.27511992734718, 0.059558726778992
4710, 0.74620187498417, 0.67431815881766, 0.025766435941725
4711, 0.51660138980096, 0.62924631217973, 0.075139158212276
4712, 0.6579194068551, 0.77079070192871, 0.024530380361607
4713, 0.66275371377035, 0.62936943174197, 0.074952960237474
4714, 0.70978268459329, 0.34133663821089, 0.026778201642178
4715, 0.65931467930668, 0.20676376302355, 0.02430920079985
4716, 0.64093904329757, 0.83345837533274, 0.025081811441403
4717, 0.85810548545722, 0.057498614595659, 0.075518740624255
4718, 0.50629266830681, 0.63839534054743, 0.025224780676004
4719, 0.69580253691571, 0.7356381025429, 0.02481235244212
4720, 0.69013267980148, 0.7231289578449, 0.074003016004101
4721, 0.49277037921776, 0.58407621939765, 0.075665324061227
4722, 0.71744878449047, 0.056616518083799, 0.073717910171383
4723, 0.6539457577635, 0.29320860824323, 0.075498887837194
4724, 0.56457880146243, 0.6340366595626, 0.026349570866795
4725, 0.79061367360776, 0.77043020509508, 0.026249877843044
4726, 0.5805383832678, 0.55202371273563, 0.024356377665844
4727, 0.50113324818741, 0.58004903194801, 0.024316078360792
4728, 0.47053253331298, 0.76509515629955, 0.026849547706351
4729, 0.5829583276606, 0.55715669151937, 0.076276046419825
4730, 0.41092116093442, 0.60953184335651, 0.073529064074666
4731, 0.87224946595474, 0.1840575364046, 0.073603304976367
4732, 0.82175567687754, 0.77401797116411, 0.074216294522164
4733, 0.85158431924902, 0.33194250852787, 0.073689222863052
4734, 0.83376569955967, 0.5036217975164, 0.073834680783767
4735, 0.62557949410251, 0.41744920343679, 0.024265166145685
4736, 0.59818588240998, 0.75099134549912, 0.075663245097857
4737, 0.63779732510871, 0.71968709219791, 0.076289831689895
4738, 0.63779732510871, 0.71968709219791, 0.023710168310105
4739, 0.81811484729066, 0.31144698452, 0.026049561610123
4740, 0.66284046465686, 0.38139104812246, 0.024293665519883
4741, 0.66547140135648, 0.2882271625035, 0.026172340708428
4742, 0.82349025085569, 0.66290578756914, 0.025918294387453
4743, 0.83411506559093, 0.62349103570515, 0.075121754366966
4744, 0.83458277674311, 0.41885073522789, 0.023697765757359
4745, 0.80379416539271, 0.37658385099562, 0.023701437012774
4746, 0.71621361977472, 0.53799694494502, 0.076222707504661
4747, 0.81339764545284, 0.46668711235085, 0.02369671141352
4748, 0.81339764545284, 0.46668711235085, 0.07630328858648
4749, 0.54307363852053, 0.58847667332826, 0.024361796218191
4750, 0.72141856675862, 0.33168826071502, 0.052484489303734
4751, 0.65416256348284, 0.85904883068905, 0.052481747274474
4752, 0.91452695424976, 0.29280271980284, 0.024969986268876
4753, 0.65525892142486, 0.37577124713432, 0.075556371139862
4754, 0.50900202819025, 0.70882660967521, 0.07584936115764
4755, 0.78101133568527, 0.41559192273099, 0.074937326649271
4756, 0.46553203374585, 0.62007275786121, 0.074748065050129
4757, 0.71722076628444, 0.48437291143249, 0.025635037910368
4758, 0.47164412400851, 0.54452071243366, 0.025727511691922
4759, 0.69152048862696, 0.41835044311904, 0.023717931788482
4760, 0.63071377207295, 0.57697884824283, 0.075323059704923
4761, 0.83364811754683, 0.17980524603757, 0.052330236696288
4762, 0.60779537812589, 0.86471927081966, 0.075799319777547
4763, 0.81191139205902, 0.15164050070663, 0.05
4764, 0.67203763495265, 0.68812649231642, 0.024274057697139
4765, 0.79472059857383, 0.44831445118921, 0.05
4766, 0.63701572166759, 0.33867740513393, 0.025505176107366
4767, 0.86366854064917, 0.3742032455883, 0.024402159654382
4768, 0.88104277694255, 0.17499062454004, 0.02408118177456
4769, 0.87984975456975, 0.71073061922982, 0.073339033356092
4770, 0.49764107827748, 0.72003288462116, 0.024576796086866
4771, 0.40803321825867, 0.58130508999893, 0.024641135186023
4772, 0.41842724083596, 0.6744134547658, 0.024656956835627
4773, 0.72294226407628, 0.39109584146088, 0.026324487998349
4774, 0.79311947551875, 0.3819476251068, 0.074591287942892
4775, 0.91338668434776, 0.1424295801922, 0.026035093583421
4776, 0.8119888857201, 0.20723675188697, 0.024162399633324
4777, 0.73457855871133, 0.55670061669259, 0.04969803196834
4778, 0.76272349876769, 0.64392150613653, 0.050550171347171
4779, 0.87835164058216, 0.23291368962613, 0.025492006707164
4780, 0.46239596907733, 0.62351689203162, 0.025655189095364
4781, 0.48300163498378, 0.78799083914743, 0.02518741894644
4782, 0.69728435346039, 0.092107904371307, 0.024875678178154
4783, 0.4713789945635, 0.58745865903632, 0.048763094805739
4784, 0.56960268411717, 0.39786666197154, 0.025253874552806
4785, 0.6654275674717, 0.20636047042625, 0.05022313355144
4786, 0.77026582851536, 0.10021076458847, 0.07662814638014
4787, 0.80381237274581, 0.5406804916829, 0.024270146315555
4788, 0.61937348591798, 0.32785146373326, 0.075339119403924
4789, 0.66203646906125, 0.21279295879994, 0.075272379541819
4790, 0.91513914729419, 0.49241080357408, 0.025160279472294
4791, 0.85549983603822, 0.45656819480204, 0.025897538112725
4792, 0.8220384145176, 0.49086986699444, 0.053948659394697
4793, 0.51188173050112, 0.78084485292175, 0.023877466646763
4794, 0.74430698538661, 0.31362231951404, 0.024149755152904
4795, 0.55208410211447, 0.64967135603315, 0.051820659429494
4796, 0.54095794330452, 0.8771943893054, 0.026980363341823
4797, 0.73054052557703, 0.44768375052866, 0.024610594190896
4798, 0.59320957172263, 0.71395736779544, 0.07441600132641
4799, 0.78915751751305, 0.62938198056696, 0.02508862262221
4800, 0.73395384641352, 0.30778949829028, 0.074743778346458
4801, 0.55527487282093, 0.83159395419113, 0.02475887084816
4802, 0.70563255270117, 0.47580433642748, 0.075426575450911
4803, 0.68757086520728, 0.098416361993798, 0.075503772176523
4804, 0.88691028436883, 0.43433823649045, 0.075576600462194
4805, 0.65931844719741, 0.53376569579494, 0.025630788947065
4806, 0.8923921167718, 0.70874285358935, 0.025680564322044
4807, 0.58602315799594, 0.64886757317654, 0.075015720565411
4808, 0.54555589303282, 0.50038842730045, 0.049720683542395
4809, 0.38990350627764, 0.62526805997577, 0.074630715201003
4810, 0.64912646928605, 0.32113571545982, 0.050802376663977
4811, 0.88610229884669, 0.73766428928886, 0.02577911132855
4812, 0.87448962222923, 0.79129386672159, 0.025785577715015
4813, 0.54627310219631, 0.66932602557336, 0.075386820805264
4814, 0.88572850446113, 0.11026893760648, 0.046975418983509
4815, 0.78323823833617, 0.7743855176229, 0.076515682844216
4816, 0.79076980272979, 0.58653014307606, 0.025517409453887
4817, 0.8623648653004, 0.58158200937518, 0.07545125355479
4818, 0.88564923115062, 0.3643499029652, 0.042278047406093
4819, 0.91317785449416, 0.66387548878366, 0.046777946302004
4820, 0.65727895248193, 0.043753993067275, 0.051104745375565
4821, 0.61470955981625, 0.37914295232035, 0.074321614723335
4822, 0.63407699927823, 0.41981736546813, 0.075208037560673
4823, 0.79677270796938, 0.70877153234237, 0.074862204307857
4824, 0.85886278888723, 0.48748785249495, 0.050698023975977
4825, 0.71009841242678, 0.40029091562469, 0.050797352450999
4826, 0.47677629703642, 0.54353500702083, 0.075793953562589
4827, 0.64483855353064, 0.13583195443961, 0.074329157726365
4828, 0.39172236343936, 0.5316666738976, 0.042543353488836
4829, 0.83522432182308, 0.50284635481308, 0.025074556839238
4830, 0.84575963808712, 0.024398559704332, 0.051623455792209
4831, 0.81763643492686, 0.024078570838991, 0.075725237378963
4832, 0.69963104350699, 0.59367551659296, 0.076235516492241
4833, 0.70009017997317, 0.56130995846622, 0.050971449659301
4834, 0.82869627203134, 0.71253584659765, 0.074973482798497
4835, 0.65146366787282, 0.25599092819781, 0.02576133021553
4836, 0.54201504196139, 0.55018843733635, 0.024728872620075
4837, 0.51726824861714, 0.77846380956268, 0.076624496652995
4838, 0.54020411717392, 0.74686648719318, 0.075205484839373
4839, 0.71376843451303, 0.28859697499817, 0.07527593458478
4840, 0.75253846015487, 0.15219937365685, 0.024041902114853
4841, 0.57618786687574, 0.81198478307138, 0.053338376315274
4842, 0.88007922413116, 0.41348645309295, 0.025380824240503
4843, 0.88307712864485, 0.52458578733661, 0.073914865297781
4844, 0.78357808827651, 0.67091560092868, 0.050094115038777
4845, 0.85915887210316, 0.13456580633091, 0.047113552820756
4846, 0.91518211651422, 0.80966928124193, 0.03981865607639
4847, 0.79018319039729, 0.3972531294691, 0.04587114826395
4848, 0.69151513238258, 0.024611645683922, 0.053099213964988
4849, 0.85154583675174, 0.10426175630285, 0.025271617368992
4850, 0.74223830037182, 0.2502073536493, 0.07586963593941
4851, 0.53919755245454, 0.6893029764762, 0.023729357838005
4852, 0.85979320146134, 0.75250809332988, 0.075415042631767
4853, 0.83346802496846, 0.31181181883504, 0.047274097767325
4854, 0.88396995048403, 0.057085059966495, 0.075401745435004
4855, 0.78734979503146, 0.50934644536415, 0.024229909437449
4856, 0.78591861937207, 0.056366088211377, 0.024178128490579
4857, 0.69409195635219, 0.050165737529684, 0.023663765162121
4858, 0.88448691465369, 0.53234862912051, 0.024291413172129
4859, 0.89887870343164, 0.66487295806998, 0.025100845887905
4860, 0.69043756909691, 0.52667392500711, 0.045753210207519
4861, 0.70603536480921, 0.84408835131284, 0.026113701603503
4862, 0.71886690168398, 0.70680832919758, 0.077439697180124
4863, 0.69734775776796, 0.40297506794092, 0.075812421731435
4864, 0.88094220312467, 0.43970827734005, 0.050350756906632
4865, 0.54290016121657, 0.5498081678023, 0.075735073452611
4866, 0.70004998014992, 0.21612601647093, 0.051907132973935
4867, 0.72104401657194, 0.58659223423972, 0.050156549573111
4868, 0.74597356309262, 0.77944348521618, 0.024809088808061
4869, 0.53760943282362, 0.43523455310582, 0.023047193578024
4870, 0.91359829415759, 0.24801817149861, 0.050872250999947
4871, 0.40380860182542, 0.59988828891274, 0.043433102325633
4872, 0.71479900159132, 0.78040403160971, 0.047949406782779
4873, 0.43248692181546, 0.57513015015369, 0.023456118364509
4874, 0.80479756204939, 0.5420167598106, 0.076698879764449
4875, 0.63993830309654, 0.25708770140092, 0.075906832344877
4876, 0.58908141879729, 0.61488322507095, 0.048566853266973
4877, 0.67715099327673, 0.46337730252391, 0.044358637310424
4878, 0.75319742621176, 0.29124984730602, 0.049185830044757
4879, 0.79831653424202, 0.078969300106184, 0.023972358530901
4880, 0.9158908251927, 0.34283329802332, 0.026002031338039
4881, 0.44423536109481, 0.57741519782807, 0.076022127507051
4882, 0.79471105635887, 0.21517433073238, 0.05523109793632
4883, 0.49651169702864, 0.49958687546217, 0.055093307537174
4884, 0.46825538968739, 0.4627930557238, 0.073897828893761
4885, 0.43589199228612, 0.70857539437792, 0.050186678040657
4886, 0.5885619298295, 0.29837347911639, 0.048374036978866
4887, 0.91599856790301, 0.40106050649331, 0.058672613117694
4888, 0.78333919531568, 0.50473649432971, 0.076599711404589
4889, 0.46502174833378, 0.70931770509428, 0.022786189234292
4890, 0.41730841028857, 0.67462513566889, 0.076143780675754
4891, 0.47436238573994, 0.65710357330549, 0.075323348147545
4892, 0.48209223333449, 0.66349472181984, 0.023655815000106
4893, 0.88423460074006, 0.27518643751794, 0.050856972216127
4894, 0.61649177581422, 0.49386123626328, 0.023312145242904
4895, 0.75800554860163, 0.073306543752876, 0.050202066665616
4896, 0.51286929594093, 0.55786575243723, 0.049435849059162
4897, 0.50907593823753, 0.41813154143185, 0.023960022892739
4898, 0.82908821777094, 0.55731294180655, 0.023035368080569
4899, 0.81733830883616, 0.3507133581724, 0.024291226996996
4900, 0.62476053499306, 0.20862474380549, 0.041108677808317
4901, 0.60303769682209, 0.686016051806, 0.049502038851364
4902, 0.9012405304011, 0.13368453837611, 0.074923888991141
4903, 0.80098738400596, 0.52007289995327, 0.042297753088723
4904, 0.85557052003871, 0.3245857348606, 0.024932714832097
4905, 0.42059364563825, 0.50791690088257, 0.043839781879709
4906, 0.55863598965964, 0.34589276073139, 0.054737016791555
4907, 0.48268850320815, 0.49607228262226, 0.076819668514785
4908, 0.74883281123822, 0.76549079305739, 0.076777828616797
4909, 0.45540442060918, 0.68428167628998, 0.053417276268224
4910, 0.84337163291736, 0.73511583531976, 0.049128296752959
4911, 0.53946638701315, 0.37897631301916, 0.049885172690786
4912, 0.77029331721345, 0.71105767904192, 0.075822724964595
4913, 0.71713092585343, 0.51371430574852, 0.050125131644662
4914, 0.47817479896001, 0.72000722501701, 0.043250494542159
4915, 0.91687629742098, 0.5744533380903, 0.023638005000246
4916, 0.67568952691106, 0.81250338055279, 0.053602992542145
4917, 0.71997029882729, 0.17154811619933, 0.043893775780241
4918, 0.75006124357367, 0.74703862052832, 0.048281744858874
4919, 0.76947285030496, 0.48168419299871, 0.075225974030533
4920, 0.7093719909289, 0.81062176340863, 0.024473846047025
4921, 0.7810659777531, 0.096288036211788, 0.052452725266075
4922, 0.70666350446951, 0.19481594475319, 0.024976364694332
4923, 0.86424419197379, 0.24915713846101, 0.050310962175767
4924, 0.88295236699896, 0.28528288498653, 0.02693925018455
4925, 0.84450751194345, 0.080462746187758, 0.05685204247113
4926, 0.69360742296333, 0.32937370929423, 0.075072997474957
4927, 0.44378134853106, 0.66698873242231, 0.023856274815713
4928, 0.8817290277021, 0.81094234751113, 0.075398488215498
4929, 0.67653359985632, 0.85450282826999, 0.076292088544192
4930, 0.61814590976848, 0.5897980529908, 0.055440489864806
4931, 0.88893931700537, 0.023984667521242, 0.043344430096161
4932, 0.7425100844648, 0.40071466490152, 0.075426148827135
4933, 0.6518246111194, 0.54474194467037, 0.050635008722766
4934, 0.58803104352576, 0.36629330603545, 0.075917865477232
4935, 0.83946042219406, 0.14932109925041, 0.076550654354036
4936, 0.62304767641534, 0.83895783513494, 0.047574536620678
4937, 0.76247373534521, 0.15957302449251, 0.047961051483829
4938, 0.70448307219621, 0.62330211810979, 0.075636714828331
4939, 0.61583926636774, 0.87116406622657, 0.024857070537514
4940, 0.6362115262767, 0.17375880833815, 0.050797466678252
4941, 0.54100002346972, 0.56648988023186, 0.05
4942, 0.66071305503132, 0.02303928099956, 0.02307309795582
4943, 0.508174632632, 0.75011455464195, 0.042706684176224
4944, 0.80984898356515, 0.022875952961518, 0.042869100766991
4945, 0.82192746203021, 0.64127696350735, 0.054358016073863
4946, 0.72029466349677, 0.29908397356328, 0.046842025714683
4947, 0.77658200528089, 0.1811799557196, 0.047315344173805
4948, 0.43192008172832, 0.6376558539453, 0.049940987847096
4949, 0.85416701151882, 0.34622930305936, 0.052610024491611
4950, 0.41978888207531, 0.57914870959873, 0.076096877341476
4951, 0.68339484053307, 0.70656434454505, 0.050072807588997
4952, 0.88881169912225, 0.46710726431825, 0.047239173089014
4953, 0.61901212081114, 0.62144599239119, 0.023175777438425
4954, 0.84190188728725, 0.74700773952876, 0.024187419663967
4955, 0.79967292749346, 0.12489886919961, 0.076896887956006
4956, 0.64443254977681, 0.13144390221596, 0.027389185764444
4957, 0.7883103367581, 0.44093279563033, 0.023769421200391
4958, 0.83005053563494, 0.39182770887988, 0.023275421587289
4959, 0.70035209986469, 0.74518611089833, 0.076737859313006
4960, 0.51461246823016, 0.46180855091878, 0.07672748751085
4961, 0.63325038566909, 0.56011951198213, 0.023472028630859
4962, 0.91708825408551, 0.37693989212258, 0.078003118382329
4963, 0.74139715265554, 0.4154294852812, 0.048464827741247
4964, 0.68082393290061, 0.2860931945519, 0.04708371045883
4965, 0.7972035582861, 0.64296564898072, 0.048152805285161
4966, 0.70420533691726, 0.10340334180052, 0.056181135506796
4967, 0.75803010520937, 0.11725659901543, 0.022225377229574
4968, 0.82221373821559, 0.81937945171746, 0.044264140825251
4969, 0.70919859708767, 0.43681889807143, 0.05600465029115
4970, 0.53327016690546, 0.49171941438477, 0.077898411741997
4971, 0.5159572868148, 0.66820228397325, 0.055719234634092
4972, 0.8633440543183, 0.41234392620383, 0.049134181621404
4973, 0.71829166785694, 0.33288997847592, 0.076969301536159
4974, 0.65497858605267, 0.35418491879409, 0.057235528062363
4975, 0.84785252750483, 0.15904927629382, 0.023435374217051
4976, 0.36113705840956, 0.57697935527809, 0.045176475862268
4977, 0.64908187219856, 0.44596361560923, 0.024279385089276
4978, 0.72062824328293, 0.71737815773579, 0.022929913786975
4979, 0.50370363765567, 0.60253723612763, 0.05
4980, 0.61221077168871, 0.76150066958154, 0.022861481985101
4981, 0.82441304180352, 0.2235796659818, 0.04705167339667
4982, 0.59524823559352, 0.47332033972695, 0.075975294555542
4983, 0.66758442116953, 0.46530429527952, 0.077812194875886
4984, 0.75727356374923, 0.51669028830739, 0.050824487291605
4985, 0.68239739451611, 0.16050840360353, 0.048680237958759
4986, 0.49897189362969, 0.42749294633814, 0.050809919561431
4987, 0.86126094969622, 0.16710512019655, 0.050634046921792
4988, 0.81699976393106, 0.25134288196644, 0.075901460321868
4989, 0.78554100686937, 0.17186970250245, 0.076744945375419
4990, 0.82618918821835, 0.56014777567972, 0.047379536649558
4991, 0.73525945643644, 0.62124795015537, 0.076966573100934
4992, 0.72734865597519, 0.52118254495727, 0.024293614365375
4993, 0.67123759236732, 0.090886651544862, 0.023272653204782
4994, 0.76522744524649, 0.43951204513098, 0.055790820175621
4995, 0.7106308290087, 0.72750610464703, 0.04387048885065
4996, 0.86670857324686, 0.45245480328169, 0.075980708718841
4997, 0.39904319691078, 0.54164150839115, 0.022176304512869
4998, 0.83054340333698, 0.1853008858362, 0.077624205418002
4999, 0.74511166524886, 0.8012991742382, 0.076949763722436
5000, 0.6605304453841, 0.72811864484227, 0.050114634323677
5001, 0.39408341316036, 0.63794673819594, 0.044246531911316
5002, 0.66303104817403, 0.8219802912968, 0.022481253648379
5003, 0.57385110469344, 0.71344116191321, 0.022346548785242
5004, 0.73699329038685, 0.43178911539803, 0.077554719463272
5005, 0.80056213565249, 0.18032955806858, 0.05
5006, 0.63373130657735, 0.69584432318461, 0.049863255319606
5007, 0.47874766259493, 0.49576348032681, 0.023280365259292
5008, 0.69919781946865, 0.68614789405103, 0.04912827017474
5009, 0.82691618539524, 0.68028389447854, 0.050108091487477
5010, 0.48080954095981, 0.51913259166472, 0.048868366236636
5011, 0.50991995740791, 0.7061079131595, 0.04557811417786
5012, 0.43485179068868, 0.61382645164178, 0.048310182291362
5013, 0.8850140350515, 0.097517020360371, 0.075947968887484
5014, 0.59708397525712, 0.27455749641715, 0.050328100996331
5015, 0.67690227805093, 0.12364362116592, 0.0237425616171
5016, 0.62211579598579, 0.20984636891774, 0.072406274791936
5017, 0.55019697080136, 0.52398303936774, 0.050026430973442
5018, 0.86539199893179, 0.53355820026047, 0.042940637331466
5019, 0.5472930521559, 0.76766123753329, 0.043572366214037
5020, 0.74917649269142, 0.78819372788394, 0.048195482556532
5021, 0.8872381400769, 0.023835687515881, 0.075810580206018
5022, 0.82404953381971, 0.58504057621897, 0.060075752515155
5023, 0.68576827534165, 0.074210917502465, 0.07623280244779
5024, 0.61263608084302, 0.39112569436668, 0.022673882840514
5025, 0.85049915773469, 0.27733064265894, 0.076047171611167
5026, 0.83829153017979, 0.79474299859344, 0.077713609726263
5027, 0.83039070345715, 0.18524546548063, 0.022297563433334
5028, 0.68060545266022, 0.81108775525919, 0.077756614046826
5029, 0.72414605470103, 0.26613641278381, 0.047889517523367
5030, 0.78673989927618, 0.30707685973845, 0.049460346712698
5031, 0.78717441185088, 0.79417643735884, 0.023633830643083
5032, 0.84995598867603, 0.59709793148514, 0.046284193613752
5033, 0.75734233702906, 0.33063639639096, 0.047155110511028
5034, 0.82231110314732, 0.41752836034313, 0.075872599171537
5035, 0.85851259580639, 0.65731262036481, 0.022406317234743
5036, 0.81472135324144, 0.088463922222044, 0.076644382473247
5037, 0.82950642293607, 0.10722622577251, 0.04194036515333
5038, 0.915571787395, 0.28306522923509, 0.049346986434699
5039, 0.73599511018139, 0.68290047203175, 0.047216690855877
5040, 0.56389793386717, 0.74928268111065, 0.077832020107632
5041, 0.91535089544266, 0.62590097396829, 0.049583729535868
5042, 0.51554054872062, 0.5160057285689, 0.045383545996158
5043, 0.91678316449982, 0.70360842699933, 0.026069584938243
5044, 0.65707772936036, 0.048958714338321, 0.076480892465487
5045, 0.91488212366845, 0.082483646035082, 0.023819474429092
5046, 0.91751426686765, 0.041367100471419, 0.051311711910169
5047, 0.76406793086325, 0.56654388762302, 0.056872026454616
5048, 0.8418937921532, 0.81846307357812, 0.077907158182095
5049, 0.89032295982691, 0.14802251947925, 0.021353523829398
5050, 0.7905630037296, 0.48358904313223, 0.04503762112267
5051, 0.76770239982427, 0.54894856701152, 0.022135979623295
5052, 0.63380167978394, 0.50139372699005, 0.078654815408982
5053, 0.566536739595, 0.83940133128726, 0.075911539053698
5054, 0.51910059296095, 0.40289107865664, 0.058322617687415
5055, 0.53883673011549, 0.81062934998538, 0.055552793613571
5056, 0.43371815653492, 0.64826521927057, 0.077411107431863
5057, 0.91720142476148, 0.58104127803327, 0.074754795605082
5058, 0.88848793503198, 0.60290945589029, 0.022345912956509
5059, 0.89062500229038, 0.81061177796437, 0.023663239749093
5060, 0.75462153007882, 0.079923051061744, 0.076976564106722
5061, 0.91600876235426, 0.19011846385209, 0.023470578557794
5062, 0.91577335450522, 0.77505714972057, 0.045800013734517
5063, 0.57994170462009, 0.42085616904194, 0.023737967570606
5064, 0.67746979209344, 0.39351928370179, 0.047209824593315
5065, 0.57078350875507, 0.57762728140387, 0.050039305595859
5066, 0.76766539019711, 0.70694280282125, 0.023414530076482
5067, 0.67966233451441, 0.63115549372773, 0.050302948550064
5068, 0.55977359513601, 0.55190787353217, 0.049912723516427
5069, 0.61228127513667, 0.4841956992824, 0.048762640610459
5070, 0.44410541863978, 0.52569260244715, 0.04755475659033
5071, 0.88799492686852, 0.23755878569429, 0.07668140578071
5072, 0.71475519711623, 0.29316632353667, 0.022604751808322
5073, 0.80927377105646, 0.42041087583885, 0.05
5074, 0.80668120223392, 0.20856736083056, 0.078182289620357
5075, 0.57702384742333, 0.50734950013578, 0.078260018263448
5076, 0.62946803611044, 0.46266636959188, 0.054411397902265
5077, 0.50128607554884, 0.8205679754508, 0.050342453285116
5078, 0.36757904787642, 0.58997210342391, 0.076715347865219
5079, 0.91701498869704, 0.47848424998128, 0.047054654819811
5080, 0.65731594271735, 0.69910789027838, 0.050066537718393
5081, 0.5224098954544, 0.58794384065781, 0.05
5082, 0.37132445304423, 0.54380983642137, 0.056868693553448
5083, 0.72286938291359, 0.77385281901768, 0.022687940057882
5084, 0.60095912658745, 0.77970582654779, 0.04840300432383
5085, 0.75607446146906, 0.52708476279442, 0.077549061001073
5086, 0.75608065772464, 0.65438725148056, 0.077273081333094
5087, 0.84267976329832, 0.229050963135, 0.077794470860024
5088, 0.66800667173136, 0.69127716407674, 0.078354382147803
5089, 0.6493073721064, 0.39766965080298, 0.049588330325341
5090, 0.64264557547257, 0.28095202158352, 0.055651466033598
5091, 0.85615369804787, 0.24368104677859, 0.023263457589276
5092, 0.85059721623281, 0.68824135626415, 0.02390737689056
5093, 0.64597113976551, 0.74688861418004, 0.050012545335185
5094, 0.91645435635658, 0.53370917245832, 0.047116989828477
5095, 0.78528855539783, 0.36139358934152, 0.049936822303611
5096, 0.82400558269832, 0.069403833524443, 0.045877342494826
5097, 0.41200933553519, 0.55280204069453, 0.055200672122627
5098, 0.75624858154742, 0.49280242187534, 0.050691788698014
5099, 0.78812827306001, 0.28832143610208, 0.076751072214393
5100, 0.70776115963403, 0.13929737528165, 0.023965863494026
5101, 0.67073142526395, 0.4310262586399, 0.052789146726471
5102, 0.59902434390255, 0.81127200535325, 0.022807607109434
5103, 0.75844151533444, 0.46317389361154, 0.021949723967092
5104, 0.7436874623315, 0.83398876212549, 0.050926730698001
5105, 0.57958193288398, 0.8930946296886, 0.048360787795407
5106, 0.74692156907165, 0.15551303433907, 0.076539093217888
5107, 0.76903683648112, 0.3411681786018, 0.077911208167998
5108, 0.68566779771233, 0.80273664261742, 0.023858683315413
5109, 0.81457081363628, 0.34022957056043, 0.045993632789626
5110, 0.73458039038871, 0.71685309981343, 0.056902085731791
5111, 0.48525116793407, 0.79563567508685, 0.047320616162291
5112, 0.42139102389739, 0.68240574128175, 0.051222504201761
5113, 0.55760749646388, 0.62194058090294, 0.045948867743142
5114, 0.91792628384318, 0.45599135764639, 0.078159109931788
5115, 0.59074022490749, 0.62579211084939, 0.077615377177708
5116, 0.76212558586297, 0.022140723857111, 0.058324341581153
5117, 0.57414711670196, 0.89172805620548, 0.022312850717895
5118, 0.52099903705491, 0.46949481007824, 0.050061966886815
5119, 0.79733683450814, 0.61041896283162, 0.055607509343671
5120, 0.4889135109097, 0.52902171331419, 0.021754264843719
5121, 0.79117052945061, 0.26622521415493, 0.049131330519579
5122, 0.76508505353964, 0.35943835121841, 0.022820713089213
5123, 0.76019864321095, 0.12327247053392, 0.050142027931305
5124, 0.60581320655925, 0.44459251185964, 0.021331829257374
5125, 0.34872183179477, 0.55804519807533, 0.076571404177367
5126, 0.6782673022511, 0.75522193694848, 0.053293103340519
5127, 0.57659548429264, 0.68369308682057, 0.051237616873848
5128, 0.57628046751488, 0.5298220010615, 0.049640887277405
5129, 0.85543004408495, 0.51298804413811, 0.077774827846059
5130, 0.81864123438789, 0.59536570968821, 0.021377120957773
5131, 0.48393293889739, 0.45802938991055, 0.021596160650491
5132, 0.73018232080845, 0.21429130766063, 0.0569939305553
5133, 0.84460088198437, 0.8164948530053, 0.051712320072088
5134, 0.41671680348974, 0.542414445203, 0.07694883147112
5135, 0.67679868946865, 0.41512698210311, 0.077869737051513
5136, 0.91260435932135, 0.20541071127075, 0.078179633231678
5137, 0.57546366528808, 0.37790757353806, 0.049933990361432
5138, 0.72568084111348, 0.13455704545612, 0.048967965811337
5139, 0.57480269453668, 0.45330152587095, 0.053154595818604
5140, 0.53027423855407, 0.62236054218864, 0.044533746072238
5141, 0.57799871209493, 0.31032279042295, 0.021179936728975
5142, 0.81452284804903, 0.49030072436271, 0.077323378617287
5143, 0.73329525907391, 0.099417476297371, 0.022426856724945
5144, 0.78970373475014, 0.48601754203636, 0.021110077187095
5145, 0.65886765706364, 0.24983252434668, 0.04760514421507
5146, 0.54132915056413, 0.74495170176952, 0.023081329324909
5147, 0.66394802540415, 0.021363440383798, 0.048710554687282
5148, 0.51646483628884, 0.67093011613298, 0.079012898441478
5149, 0.88954189310427, 0.041944712782589, 0.022650324481699
5150, 0.69025687987436, 0.18827427033897, 0.049793783591915
5151, 0.91639129379237, 0.25070071185148, 0.076895015279418
5152, 0.60519054551587, 0.65669878475647, 0.048039519362011
5153, 0.62320029024081, 0.29257002051296, 0.022488861447482
5154, 0.87282434641964, 0.057565041347979, 0.052403535190323
5155, 0.8954429983769, 0.18208568896669, 0.078409124588056
5156, 0.45460032232014, 0.56627053224871, 0.021077337821797
5157, 0.67808688431708, 0.59734472150582, 0.021203683061154
5158, 0.72843225198628, 0.64629449804572, 0.044834398003111
5159, 0.60430210700829, 0.43966321236759, 0.060579659353055
5160, 0.83294414082626, 0.62814772510672, 0.021313435284001
5161, 0.79271651773595, 0.72051151008423, 0.050001083114429
5162, 0.62757176231129, 0.76711888831069, 0.052858668964726
5163, 0.58198496064814, 0.65270701114662, 0.022419356592459
5164, 0.75584502954767, 0.37703299429256, 0.049985530316586
5165, 0.58748892577394, 0.50881666622403, 0.02281820321417
5166, 0.91773093777413, 0.098442630930697, 0.048344730638602
5167, 0.80001008972773, 0.12154182203844, 0.020784698946649
5168, 0.4896783743234, 0.67867582471312, 0.044264196931934
5169, 0.70122405326482, 0.078111253298414, 0.046381910965138
5170, 0.72270131291197, 0.74661548186314, 0.05180703745683
5171, 0.91567901651519, 0.76803411592743, 0.022697455706419
5172, 0.61070671689251, 0.31495175674357, 0.048382691779174
5173, 0.45595293202567, 0.69957919110331, 0.076823173898952
5174, 0.72258349456964, 0.45950832739149, 0.045871105292959
5175, 0.71429322050892, 0.18462592864961, 0.077291623509204
5176, 0.55923870409795, 0.34432144965293, 0.078413048057966
5177, 0.5562222737845, 0.46250534391794, 0.077860135638847
5178, 0.68757301859622, 0.85091687280992, 0.041103890104822
5179, 0.59341991480865, 0.5081192573364, 0.047936584020291
5180, 0.70184669508604, 0.61388477722067, 0.051765780028936
5181, 0.83084919326184, 0.44198691842266, 0.021416445125897
5182, 0.60637165104892, 0.68055400882316, 0.02147412418395
5183, 0.76533643798598, 0.54936489391204, 0.077984672670473
5184, 0.62139152555932, 0.67803084818154, 0.078244378311525
5185, 0.72674463379003, 0.26435354312871, 0.021130534621059
5186, 0.91781617674985, 0.43631508452529, 0.052320684910284
5187, 0.62275687870295, 0.80196686180306, 0.044848674203913
5188, 0.60976867954515, 0.45512395802719, 0.077870300017829
5189, 0.58839991020546, 0.85121859412771, 0.077606684966515
5190, 0.79000904948017, 0.13651345736414, 0.045991797312877
5191, 0.61407316694312, 0.80397426176952, 0.078388453180763
5192, 0.76647438371022, 0.69775164316387, 0.048175175476882
5193, 0.68617249606112, 0.78051084940603, 0.053972055284197
5194, 0.7251635210114, 0.023619506493126, 0.051662729269827
5195, 0.84554808891144, 0.35090762863361, 0.023980095329666
5196, 0.88649145327785, 0.19792107342748, 0.021850666622458
5197, 0.9165233626145, 0.22204837342348, 0.048676427937308
5198, 0.88188592834498, 0.32610075490695, 0.055667874415899
5199, 0.65316401381601, 0.8639869220954, 0.076543724227336
5200, 0.47897631335679, 0.55628490689582, 0.047712321495399
5201, 0.64601429033711, 0.79289107799166, 0.04709555429853
5202, 0.57406864512519, 0.48492100706948, 0.044353769868137
5203, 0.67650937781285, 0.22242178368211, 0.021790610932779
5204, 0.52273451449213, 0.80124303525969, 0.021771845498174
5205, 0.74491623337993, 0.1978973926772, 0.046614943442229
5206, 0.63413379905327, 0.62183961874159, 0.049705088766812
5207, 0.86176676008832, 0.29794105862621, 0.054522032390204
5208, 0.72876072322852, 0.050593675860627, 0.054084696642292
5209, 0.63721441700909, 0.37754970910054, 0.048949267919149
5210, 0.72108942089352, 0.54823436535781, 0.020797332741771
5211, 0.89364227100558, 0.47948139332681, 0.022569603840779
5212, 0.7294660838928, 0.17314438815479, 0.021619870354251
5213, 0.57018269231286, 0.32658244647447, 0.048240319951456
5214, 0.7604489457897, 0.23628090621163, 0.049849742349388
5215, 0.80895232456237, 0.7761137655011, 0.054764836068245
5216, 0.84528042909868, 0.78683769872737, 0.049180418992085
5217, 0.52437132875023, 0.62452052069877, 0.020921999960844
5218, 0.57570671878921, 0.57916804064869, 0.077721680233605
5219, 0.45281677140869, 0.55659082613475, 0.054616092958359
5220, 0.4061167569066, 0.66019777039259, 0.052287293004216
5221, 0.86078636342197, 0.48471334169114, 0.078522025872692
5222, 0.63193137078235, 0.23116502998653, 0.04878063370596
5223, 0.88954398788209, 0.28540874899036, 0.072193565472679
5224, 0.57093206581649, 0.81658490349222, 0.077944875146758
5225, 0.69856133582695, 0.151401929397, 0.078167547390174
5226, 0.56489325846152, 0.87562318642552, 0.075658291441372
5227, 0.56611840711327, 0.78220534870013, 0.077091405250611
5228, 0.88991105981862, 0.3507348550997, 0.022772194563199
5229, 0.56331876038169, 0.42601470230526, 0.052816357485085
5230, 0.76417742556371, 0.19760392814215, 0.078096469992702
5231, 0.59708223567267, 0.33162362466535, 0.058238974119628
5232, 0.7391306874303, 0.49133787834104, 0.021480397619432
5233, 0.91837049552307, 0.62212898741715, 0.026699378307642
5234, 0.68490479150035, 0.12947146505347, 0.045598143699611
5235, 0.88278043024494, 0.62792454335351, 0.052542701520187
5236, 0.91660829708172, 0.50215516249086, 0.047104824421044
5237, 0.85037233900124, 0.023219457765947, 0.023751400444273
5238, 0.61486176257266, 0.73539355264205, 0.079333265602048
5239, 0.52737297532408, 0.73930759567484, 0.050042890536326
5240, 0.78440301508648, 0.46418391475874, 0.078893845310548
5241, 0.60305490969193, 0.82768856456909, 0.050972023135467
5242, 0.49399587042981, 0.67621982299071, 0.078388650424892
5243, 0.72610837858172, 0.81270945255287, 0.056276738097843
5244, 0.66266889403219, 0.35584294127835, 0.02076249575245
5245, 0.60923765043079, 0.39447076924451, 0.048686483087249
5246, 0.64032223271172, 0.59244432851691, 0.044683987349226
5247, 0.65304454097887, 0.31604996963764, 0.0790737805913
5248, 0.44649760497789, 0.72896690952453, 0.050489145981021
5249, 0.8538453176516, 0.55329562224367, 0.078655193192404
5250, 0.82305943378106, 0.38867922318289, 0.045218952376309
5251, 0.65956250477083, 0.50170781483143, 0.05105337882013
5252, 0.69386079589168, 0.27660673115983, 0.077746088629262
5253, 0.67212424116112, 0.60484139541838, 0.048856352059363
5254, 0.75317865924632, 0.45723344942792, 0.044656103531398
5255, 0.71368847864688, 0.68427407515518, 0.078208877799091
5256, 0.86451704356758, 0.72320657816228, 0.044888354007527
5257, 0.80970765767031, 0.036488409412835, 0.022193574821028
5258, 0.69393619115975, 0.26106292805291, 0.04622245938552
5259, 0.50986575376987, 0.55916040532213, 0.020539831121861
5260, 0.91833466715897, 0.33747498132571, 0.052844451436889
5261, 0.4626808341119, 0.75809560379224, 0.078503132820973
5262, 0.49490973907614, 0.63613078049987, 0.078324649415069
5263, 0.51320428037519, 0.84561190824596, 0.05036693820696
5264, 0.38572118458364, 0.57971430778545, 0.055038617791842
5265, 0.6855516836167, 0.49467060112727, 0.020773791048108
5266, 0.60364538920027, 0.25550057326085, 0.079351359880166
5267, 0.54280450208145, 0.78844461919177, 0.079069451146522
5268, 0.85589775045619, 0.081623280521701, 0.02204704889679
5269, 0.68463080112287, 0.66254947453073, 0.052979469701183
5270, 0.79624292475794, 0.59411849039058, 0.079680084400237
5271, 0.72463260197493, 0.64940295759832, 0.020492829908602
5272, 0.641242660646, 0.14864729996633, 0.049216019695813
5273, 0.85197537014496, 0.75680410016886, 0.054025072504746
5274, 0.61308640481554, 0.56003298296664, 0.049950644743244
5275, 0.65284134547267, 0.57109900610892, 0.07730232016181
5276, 0.63517326074318, 0.76815308766681, 0.022573300743826
5277, 0.70027617256051, 0.56067886551712, 0.020774223205746
5278, 0.65672913901686, 0.67012173790974, 0.046312562409947
5279, 0.77889654189022, 0.58497580800142, 0.048858569924425
5280, 0.42878152625356, 0.56647978130649, 0.045444818627495
5281, 0.65105923106806, 0.6441200188568, 0.045392635440976
5282, 0.80936924177259, 0.71360449964761, 0.020263224699675
5283, 0.85422276688049, 0.68976673012275, 0.046751564514765
5284, 0.91619127847014, 0.072929603810697, 0.045863312983302
5285, 0.65968399201403, 0.4257456468423, 0.021156931616467
5286, 0.91858253970592, 0.53598968572733, 0.021509233775635
5287, 0.71008989623112, 0.10303014083993, 0.078579173304437
5288, 0.85729624544348, 0.55960841157611, 0.055288932638542
5289, 0.51568431058318, 0.5161202442702, 0.020775172493829
5290, 0.83266154658289, 0.12664878184239, 0.053587920360725
5291, 0.45917207908985, 0.75223845663857, 0.041960019132141
5292, 0.79413603776837, 0.17318115192724, 0.022461098439787
5293, 0.7906901416094, 0.24572282846663, 0.022942282285397
5294, 0.76158954125067, 0.034167501713456, 0.078739258249022
5295, 0.8579106300207, 0.27322254137472, 0.02357663445912
5296, 0.79575561589784, 0.24096755590772, 0.078744163999667
5297, 0.89330329693051, 0.49546549001333, 0.078634278825676
5298, 0.68274872801933, 0.52137005563082, 0.078198490251626
5299, 0.55301677831054, 0.79696009956875, 0.043927096597634
5300, 0.53959436108087, 0.60989438320025, 0.078277003773037
5301, 0.86388119229433, 0.08455548314198, 0.044688005045353
5302, 0.65466096426627, 0.57763616273336, 0.054604685490754
5303, 0.69250611067017, 0.49391294378505, 0.048411497084504
5304, 0.74600877762721, 0.80716729036499, 0.021664928090394
5305, 0.78707703411518, 0.21434743366274, 0.022177036927831
5306, 0.77293540029896, 0.74312306616412, 0.045172627732784
5307, 0.57439723625752, 0.67578810083502, 0.020548741663022
5308, 0.4358903642521, 0.71163231547828, 0.078384325848471
5309, 0.68848062201047, 0.31484139693333, 0.05738188318773
5310, 0.91704094646136, 0.81156951102723, 0.077347348244402
5311, 0.82062090058492, 0.075697965025601, 0.020809914930684
5312, 0.61959648784766, 0.55728231126579, 0.078523637788093
5313, 0.40746216342253, 0.60395211436465, 0.021176553839741
5314, 0.52570166669783, 0.69014786042179, 0.049247225697251
5315, 0.51082015256998, 0.77635083777155, 0.054439993867864
5316, 0.76354460556439, 0.24073561187261, 0.077674605710789
5317, 0.82241505341647, 0.11809702512193, 0.020714505232709
5318, 0.45269136897786, 0.5563952603009, 0.077308436654463
5319, 0.79624171678251, 0.56584315268753, 0.050062978559385
5320, 0.77859072238751, 0.54704031372868, 0.050730320648805
5321, 0.90619393024932, 0.05035291623827, 0.078357635127897
5322, 0.72775859343699, 0.24077137578158, 0.04453554499186
5323, 0.88606436844613, 0.67262493683426, 0.050363874843233
5324, 0.72700134077414, 0.62573131523668, 0.055304281906685
5325, 0.87340779290834, 0.58538200527868, 0.022203908218457
5326, 0.69058480634346, 0.025351084279039, 0.07992532492518
5327, 0.76312443839322, 0.66000720672214, 0.020283467449694
5328, 0.73466697267643, 0.10544862294514, 0.049744428998117
5329, 0.83535522892203, 0.52997234260112, 0.049800452401198
5330, 0.80874997839927, 0.10479601755425, 0.053658606218264
5331, 0.91774111958858, 0.17485262237155, 0.078024475186123
5332, 0.89318146095798, 0.33600597864656, 0.078348094102726
5333, 0.67550846690462, 0.45970470092232, 0.020774201684993
5334, 0.85849559773225, 0.63421209321311, 0.077741357704114
5335, 0.72839754291392, 0.22243734874941, 0.078970603222684
5336, 0.42473430704101, 0.4998791608006, 0.078191763850301
5337, 0.78643202127345, 0.8251391033062, 0.022985995243668
5338, 0.59006904077603, 0.85760518843478, 0.021668215949088
5339, 0.42685539227931, 0.49739746703218, 0.020927948055257
5340, 0.72588984145549, 0.021034563039259, 0.021980499770505
5341, 0.73858026728613, 0.5417467242184, 0.079408657189193
5342, 0.75440288040101, 0.21490169921891, 0.021316003719636
5343, 0.89095630415183, 0.078886045836218, 0.020694471089851
5344, 0.89070326025833, 0.15755425356922, 0.042786195684949
5345, 0.44889540857565, 0.66375384550953, 0.045829387533361
5346, 0.57121611279218, 0.71132800092408, 0.079015747799093
5347, 0.74552324124383, 0.71895441709006, 0.022743584610656
5348, 0.48477494298531, 0.70037796293062, 0.055681275039893
5349, 0.80081387070523, 0.65505678578453, 0.022594228962968
5350, 0.81037642838616, 0.28042875791856, 0.045162839591614
5351, 0.74920135556821, 0.35480047179394, 0.079596261077436
5352, 0.88690255591426, 0.51048984221431, 0.050809739248925
5353, 0.59601711130837, 0.58907377555639, 0.079620628580487
5354, 0.82255403510586, 0.27231389923062, 0.02219188236799
5355, 0.44263102033614, 0.60860549031084, 0.021103246001967
5356, 0.71601768738224, 0.77516694287828, 0.079011259226405
5357, 0.3752605675935, 0.54674687624817, 0.079567310847896
5358, 0.62156064637395, 0.35605209458174, 0.022198351792876
5359, 0.7448949495353, 0.39447263532959, 0.02069708979823
5360, 0.89173552005678, 0.50275625155733, 0.022345154105955
5361, 0.86415529497592, 0.78594946296896, 0.078790202879107
5362, 0.81722117271974, 0.34253251620134, 0.078455724030152
5363, 0.51654921106959, 0.73903995338865, 0.080197202393819
5364, 0.85799061501975, 0.052355834882139, 0.022160103743711
5365, 0.63672522110221, 0.21316296369647, 0.021176311307412
5366, 0.67507372607645, 0.66612366428524, 0.020151998627763
5367, 0.85533217673328, 0.22024549481129, 0.020923614276512
5368, 0.57859883890051, 0.30915212054452, 0.079156329357633
5369, 0.55475615815646, 0.51781987786857, 0.020885503009801
5370, 0.91677812202125, 0.36333281323327, 0.051980113354978
5371, 0.85635247386661, 0.13816423692716, 0.021541128229379
5372, 0.62910314482461, 0.35616075863939, 0.045677877865309
5373, 0.48138123923574, 0.59007725979224, 0.02085109612523
5374, 0.65508926716332, 0.60839594367443, 0.077953114047018
5375, 0.84843093973783, 0.020983487758111, 0.078379278204779
5376, 0.58024914816574, 0.40390522765159, 0.051216246014527
5377, 0.88793157283406, 0.6588856801238, 0.078134299070809
5378, 0.82237789124405, 0.30179370368276, 0.079450233823117
5379, 0.44615464350655, 0.608997738947, 0.078406824193713
5380, 0.83971171297288, 0.304367156338, 0.021623123613076
5381, 0.51799571659782, 0.71088915593672, 0.021499350637975
5382, 0.53916952111998, 0.70780112798405, 0.07862357413858
5383, 0.8423412563042, 0.81890462408177, 0.021024982423472
5384, 0.72012003002399, 0.37452205878193, 0.053895518512527
5385, 0.35099084333535, 0.55624142891983, 0.052519003385309
5386, 0.7043211057186, 0.58280200386545, 0.022033337855873
5387, 0.55512057908674, 0.5180347825813, 0.079048048552047
5388, 0.91643666342763, 0.30733279232167, 0.050660693049984
5389, 0.71850186862045, 0.36892733909682, 0.077966342203133
5390, 0.79140021810306, 0.33198411362475, 0.05159715102328
5391, 0.76196950717008, 0.27018021363523, 0.04876896257279
5392, 0.65110938016108, 0.080065837239868, 0.020374127300906
5393, 0.86680913788597, 0.81296084495969, 0.019903300279182
5394, 0.84492210138851, 0.075791343020011, 0.080339734244527
5395, 0.80550073087915, 0.80703453263647, 0.056136725773138
5396, 0.60042256575528, 0.36831955137003, 0.056402465237802
5397, 0.88149369294163, 0.61518507750344, 0.078895117171936
5398, 0.77826689382321, 0.74758222958529, 0.021771076568098
5399, 0.85718147186055, 0.4977763289964, 0.021788343957038
5400, 0.91715242306427, 0.7413644879572, 0.047730893859837
5401, 0.58548821913625, 0.62687012078243, 0.022318373343631
5402, 0.37504913012568, 0.60755132257989, 0.045155366802567
5403, 0.52204796393443, 0.64780608951628, 0.048912047969343
5404, 0.76782069661724, 0.79962707321874, 0.052715904818165
5405, 0.50709797492454, 0.49187429237991, 0.022339511076089
5406, 0.81614478957483, 0.39011059985427, 0.079028331185172
5407, 0.79996837967543, 0.040967101341384, 0.078969833176375
5408, 0.91274944174746, 0.15148688236896, 0.047556236727512
5409, 0.72247972488219, 0.071140912421411, 0.046605073154866
5410, 0.7388994450304, 0.051673025193092, 0.078182070984573
5411, 0.61827957172462, 0.84512662342238, 0.079332632199153
5412, 0.68622954539632, 0.63418226614545, 0.022327329209694
5413, 0.65684347687952, 0.020555800558714, 0.07970947402861
5414, 0.53161502170089, 0.4401653596559, 0.045521599088228
5415, 0.54014432604232, 0.83992859787936, 0.057135340256203
5416, 0.68538601797452, 0.37446084867023, 0.078598913165497
5417, 0.78297045872714, 0.27959265604697, 0.021791482170938
5418, 0.86731481743668, 0.20859135859708, 0.079168730566773
5419, 0.45089488799722, 0.59517881642859, 0.052363056640129
5420, 0.6848551499482, 0.049650709464503, 0.052362201788232
5421, 0.65351790205356, 0.86272599672796, 0.022430011912013
5422, 0.61496230790685, 0.53203605820232, 0.042786665451548
5423, 0.86028949276143, 0.63718543198195, 0.053673269509088
5424, 0.85883977634207, 0.54408447786066, 0.02128680948817
5425, 0.78323655262492, 0.60826098582532, 0.020680243035608
5426, 0.52008942386617, 0.85823061439283, 0.021731517241942
5427, 0.7071087478072, 0.24383979062464, 0.080116689466412
5428, 0.85190764234053, 0.38746360154674, 0.079445775282356
5429, 0.73502660341823, 0.52679565087912, 0.046978078232447
5430, 0.60205286716836, 0.8868812549913, 0.050910076751026
5431, 0.88827812552139, 0.73200077050454, 0.077412739423543
5432, 0.65025543572329, 0.35470209901382, 0.080477909875116
5433, 0.67506177490095, 0.24313620049184, 0.079205836308298
5434, 0.69978038485849, 0.2395067732178, 0.048457094543978
5435, 0.64965475876169, 0.48390982465737, 0.042021406783643
5436, 0.82435404513728, 0.27762799376411, 0.080329301333814
5437, 0.50974518962773, 0.83710812832748, 0.079994220768239
5438, 0.64910566954468, 0.19165886475422, 0.054105242531372
5439, 0.62857714928553, 0.68001540057924, 0.022184608950623
5440, 0.57218962811564, 0.7895700533168, 0.021106754187742
5441, 0.53510514032715, 0.58814358590178, 0.078274297035816
5442, 0.64487137722026, 0.12606005213612, 0.052217721676742
5443, 0.78064240994258, 0.052971431117198, 0.067149160779613
5444, 0.45828844838161, 0.47168142575123, 0.050415752368492
5445, 0.66386879900892, 0.47486476202534, 0.058048817705544
5446, 0.7227925036717, 0.73943474100213, 0.020518943030749
5447, 0.91853419954042, 0.57177109127943, 0.045940959398612
5448, 0.7302449995705, 0.48623130960767, 0.046797541518366
5449, 0.45905100815353, 0.50836119841111, 0.047473413952876
5450, 0.57831463164793, 0.52876636611436, 0.019986180776038
5451, 0.9181361180074, 0.21458064073303, 0.0213504662571
5452, 0.90985226604906, 0.020168553467938, 0.050584808226382
5453, 0.80028144710283, 0.01988980491326, 0.06283925273869
5454, 0.59751525480227, 0.74310060314275, 0.019674119475192
5455, 0.86401221232682, 0.66825829708927, 0.051260184146767
5456, 0.79874184045771, 0.64755766936351, 0.079348274481055
5457, 0.76771126853731, 0.80523654346673, 0.078569124317824
5458, 0.40751388924762, 0.62984556269892, 0.022298799132982
5459, 0.50149066888298, 0.76015439862524, 0.022920024068157
5460, 0.80468370793569, 0.73712071375537, 0.020432171745783
5461, 0.89593047867669, 0.25084870700742, 0.021690051051805
5462, 0.64995612907859, 0.57733215177855, 0.02088770116033
5463, 0.82378103736506, 0.67641701462134, 0.080479114115323
5464, 0.88381174648425, 0.16264367131257, 0.078732336014429
5465, 0.55226211527936, 0.48088917116818, 0.057481232591083
5466, 0.73732476937055, 0.60135439334089, 0.053319930589229
5467, 0.78391942027051, 0.75259868768558, 0.080794733603044
5468, 0.72543633432932, 0.077765978792987, 0.08042360219506
5469, 0.5997346472337, 0.54311783758323, 0.079516273165282
5470, 0.87885492374593, 0.59897163915781, 0.048529856131174
5471, 0.50363943847839, 0.6171474541348, 0.020091472231888
5472, 0.58800163430551, 0.42981005926718, 0.081010222895399
5473, 0.49499237387881, 0.64702398762772, 0.047816363762966
5474, 0.88939189391172, 0.57491557140512, 0.078499929225233
5475, 0.65186146538275, 0.7031745733526, 0.019522814243111
5476, 0.71082036101805, 0.51682015352094, 0.079569690124335
5477, 0.66247606664606, 0.1466347543644, 0.021726097716366
5478, 0.4212145953604, 0.53638485191556, 0.023265185711295
5479, 0.64518162806401, 0.74008658781345, 0.080456932040032
5480, 0.83865180523685, 0.36854852235463, 0.053917578043873
5481, 0.46494828425549, 0.64434668742315, 0.048235878964102
5482, 0.81897428553609, 0.7528529547405, 0.080291762983364
5483, 0.67877685348594, 0.55483945008634, 0.080543649920953
5484, 0.89277893641947, 0.76905668239923, 0.054401289122833
5485, 0.66708289534893, 0.13140186757422, 0.078509174164903
5486, 0.48188889360059, 0.79058393797562, 0.079585344095043
5487, 0.4969370950252, 0.53577099901257, 0.080370214376225
5488, 0.81718327844952, 0.70869252710095, 0.052879106660507
5489, 0.67544095751189, 0.57580615031549, 0.047465208838689
5490, 0.78838058673618, 0.33035297976711, 0.079831132751899
5491, 0.6412300496499, 0.22410844170839, 0.079106279093647
5492, 0.61658079048663, 0.79795437550343, 0.021794505248161
5493, 0.65937186864244, 0.49049741526113, 0.021448046446581
5494, 0.70389432787301, 0.71358569812166, 0.059622035115366
5495, 0.78784797473501, 0.018614627209555, 0.018801541188803
5496, 0.69852608596129, 0.37341103316179, 0.019979303077986
5497, 0.7623718781427, 0.43797755976719, 0.079534908931626
5498, 0.78543447435438, 0.7601659335771, 0.052763422584092
5499, 0.72706262707777, 0.47257306967347, 0.079972407812534
5500, 0.46207178797236, 0.65541006182581, 0.019620006444544
5501, 0.79093537181501, 0.69764175954009, 0.01974691252512
5502, 0.78852619793516, 0.55604022768359, 0.01984493997217
5503, 0.4310470568748, 0.64920707549492, 0.020849074198102
5504, 0.68009161856262, 0.75069956050941, 0.021363231558696
5505, 0.85274936466021, 0.39163008232005, 0.054069654638192
5506, 0.71496916386487, 0.46290572310022, 0.021088496724932
5507, 0.60461878419904, 0.42134015699187, 0.019092433583123
5508, 0.90256191072669, 0.3861685375646, 0.019603571146347
5509, 0.65542984219797, 0.39922652331707, 0.079190335014279
5510, 0.64881344639801, 0.10141514197401, 0.050323511945105
5511, 0.83552355231153, 0.65026567401291, 0.03945386184024
5512, 0.70701913250631, 0.12537891332841, 0.07946382970352
5513, 0.62791205217362, 0.64361877099387, 0.055611564298025
5514, 0.62623135084741, 0.61347428473375, 0.079798906317268
5515, 0.80025138772498, 0.68509105975913, 0.052751825812317
5516, 0.49317868826382, 0.6822506375148, 0.021226864557141
5517, 0.56082932954844, 0.68508835860586, 0.079754536028491
5518, 0.88484167048594, 0.69892782851693, 0.046494992541928
5519, 0.62694406506291, 0.46042765465278, 0.02008870868981
5520, 0.76940241442452, 0.57770476260468, 0.020521579206569
5521, 0.66156487870345, 0.48633069354684, 0.079663447283329
5522, 0.67435459325399, 0.3247286614998, 0.043639300812149
5523, 0.72432692109196, 0.23349833971193, 0.019060253902865
5524, 0.39498038473196, 0.52449850218466, 0.080674283290741
5525, 0.65974005339668, 0.60930020363881, 0.020486806198629
5526, 0.69503061951601, 0.84083564338758, 0.078118628713941
5527, 0.63849408265838, 0.82861289159525, 0.078417423565276
5528, 0.68652213259331, 0.025609849226118, 0.01987234962419
5529, 0.80059375183622, 0.24099038588233, 0.052676880865517
5530, 0.6750412654652, 0.72936005229804, 0.021574889097686
5531, 0.78278073670132, 0.020561501445497, 0.049595509506151
5532, 0.75928387595144, 0.61051874396044, 0.046571575219852
5533, 0.8312670236819, 0.71136399055894, 0.021421025676723
5534, 0.87954798089225, 0.38457701993793, 0.053766578182532
5535, 0.72218553829812, 0.81195276707717, 0.078636392812806
5536, 0.7878551271191, 0.36175411484971, 0.020297879377048
5537, 0.67512455603075, 0.78378594196516, 0.02017815374276
5538, 0.81842222898047, 0.59885462041519, 0.043910045910316
5539, 0.86497744664479, 0.19283595624392, 0.020368068891117
5540, 0.70928329990848, 0.43072479703311, 0.019622121016873
5541, 0.64617145250132, 0.43461170084373, 0.062112313110693
5542, 0.56382342358174, 0.60351264498929, 0.055959760346193
5543, 0.74093492157895, 0.35860161760473, 0.044657609957855
5544, 0.76714684770065, 0.77261412962414, 0.05187701443448
5545, 0.82139384079498, 0.48671493497384, 0.019469296191791
5546, 0.69827799103743, 0.36186085282357, 0.046202545975826
5547, 0.87026307174146, 0.72239751159194, 0.021844706904725
5548, 0.58061487920935, 0.7631075089536, 0.080215155988314
5549, 0.6147803873304, 0.29666023996224, 0.077357937161692
5550, 0.91958949051279, 0.38321436746578, 0.042262586306376
5551, 0.86094428647802, 0.68369816564267, 0.080311888674672
5552, 0.65642379151681, 0.67129529280347, 0.080014212614986
5553, 0.54448684364164, 0.71638269107551, 0.055117760923101
5554, 0.5540440080029, 0.704699017886, 0.019618593538659
5555, 0.59198143580518, 0.47893203096032, 0.055190501887004
5556, 0.38862404841689, 0.5699031520308, 0.022252575216398
5557, 0.88613292927471, 0.55578107753775, 0.051389536164924
5558, 0.49863712717265, 0.76558435787657, 0.079259770203568
5559, 0.58404638227812, 0.65626417833052, 0.053366095208712
5560, 0.7918986730516, 0.082177893359832, 0.0804682635794
5561, 0.55685520429546, 0.38835473213573, 0.079615032050823
5562, 0.37691502182766, 0.53595696248687, 0.022968606630451
5563, 0.81622002834636, 0.82318238776701, 0.022854684030095
5564, 0.88030298787257, 0.65377172548057, 0.020215940679147
5565, 0.60004193503672, 0.30946919571092, 0.021960653822456
5566, 0.76487677361918, 0.74008083246972, 0.080514057699837
5567, 0.37459026864856, 0.60635076456922, 0.019190969546357
5568, 0.60111423011592, 0.69044501753303, 0.080231608970243
5569, 0.53100113956331, 0.41373721860769, 0.020337406193762
5570, 0.59674942680556, 0.56580618950658, 0.019810660493185
5571, 0.91847063526387, 0.79576687027491, 0.021004428856936
5572, 0.91654924504496, 0.12875314034694, 0.056513400004476
5573, 0.63764584871651, 0.48998382344471, 0.019763660526597
5574, 0.67668585790728, 0.54297844831174, 0.052919639031901
5575, 0.78001476439006, 0.14928331131147, 0.019074865838274
5576, 0.51840110137514, 0.47299855446253, 0.02035198013969
5577, 0.47000818589142, 0.77056039103618, 0.048400731918199
5578, 0.85087126847296, 0.61898854524761, 0.045904671876098
5579, 0.85749277634575, 0.31049701185949, 0.079145616412223
5580, 0.6304690783087, 0.24991857958125, 0.02973875780946
5581, 0.83079784462655, 0.24449411833357, 0.049721014680639
5582, 0.91744093186289, 0.71865678716902, 0.049510146216271
5583, 0.91721493326837, 0.66071431012061, 0.077734005784429
5584, 0.73142610426193, 0.3588758008525, 0.02011504908821
5585, 0.70206574741041, 0.44863434296355, 0.080428993529457
5586, 0.868825044266, 0.22738804009127, 0.047295152938208
5587, 0.68711597491526, 0.50018039052669, 0.080566547845473
5588, 0.88329396135792, 0.019912466957941, 0.021496429670344
5589, 0.83236552905725, 0.78314286586652, 0.019914450966831
5590, 0.67691931328896, 0.34984155884369, 0.047702039401262
5591, 0.89768752747393, 0.62271473161109, 0.018923292018372
5592, 0.71090264712646, 0.16102352661774, 0.020742163264535
5593, 0.62377680383294, 0.27254296229017, 0.047507779573692
5594, 0.69644150324258, 0.26111240983851, 0.019685361211052
5595, 0.45973309812537, 0.74859633578673, 0.019263976471543
5596, 0.5189647279735, 0.80830791702778, 0.046944343429552
5597, 0.89605034031724, 0.30481999575688, 0.02073441623976
5598, 0.54323462411067, 0.89809187908459, 0.050484182767515
5599, 0.76397820525447, 0.40257203687647, 0.079973951724983
5600, 0.59533545015938, 0.53960842425528, 0.052978787341277
5601, 0.4942695847564, 0.51423063532489, 0.079616707733602
5602, 0.67759718383898, 0.17142575015687, 0.078656851697433
5603, 0.61646257958655, 0.6001933538908, 0.019549044152428
5604, 0.70602098519893, 0.65788185871256, 0.04608678142086
5605, 0.54664210129058, 0.85270081531612, 0.02271336329408
5606, 0.45239441965034, 0.52998002522931, 0.020650728703126
5607, 0.58867937658352, 0.59460905371771, 0.040897504765479
5608, 0.82879122413147, 0.048186649616919, 0.048819057892513
5609, 0.70570295393047, 0.55650188975199, 0.080439896535114
5610, 0.81293198310574, 0.74152323066391, 0.047553275067451
5611, 0.63799088054892, 0.5181167371925, 0.047030322114847
5612, 0.75667045263281, 0.26185540806839, 0.020854929866883
5613, 0.91685306801193, 0.78861813325423, 0.078251792161906
5614, 0.7179722146098, 0.044432783202524, 0.02079049128117
5615, 0.73943757838171, 0.13482395736897, 0.078379483748363
5616, 0.51360800166799, 0.5876609614138, 0.079902576118741
5617, 0.74837802325464, 0.61182236068875, 0.019208594590504
5618, 0.81738192163428, 0.15454877801732, 0.081110703141305
5619, 0.49128488351118, 0.69750768067738, 0.080763128964327
5620, 0.92001437828829, 0.49716750988186, 0.077594828822787
5621, 0.83108513142417, 0.12129267464136, 0.079638687041211
5622, 0.67923628737625, 0.743026557995, 0.081013393175588
5623, 0.68371508151233, 0.84316428667039, 0.021162560540363
5624, 0.89008442506344, 0.54536726830558, 0.07931399285483
5625, 0.89455809167256, 0.21865565553224, 0.019682014573823
5626, 0.62803072335395, 0.53676996706487, 0.079334539714817
5627, 0.80806966228689, 0.18717104867182, 0.079634113447991
5628, 0.8925305128883, 0.068065015401884, 0.052971482993678
5629, 0.88322537644112, 0.68163688122872, 0.079927061459551
5630, 0.86133908080268, 0.60300243822306, 0.079282435092391
5631, 0.5101003042688, 0.53675441144939, 0.04657707621566
5632, 0.91957681457824, 0.41553125231421, 0.019920767615374
5633, 0.64498884996438, 0.73999486272882, 0.018983574205511
5634, 0.67964840125312, 0.40084705577558, 0.019189399199438
5635, 0.69945334296669, 0.31967464923484, 0.019178357553732
5636, 0.76754723838239, 0.42276313089948, 0.021564400798014
5637, 0.36176708910435, 0.58156586789361, 0.022535374831304
5638, 0.72738029943151, 0.84032650142169, 0.021643775592137
5639, 0.54188685586315, 0.88265702281648, 0.079542719707575
5640, 0.73875472008337, 0.71480927128769, 0.080232368956581
5641, 0.73998495084576, 0.084731688599367, 0.047573552166352
5642, 0.69197930807984, 0.69423445563968, 0.018705611546206
5643, 0.65940449433219, 0.16068949449957, 0.046705258241823
5644, 0.8056647130522, 0.51972204267551, 0.019260919790469
5645, 0.81347569889863, 0.42042307652373, 0.019107932416437
5646, 0.63189705755965, 0.17495447214345, 0.020724637984376
5647, 0.81964910567216, 0.050322672890263, 0.078633540373207
5648, 0.74012187408716, 0.49733409628874, 0.08078421281078
5649, 0.81900725896179, 0.36135239584438, 0.047694753077872
5650, 0.51675456618965, 0.44227741833478, 0.01966404559379
5651, 0.52222974056279, 0.40634368828837, 0.080866629977761
5652, 0.54178170015254, 0.46492865598322, 0.047828174475281
5653, 0.44780959126659, 0.47782835664943, 0.020820160922452
5654, 0.61089097398747, 0.23511020634571, 0.046201033616615
5655, 0.59208836572608, 0.57643823961867, 0.052246546139536
5656, 0.91951812794975, 0.047932867440814, 0.02167668058857
5657, 0.86536500015069, 0.19076558238943, 0.046640411074263
5658, 0.69859294642786, 0.7661286173114, 0.020084589222507
5659, 0.73294643684723, 0.65585552788567, 0.079848031757193
5660, 0.80284585502827, 0.73853815031413, 0.079994869752098
5661, 0.83982838248526, 0.75824450884453, 0.081181639119816
5662, 0.8234539081948, 0.44768377068945, 0.081038169939538
5663, 0.76422870601644, 0.57076058771181, 0.081028507872159
5664, 0.85408892264059, 0.62001267032854, 0.019394556397137
5665, 0.91970007144247, 0.75147058137651, 0.07927990985162
5666, 0.50296954763813, 0.82016063626771, 0.019669474002452
5667, 0.91966541937842, 0.39851899028692, 0.08003942626201
5668, 0.89682631573611, 0.46123188246754, 0.080039131689681
5669, 0.72690289390847, 0.019612497712691, 0.078985054649533
5670, 0.77746268175607, 0.8280686555873, 0.080808363339697
5671, 0.671470094535, 0.28177112946441, 0.080478532678748
5672, 0.61824955019692, 0.74399721511529, 0.049765481951676
5673, 0.64512717228682, 0.41015347433026, 0.019545673418362
5674, 0.69001858855563, 0.43951500836346, 0.046664102582106
5675, 0.71877702925567, 0.11552779502191, 0.020547342240593
5676, 0.83793394489293, 0.20730939848078, 0.050457801584272
5677, 0.62855193372652, 0.37695625777991, 0.019259373123324
5678, 0.57883951657765, 0.48621653458812, 0.08025610716133
5679, 0.59611108035301, 0.40109095333517, 0.081304423089912
5680, 0.55496082765784, 0.85292369731701, 0.047130400200509
5681, 0.80096006094404, 0.42221953528575, 0.079370093757861
5682, 0.70117556385141, 0.82208967641305, 0.049826789690165
5683, 0.53984553947979, 0.40564641187778, 0.052801697150122
5684, 0.9205314379989, 0.71650033018265, 0.079709459408345
5685, 0.91760131824748, 0.091493737231262, 0.076747362392934
5686, 0.54804192181841, 0.80474467320752, 0.020272481417732
5687, 0.76797213967843, 0.40994026410458, 0.052836886476574
5688, 0.83937744876068, 0.43029112316205, 0.078550371862312
5689, 0.79109968240405, 0.11561764539653, 0.049226265480728
5690, 0.63079228712873, 0.54822019117709, 0.051327753249245
5691, 0.50461481789409, 0.61232086006242, 0.079710590596261
5692, 0.61754176699487, 0.71434802375135, 0.081172437641846
5693, 0.70230255588544, 0.61483069713835, 0.019643719964369
5694, 0.45689307199672, 0.50429598871759, 0.078373171123383
5695, 0.40275908641269, 0.59120582617269, 0.081224191199473
5696, 0.54630631391018, 0.69470131506226, 0.046668818669119
5697, 0.71695841967696, 0.086028175107018, 0.019132008116071
5698, 0.75992047370004, 0.53321498401393, 0.037373905653087
5699, 0.60741286959675, 0.65505065015515, 0.081283138128061
5700, 0.58922297800997, 0.72678728321135, 0.050028286977351
5701, 0.6793861444248, 0.53535039302225, 0.018667750324435
5702, 0.45031901884446, 0.69436017398055, 0.019102952688183
5703, 0.60884877941903, 0.70764837304476, 0.050034954813191
5704, 0.91847813574858, 0.55928776080217, 0.079343487679797
5705, 0.66708277914144, 0.34158878402256, 0.080511123826105
5706, 0.51422983393654, 0.48276264034599, 0.081544595558856
5707, 0.65070697071073, 0.7034104377569, 0.080932470662095
5708, 0.89093382254717, 0.35878859151412, 0.062502789356613
5709, 0.64039726315083, 0.62944587202738, 0.022116314155743
5710, 0.54206078001328, 0.46859536473363, 0.019915284489979
5711, 0.91864143062096, 0.25271288019019, 0.020857411453253
5712, 0.62619493242104, 0.87604739488741, 0.079244504708236
5713, 0.6508025550749, 0.064197475845922, 0.051872363515774
5714, 0.51536888893885, 0.40179891378234, 0.035865422954937
5715, 0.91978185120697, 0.45780732512653, 0.052592090463664
5716, 0.81004843478415, 0.62519169765002, 0.04696807751376
5717, 0.66777961753661, 0.78094959089813, 0.04323048203224
5718, 0.81062850283875, 0.3307495535072, 0.020921922379267
5719, 0.57671880180825, 0.60072421887166, 0.081145639205938
5720, 0.82464891650548, 0.451514602977, 0.059960165064588
5721, 0.53872729971609, 0.63830872685352, 0.081277489936161
5722, 0.42444835179732, 0.6948563674024, 0.020475456136817
5723, 0.88970273451908, 0.43254781158879, 0.020292546486318
5724, 0.70452118755018, 0.32110210893165, 0.044612209566169
5725, 0.77477252773223, 0.039176096263935, 0.019579738543895
5726, 0.58330407897168, 0.79214855789053, 0.051064893546858
5727, 0.91922293816431, 0.27387257735026, 0.079509955932469
5728, 0.72216639368904, 0.65951183708298, 0.060234512251203
5729, 0.75539314170629, 0.59141174736768, 0.080989802448796
5730, 0.60291001841961, 0.70748999182095, 0.019804577087509
5731, 0.56319130906467, 0.55166813347315, 0.081245322967141
5732, 0.74640647425789, 0.028369970133866, 0.019671890978747
5733, 0.66573323440813, 0.24096891232369, 0.019892573725588
5734, 0.79103174798394, 0.82638504572713, 0.0464754545142
5735, 0.83480327273394, 0.5372254790709, 0.018737943885005
5736, 0.47153549645158, 0.73240169918778, 0.078463145291588
5737, 0.69753112119859, 0.65597278344344, 0.081172923228903
5738, 0.81299760445455, 0.6211392977402, 0.019321444486101
5739, 0.88225886737198, 0.74187700650043, 0.046997322935977
5740, 0.82693036060824, 0.57891933664222, 0.080257650001364
5741, 0.78183585571374, 0.09070853822714, 0.018526242699222
5742, 0.77804150017997, 0.6685600297893, 0.080982844717478
5743, 0.52256998535463, 0.58825217307362, 0.019530837683776
5744, 0.5602437810387, 0.67077640202972, 0.047995845151641
5745, 0.48512880503869, 0.53850206541415, 0.057141800956847
5746, 0.91916580253647, 0.74642120901257, 0.021521064248242
5747, 0.6682783162263, 0.65228375451805, 0.080989761546841
5748, 0.78334212103369, 0.63318486288106, 0.08166535102979
5749, 0.61241116497164, 0.63270545677692, 0.046306399964562
5750, 0.75962777455066, 0.073055172743857, 0.019456856149238
5751, 0.63619755966293, 0.48058768043849, 0.081522171224011
5752, 0.73300686193799, 0.5748721001385, 0.018798491522301
5753, 0.86485893727982, 0.51431673572601, 0.052491441089071
5754, 0.73740285500121, 0.16006794883471, 0.049229146550345
5755, 0.693617305387, 0.18888976734563, 0.080474842291592
5756, 0.82171644261579, 0.51993144229505, 0.08016939865079
5757, 0.83402531129759, 0.46294928251139, 0.020355856382813
5758, 0.91845776968921, 0.44736818536633, 0.020937759751639
5759, 0.54094920541704, 0.37162097818277, 0.021249854051843
5760, 0.83986898012245, 0.33049716325835, 0.05573483196602
5761, 0.70186244757439, 0.74989112048109, 0.050284979044039
5762, 0.82479729673482, 0.089452679367647, 0.052101459950511
5763, 0.89610944146112, 0.38022666283105, 0.080874525756034
5764, 0.37657802422033, 0.6082660110777, 0.081016120816298
5765, 0.9188849141045, 0.33346839637922, 0.079318147808706
5766, 0.4887022362176, 0.7457210089396, 0.050434437038093
5767, 0.69794328674459, 0.4611054730058, 0.047460675338424
5768, 0.73835042161268, 0.63035219916193, 0.021051703796419
5769, 0.56112878094639, 0.58901732920966, 0.035188410297852
5770, 0.39556991620948, 0.5203282161521, 0.059961527672494
5771, 0.58917978919403, 0.33454033980544, 0.020144957071537
5772, 0.73736862010953, 0.053596294004334, 0.02029772066565
5773, 0.9210983757703, 0.1987636809291, 0.045387338074836
5774, 0.61255327105785, 0.49437251786468, 0.079957490668626
5775, 0.81305627408636, 0.10912505244746, 0.080014131192473
5776, 0.48281508752052, 0.44025155887342, 0.045463963824264
5777, 0.92094742015749, 0.41656961167998, 0.044896332351301
5778, 0.76569234292765, 0.3806530293311, 0.080788285052352
5779, 0.5967820743938, 0.54010630113198, 0.018253591388797
5780, 0.90263100033393, 0.017754589536806, 0.017741450484991
5781, 0.89327842395531, 0.12576344957649, 0.020891597358235
5782, 0.47677756933178, 0.72697887207469, 0.019738363644852
5783, 0.84511644822506, 0.46726230227051, 0.049935193340602
5784, 0.71065320198637, 0.66668512938172, 0.017828765906
5785, 0.51688539670981, 0.55704178030719, 0.079902822929749
5786, 0.83037278463902, 0.66064949701663, 0.057128347752457
5787, 0.69218607056783, 0.44316970350305, 0.018833691492396
5788, 0.62767578343757, 0.34686531033426, 0.07926114982816
5789, 0.63796198553718, 0.52047281672075, 0.020350488776129
5790, 0.83985713216019, 0.64798922168726, 0.018875862762591
5791, 0.80969008759822, 0.18691107181635, 0.019778740543339
5792, 0.89926718195762, 0.62894205169842, 0.080606165114296
5793, 0.66181456101298, 0.83773455745475, 0.052243041923372
5794, 0.77450807435717, 0.39550098114211, 0.019565450646214
5795, 0.84620376225408, 0.66029182975415, 0.080934791715585
5796, 0.68057182103721, 0.37072981150807, 0.053470325068652
5797, 0.62301080619905, 0.19704403776834, 0.022613417754665
5798, 0.5080428382033, 0.44140113161906, 0.080281303451954
5799, 0.67319193356078, 0.31011706501804, 0.081152228024017
5800, 0.74570672068133, 0.17824168885311, 0.079345814641579
5801, 0.57836978708367, 0.38558462301394, 0.080214624421545
5802, 0.66760482482007, 0.11645339851912, 0.04878718577149
5803, 0.6641083081781, 0.72847389374663, 0.080469342187539
5804, 0.75024259338462, 0.3332404340539, 0.018329608341087
5805, 0.78348645260631, 0.66895079098031, 0.020032926471467
5806, 0.60276278356843, 0.41391238024294, 0.053678782497314
5807, 0.8857504724209, 0.19942310652574, 0.04650779703104
5808, 0.85011137974809, 0.43330808887987, 0.050166964276868
5809, 0.67327518599988, 0.5554068773019, 0.018821529025159
5810, 0.61903418576812, 0.39932556167524, 0.079104958284394
5811, 0.87920895802686, 0.41403125356842, 0.079033008481256
5812, 0.47725606207129, 0.62290387750763, 0.043422156023104
5813, 0.82339989905417, 0.51084128285697, 0.04723534330186
5814, 0.62372026664966, 0.19475566005935, 0.056769004609162
5815, 0.62102272207656, 0.63916812872528, 0.082133555296369
5816, 0.65453733398878, 0.79075461030482, 0.018841797959017
5817, 0.8185912037906, 0.63607820200087, 0.081648833341737
5818, 0.9190057761841, 0.67679084725658, 0.025135827057339
5819, 0.91943792066275, 0.65487556172169, 0.020146429854769
5820, 0.88879908970202, 0.68782663077641, 0.021270342152776
5821, 0.89656382955357, 0.33029204896258, 0.019684847939709
5822, 0.73062013262606, 0.73692624495842, 0.081411032433223
5823, 0.85505371132875, 0.41468335939551, 0.020245103658008
5824, 0.54473166316806, 0.7651581087822, 0.019032319618345
5825, 0.39181160048479, 0.61932884308033, 0.054290023253965
5826, 0.64679667415286, 0.29606854837843, 0.020826453521933
5827, 0.91737647038866, 0.6847164692832, 0.055302430479936
5828, 0.55037217928157, 0.67285381559371, 0.017535344998787
5829, 0.81103175134456, 0.24955590246237, 0.018965277191223
5830, 0.82173646649659, 0.40164572334972, 0.058324302351256
5831, 0.77250306977266, 0.77950463788259, 0.020676557293649
5832, 0.71242654273207, 0.16012286446326, 0.060582385259981
5833, 0.73460287859102, 0.69323544817678, 0.079910533710226
