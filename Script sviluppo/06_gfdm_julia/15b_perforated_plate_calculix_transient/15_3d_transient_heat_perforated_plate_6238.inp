5834, 0.57818326989606, 0.89806627588658, 0.073918086767161
5835, 0.39142249407101, 0.55898422209182, 0.054490305294632
5836, 0.68768944578806, 0.18663801925582, 0.020401543360382
5837, 0.68271258382595, 0.16628415631546, 0.019431109526272
5838, 0.63301751511875, 0.2980751300307, 0.047878854125353
5839, 0.43959708630794, 0.48586826039446, 0.052170177815942
5840, 0.59000936604049, 0.45771455257501, 0.018142045594091
5841, 0.71686785107875, 0.11576317006422, 0.044410738425842
5842, 0.8460746287227, 0.57678589128723, 0.049954278657827
5843, 0.60837738533081, 0.24485281022843, 0.020592314802862
5844, 0.57465429882709, 0.35955841410923, 0.020005380536374
5845, 0.56204455389819, 0.8730656998242, 0.02110464028827
5846, 0.7989775281241, 0.5181835821292, 0.080249403687405
5847, 0.79470249458406, 0.74137252793081, 0.057795642789859
5848, 0.6309749224506, 0.76369710676182, 0.081570173334282
5849, 0.48409199559215, 0.62403658794389, 0.019540299190202
5850, 0.56631075081788, 0.43591530142552, 0.019236631357285
5851, 0.85898903955741, 0.2497472455694, 0.07908571357011
5852, 0.89291984648222, 0.56214738921998, 0.019619658547731
5853, 0.82783128832123, 0.55565136089001, 0.080804934825082
5854, 0.47326983412157, 0.58035035131292, 0.081467597723199
5855, 0.76754873188936, 0.13037998870298, 0.080150637088061
5856, 0.73649280665816, 0.50113656534367, 0.060054477848944
5857, 0.68829826308949, 0.46524315039732, 0.080193035448587
5858, 0.64108306765752, 0.43921039639812, 0.081695881382834
5859, 0.64897053009184, 0.64463708410168, 0.080406372851646
5860, 0.85976267104624, 0.75817178132342, 0.020735525856427
5861, 0.75222098072179, 0.62711433935867, 0.057041938286987
5862, 0.52777319250848, 0.82694598746939, 0.081276312211454
5863, 0.61665692838533, 0.59171163904571, 0.079602164096807
5864, 0.75428094852785, 0.17657810410052, 0.018293405040754
5865, 0.83747809383047, 0.58695738522876, 0.017871963683372
5866, 0.7709615123587, 0.14125335497776, 0.052658105897168
5867, 0.58340627886099, 0.67266595850631, 0.080932792208137
5868, 0.80090479817213, 0.45034113454408, 0.079779948300292
5869, 0.82571670461645, 0.018950728892855, 0.056624815409731
5870, 0.5741270292656, 0.82502359553339, 0.019067857937276
5871, 0.73718097198227, 0.7823618877956, 0.080113620518817
5872, 0.70729395628765, 0.40508898454039, 0.019993833165493
5873, 0.41282069768877, 0.59309304168376, 0.060914120309666
5874, 0.71268809847822, 0.2748545820548, 0.032630904439948
5875, 0.79086964028279, 0.040180438902149, 0.052672762058987
5876, 0.67892148442589, 0.50880111042991, 0.053306662951822
5877, 0.71664862999736, 0.58362652514627, 0.081112509827589
5878, 0.87942121582482, 0.48507232815723, 0.054938336966516
5879, 0.89088286330486, 0.077072230228533, 0.080395681419955
5880, 0.75872991640439, 0.42453704433786, 0.040942885183453
5881, 0.80778209165698, 0.79563247060617, 0.021045563061377
5882, 0.80662647483807, 0.32786232611721, 0.067932202137055
5883, 0.71646433991191, 0.8449009306167, 0.079353787640638
5884, 0.76116121564294, 0.31955256295837, 0.079471190134463
5885, 0.60497944965379, 0.79033265726107, 0.065725134254998
5886, 0.53322846876898, 0.76572634641766, 0.080360913573745
5887, 0.77518852003341, 0.60333882861791, 0.057868367737025
5888, 0.92099395038323, 0.1777239614861, 0.046754409923583
5889, 0.68276079445022, 0.07905303721548, 0.05612681095034
5890, 0.74584160664062, 0.053948602733479, 0.042507687151798
5891, 0.7496232775114, 0.13598323328931, 0.036827544219694
5892, 0.56107247029185, 0.55402995005806, 0.017825807153477
5893, 0.77803996273248, 0.25585226508245, 0.081279217169857
5894, 0.74270834189421, 0.29375387604649, 0.017771574385798
5895, 0.75990440323375, 0.55379064555672, 0.040881904078246
5896, 0.81505056497699, 0.29164067174427, 0.020472628649214
5897, 0.92089885459413, 0.55412606115945, 0.057319456237039
5898, 0.79362438554294, 0.57358551170046, 0.081425921896134
5899, 0.72834214272258, 0.81905296828122, 0.019077199676788
5900, 0.66494910004792, 0.33536785369271, 0.018258879187556
5901, 0.71638630349617, 0.43357144056974, 0.079712866968062
5902, 0.87607453315012, 0.79446478482918, 0.063988226024129
5903, 0.54570654721681, 0.6527447130762, 0.018088759535437
5904, 0.87205438836471, 0.3266679771479, 0.078863747219215
5905, 0.43297404495356, 0.51956162997414, 0.080085810194965
5906, 0.64567900823038, 0.79620409423145, 0.08126788165214
5907, 0.45729692129688, 0.69797089057385, 0.038143406003804
5908, 0.53448293287933, 0.83469910791577, 0.020999258799123
5909, 0.7611425097776, 0.31048972849241, 0.052080797526918
5910, 0.83782429543063, 0.34620139130524, 0.08082389538465
5911, 0.51135209135817, 0.64984909125425, 0.08197264498378
5912, 0.84178507979452, 0.6688051404236, 0.018128001289191
5913, 0.74985509413857, 0.71808158460729, 0.042974304884821
5914, 0.72770285022007, 0.61142922720705, 0.018345974379798
5915, 0.88183621984349, 0.14022964933444, 0.080340239598212
5916, 0.65871849921519, 0.22626908719025, 0.051614115971182
5917, 0.58233653931713, 0.48842279623015, 0.017355658239729
5918, 0.81774999810548, 0.2988666892913, 0.051027426648584
5919, 0.76522639899432, 0.8256596863306, 0.018968212552258
5920, 0.67349196307825, 0.83145442280984, 0.079504589707287
5921, 0.49388421989927, 0.42711788193454, 0.075750943826101
5922, 0.90145702585507, 0.18617327754016, 0.041809832045084
5923, 0.79677732388313, 0.39566759710987, 0.019807372801924
5924, 0.61808068072897, 0.62146867853915, 0.062633681235731
5925, 0.56117219949077, 0.46311562017107, 0.041369714605865
5926, 0.77653643218116, 0.34468815913714, 0.058793663815912
5927, 0.88764792617698, 0.58026254575769, 0.051535335735548
5928, 0.73477281255237, 0.11488548068551, 0.081934335696599
5929, 0.89552642027575, 0.25706931540683, 0.081047738579219
5930, 0.71601937442263, 0.35091076120212, 0.04647773342284
5931, 0.62076113804928, 0.4334115459508, 0.050020554391288
5932, 0.86130015588731, 0.11436233387325, 0.079620571853111
5933, 0.57323070522511, 0.52711872475224, 0.082007016482944
5934, 0.86814208388561, 0.019953563014091, 0.049198791682361
5935, 0.73260881884646, 0.13534262905736, 0.017951648244393
5936, 0.72404948679994, 0.089907846789656, 0.05954316680045
5937, 0.91752610581571, 0.68734905956238, 0.077767305590645
5938, 0.63179917488264, 0.49046147432477, 0.049728200118975
5939, 0.8524826560313, 0.78851307365543, 0.018884194848038
5940, 0.68049838203018, 0.27241485629278, 0.062560403558075
5941, 0.89859784541076, 0.44615379221201, 0.041178574087016
5942, 0.69930953941419, 0.30226270853054, 0.081334434025682
5943, 0.78218731153709, 0.79326822943759, 0.067216687847637
5944, 0.79712528060791, 0.36266132053865, 0.080729225587561
5945, 0.89869993797523, 0.75208722747969, 0.08139341878421
5946, 0.73187491999367, 0.41089500522904, 0.017425218386062
5947, 0.53935220896373, 0.37255456322478, 0.079549501860566
5948, 0.88723998642627, 0.21956980418355, 0.040418820972827
5949, 0.66625991041181, 0.069205558378278, 0.080991603469081
5950, 0.67923715615171, 0.59957071296488, 0.082055339538191
5951, 0.6454501411826, 0.58968414616861, 0.081731926674664
5952, 0.7368687889544, 0.81476109226655, 0.038664441094518
5953, 0.7978478280085, 0.46381498025696, 0.06315164429324
5954, 0.62459293472152, 0.54082154289138, 0.018015767340057
5955, 0.46949126804834, 0.6385829944071, 0.082367085782488
5956, 0.84737992979386, 0.19627872987938, 0.081994577708656
5957, 0.69388057351698, 0.67951828838165, 0.080674944156791
5958, 0.64580657967215, 0.10173863216723, 0.080647084841278
5959, 0.71507970571953, 0.16400367075604, 0.08102002523428
5960, 0.78494789081079, 0.54481380124884, 0.082273261553488
5961, 0.83220731271139, 0.10008712946067, 0.019828923395662
5962, 0.43321846765798, 0.58628800470855, 0.047758590250446
5963, 0.83428572788606, 0.16764069857264, 0.035988215600491
5964, 0.5345400117277, 0.72268900991588, 0.019401466263275
5965, 0.89921973119916, 0.30719029978225, 0.082139655870367
5966, 0.89647597199074, 0.39576899261602, 0.048633798423391
5967, 0.56571919004842, 0.73858558335497, 0.01830310321711
5968, 0.75689031725229, 0.69021237786934, 0.018395439430439
5969, 0.63707855772739, 0.65069801386633, 0.014832029261832
5970, 0.43572193924759, 0.54657241129058, 0.049044559133584
5971, 0.67488527555018, 0.85885416804478, 0.055823043215198
5972, 0.89565781666434, 0.25807760706679, 0.045989720243487
5973, 0.52302656547618, 0.64822636973846, 0.019015548716125
5974, 0.79833764441257, 0.5016507372804, 0.051017062202195
5975, 0.49959532972364, 0.7260414028641, 0.082236840021838
5976, 0.60662171208861, 0.37094033188918, 0.021163983931821
5977, 0.84511055103816, 0.53056774248986, 0.081231614868641
5978, 0.68203238016803, 0.62707076107403, 0.081281599708743
5979, 0.65866146253695, 0.27829726059746, 0.04292312613381
5980, 0.65481968688152, 0.52100456767768, 0.081748820882781
5981, 0.61688944614224, 0.64129455763953, 0.018953110661986
5982, 0.60306186003148, 0.8315083203445, 0.080730736860079
5983, 0.67370001737843, 0.57454173845337, 0.08214486098184
5984, 0.59607649188262, 0.32843854590851, 0.079441927981116
5985, 0.65705649767731, 0.67543015484128, 0.017954614963677
5986, 0.86751001089609, 0.76951825463763, 0.067079986128266
5987, 0.60652228283586, 0.8865261284558, 0.075383207403956
5988, 0.84915311691674, 0.039829783677497, 0.037931109794819
5989, 0.55019533472431, 0.40426348493261, 0.020551648447317
5990, 0.85071425625487, 0.46684124807651, 0.080794152547044
5991, 0.54250757116179, 0.56942057888118, 0.081050445336597
5992, 0.83506029119432, 0.69357747617906, 0.079704496571702
5993, 0.72087327220625, 0.50290631071188, 0.017836210316093
5994, 0.72996765760352, 0.70854991505888, 0.038813003637732
5995, 0.63336290531892, 0.16829325771959, 0.079871198486627
5996, 0.6253903928279, 0.78756910120255, 0.08268599685965
5997, 0.55959502900679, 0.59962299679359, 0.017843012388888
5998, 0.74529946994237, 0.019542749922724, 0.045070356788742
5999, 0.53528258646627, 0.45597598624929, 0.082784768678578
6000, 0.86346284956179, 0.70580142971088, 0.056135541175354
6001, 0.63209520588929, 0.69519863633324, 0.080430982920729
6002, 0.74561479578616, 0.18059629886007, 0.058050935740488
6003, 0.88400977294722, 0.37076409869961, 0.020396212083124
6004, 0.39359229166471, 0.64527998726212, 0.024217710363778
6005, 0.57070437157676, 0.74041492181975, 0.050025453800289
6006, 0.60518559531204, 0.52176459974489, 0.05735595411214
6007, 0.80888583552695, 0.76061328270519, 0.041415533364109
6008, 0.77717679500606, 0.2241104869986, 0.048764899963338
6009, 0.75639992041589, 0.53150533619251, 0.017151115583835
6010, 0.63859475487136, 0.45800499965023, 0.036857187416709
6011, 0.60800170246499, 0.43539796635487, 0.082275430112256
6012, 0.8580371444109, 0.1420802658512, 0.081006172974941
6013, 0.802879498931, 0.77319430055345, 0.081935037596352
6014, 0.81180274793566, 0.57772158297797, 0.044230221785879
6015, 0.71741731520144, 0.67877164209747, 0.054496417601777
6016, 0.77994393329418, 0.12368270292231, 0.019821717892157
6017, 0.69792808505404, 0.072780137380678, 0.018490291040494
6018, 0.82937137802462, 0.77557955286368, 0.05531938445765
6019, 0.84444620702544, 0.37808674606322, 0.018748997186846
6020, 0.42888030271405, 0.66173231263814, 0.036999972360135
6021, 0.62353331171189, 0.73357217381777, 0.019709132356686
6022, 0.75864532426714, 0.21698505785589, 0.082121527353658
6023, 0.86838447166074, 0.39397708051319, 0.019271181594672
6024, 0.75231245134912, 0.47128265452286, 0.079593955824308
6025, 0.59710495411918, 0.58853960812613, 0.017172912411848
6026, 0.54687161819841, 0.49928069162364, 0.019306793544365
6027, 0.89595274858798, 0.77181681322193, 0.018046694880556
6028, 0.56193506012241, 0.42104228805568, 0.081036234921542
6029, 0.42858642650494, 0.53150071026807, 0.063964561770822
6030, 0.50870594686859, 0.45494074760783, 0.035813390191547
6031, 0.82079493016944, 0.57528891787743, 0.017267666980961
6032, 0.77642786542606, 0.52371464131736, 0.051344381017984
6033, 0.59052675232279, 0.72416529501593, 0.018334714976036
6034, 0.74017339260005, 0.34002957702978, 0.053414642418626
6035, 0.89949334420343, 0.41063859351989, 0.018780366283445
6036, 0.51277270378189, 0.52170702299409, 0.082832802514758
6037, 0.44880837902258, 0.58542787448296, 0.017589572897646
6038, 0.74921507179367, 0.01786131545341, 0.079374328315609
6039, 0.9214715713308, 0.43619981554021, 0.082001501538698
6040, 0.92001144091506, 0.47324253475824, 0.019044198065906
6041, 0.77244322156936, 0.64186580408599, 0.017578136282222
6042, 0.64713031653969, 0.32243262477142, 0.018885705245119
6043, 0.82554460823035, 0.019722008239792, 0.017669116450575
6044, 0.6583418665321, 0.76052504536881, 0.079766061711442
6045, 0.44454846404213, 0.73159516951527, 0.019171453194268
6046, 0.85550007418999, 0.59648825395191, 0.018531454585666
6047, 0.52355514483336, 0.7053406610679, 0.062332451622502
6048, 0.9178987987294, 0.14726323964385, 0.079203137362496
6049, 0.85033632352235, 0.21973332833783, 0.06114969833863
6050, 0.51098224193893, 0.67205413601799, 0.01877950559189
6051, 0.84009867264188, 0.28283716075049, 0.019689965392828
6052, 0.919977706005, 0.63101146384342, 0.077266181117549
6053, 0.58716438206773, 0.84930803536821, 0.040321813180454
6054, 0.48431034890572, 0.56359047382066, 0.080508637145972
6055, 0.57978172964868, 0.87166495894198, 0.049419190456603
6056, 0.50981131016638, 0.68969537369148, 0.082132382044853
6057, 0.84642522008587, 0.72085141658423, 0.080875067789589
6058, 0.78554091384134, 0.80104290230405, 0.042751467258473
6059, 0.84395807070125, 0.28888042048062, 0.04987604806997
6060, 0.70422033748388, 0.23927412453924, 0.018790392749878
6061, 0.57582150731692, 0.31021513707735, 0.058994588915953
6062, 0.54330577551376, 0.56925270827282, 0.018412686595319
6063, 0.53206675159877, 0.77047635264456, 0.056698887265151
6064, 0.54037944229945, 0.84349103455331, 0.08141063678529
6065, 0.61637707522196, 0.57034264108141, 0.019374022539444
6066, 0.47540617367673, 0.60446333680486, 0.082537845697875
6067, 0.74943319981199, 0.44333995820928, 0.018248834821543
6068, 0.49923804206094, 0.70114800888093, 0.01773193541054
6069, 0.78230186267223, 0.1156899827948, 0.080642019862502
6070, 0.68255516799065, 0.2973347680819, 0.019885902625664
6071, 0.6318760874157, 0.70088750450827, 0.019686816473864
6072, 0.72333731178617, 0.21297288508814, 0.018045261908241
6073, 0.69451360737556, 0.59668271497126, 0.032819362655158
6074, 0.90455577473334, 0.59666308306088, 0.080300790314056
6075, 0.64319754526868, 0.34023067857784, 0.048869375552928
6076, 0.67524672038239, 0.26926763718847, 0.016744532637154
6077, 0.73933935924156, 0.84110233507964, 0.083320036415806
6078, 0.58528224156331, 0.80585589390851, 0.036469548544986
6079, 0.6555848381834, 0.8097893050288, 0.052993881822327
6080, 0.74155950990181, 0.26946242315034, 0.082239483643877
6081, 0.90307628192152, 0.75166004262046, 0.058902374092624
6082, 0.92115254264239, 0.6075331819597, 0.043012026671826
6083, 0.87038517012814, 0.54072600975168, 0.082934724457972
6084, 0.75219214731382, 0.39807146849602, 0.057731405167268
6085, 0.83516568058941, 0.35064149233475, 0.041486943063344
6086, 0.67043909602248, 0.071467680738216, 0.016919809394909
6087, 0.89525008797689, 0.21871815527408, 0.081706066103157
6088, 0.41416590099364, 0.62883412286223, 0.079731874014733
6089, 0.79308037850641, 0.69007296309156, 0.081457682599713
6090, 0.76869778851616, 0.28327801119134, 0.081145138303047
6091, 0.79562049741534, 0.81060472531281, 0.079694422569516
6092, 0.6825055820919, 0.44207686456851, 0.080467793031578
6093, 0.58448810430322, 0.76879765117803, 0.044915705764867
6094, 0.70483006103534, 0.12502971330527, 0.058316019438491
6095, 0.54310455613288, 0.35987409998319, 0.054761553252644
6096, 0.53975308578228, 0.53097036825273, 0.019739963563792
6097, 0.81032414058784, 0.69271576959422, 0.017316016207712
6098, 0.82138405891587, 0.54409470765929, 0.036166911767295
6099, 0.70591512767978, 0.54907617335146, 0.036138351553977
6100, 0.91856314526538, 0.1213147682134, 0.080074682213789
6101, 0.70853465929402, 0.035179311443332, 0.049315057779332
6102, 0.87182434575906, 0.75904330523715, 0.050186400906168
6103, 0.40405263241192, 0.66161042209916, 0.018114211999965
6104, 0.78230080990298, 0.29995276666314, 0.019742161273349
6105, 0.59911376617043, 0.77561821591997, 0.083432418993416
6106, 0.89823207836268, 0.65029685811124, 0.049247617630285
6107, 0.67826392983797, 0.25041568388822, 0.053268065972075
6108, 0.63948917597453, 0.87424022399871, 0.056997692786514
6109, 0.64044820444499, 0.66881264087267, 0.062654434648415
6110, 0.77988574469818, 0.18631893810014, 0.017394697963833
6111, 0.78186408584934, 0.7051115445728, 0.037532582433795
6112, 0.73051123127501, 0.56921486926676, 0.083329790270505
6113, 0.53977286553126, 0.53067855915403, 0.080364039133287
6114, 0.8083820628202, 0.061588312632346, 0.055824490653546
6115, 0.77326916332663, 0.48303661391939, 0.055442223092735
6116, 0.59668470657102, 0.26916088725569, 0.019542648199338
6117, 0.48734027509023, 0.46618329503451, 0.081162277774782
6118, 0.4895666712188, 0.478754897937, 0.049185574202115
6119, 0.86894449531693, 0.28381423292795, 0.068331744521613
6120, 0.61439671671753, 0.21779464504854, 0.055498399409231
6121, 0.86372029129891, 0.81650591493966, 0.081787528969254
6122, 0.76024425744008, 0.24207578633993, 0.01819038046054
6123, 0.918823428827, 0.52400418116828, 0.078954209584204
6124, 0.77157457111669, 0.83168161181236, 0.058774802875361
6125, 0.53684748516254, 0.60910225186677, 0.05793382501378
6126, 0.49000531416151, 0.55912009844764, 0.019528007203568
6127, 0.55333710702991, 0.35117372743771, 0.020428284421654
6128, 0.66675650492726, 0.78134362616021, 0.083431897963614
6129, 0.64179513804413, 0.27719239917235, 0.079980642817174
6130, 0.78250287860828, 0.24229430802172, 0.041279696431414
6131, 0.81004908547746, 0.22846065185558, 0.016761317881894
6132, 0.64558087908689, 0.20939226970068, 0.039162981619492
6133, 0.69444876976246, 0.77158952495599, 0.081801221225298
6134, 0.72811051666219, 0.67647856383163, 0.017469844923215
6135, 0.840613396972, 0.54885976751652, 0.058773384683734
6136, 0.73873626328566, 0.46351431363417, 0.057168034357483
6137, 0.76247581572787, 0.57838787341212, 0.03935882578553
6138, 0.82287939334601, 0.43506011190729, 0.048663340496225
6139, 0.5595526830669, 0.4777617928391, 0.017768781793366
6140, 0.77737866906212, 0.3072470242446, 0.080094782392221
6141, 0.83285854327396, 0.37442029497569, 0.081357943563815
6142, 0.89087183787528, 0.69483557540979, 0.065896539027462
6143, 0.70054086965113, 0.30025930949036, 0.050522419745702
6144, 0.47052487808682, 0.48095877390551, 0.082413897603403
6145, 0.59922618242207, 0.66211584604846, 0.019176169950456
6146, 0.91972414318734, 0.31113747874356, 0.080083302454866
6147, 0.44915980396188, 0.62939283753974, 0.081048544689855
6148, 0.80322279520697, 0.79165739707294, 0.04350131446825
6149, 0.82981442054659, 0.72337389978863, 0.058124483445109
6150, 0.63345194810155, 0.86657911649951, 0.017975879473215
6151, 0.48809947952125, 0.80673599278137, 0.02025633574378
6152, 0.51380889267968, 0.43388838660821, 0.039143951286978
6153, 0.89891960720282, 0.31761607447645, 0.048125807040079
6154, 0.53095724815083, 0.42629021051263, 0.079586851864988
6155, 0.54254854644794, 0.80812482780176, 0.081901101208028
6156, 0.46222732435059, 0.55764589602254, 0.037207397820134
6157, 0.89939460897953, 0.089734128157442, 0.062625602561957
6158, 0.60116673955573, 0.60021238775339, 0.055368997931096
6159, 0.56313958247105, 0.90737533443417, 0.051329924907908
6160, 0.6936348213914, 0.21285380705766, 0.017919563412518
6161, 0.65495306138779, 0.59856135989796, 0.056693683830391
6162, 0.67495863801534, 0.40956252277794, 0.05879967852697
6163, 0.64022041781775, 0.42932770566249, 0.018062641931118
6164, 0.6678426424295, 0.10187133269702, 0.08038398504064
6165, 0.6481928921947, 0.20169167928047, 0.081834852560268
6166, 0.74033656542725, 0.12334080948712, 0.056877749577826
6167, 0.87836759734475, 0.30766746144539, 0.047229231888269
6168, 0.68008115999989, 0.7068192239971, 0.081270611112968
6169, 0.78517345453403, 0.60204297730024, 0.040637891777667
6170, 0.79342919645328, 0.023280583561114, 0.082410990872431
6171, 0.54251541901446, 0.63285172165, 0.016305167851099
6172, 0.6232611941112, 0.71650389612071, 0.036855084155053
6173, 0.57566266213455, 0.4639656599949, 0.081386137367851
6174, 0.83370962685646, 0.093016987126375, 0.080277147807891
6175, 0.84846236829611, 0.43341251127137, 0.017344292873361
6176, 0.86456309265903, 0.16597134083555, 0.082913460420687
6177, 0.42072568727363, 0.69388237623617, 0.080807442462199
6178, 0.82911198921788, 0.47688448122476, 0.083235470055271
6179, 0.7377660444535, 0.70060308170116, 0.016996303546538
6180, 0.4467631026018, 0.62546866480252, 0.037627677005606
6181, 0.65922252082499, 0.25546064860644, 0.081837268379954
6182, 0.49982209647177, 0.76004190222175, 0.059702040633309
6183, 0.91868331700575, 0.81624448977317, 0.020629995598995
6184, 0.61046632404239, 0.34949528994214, 0.049861524020864
6185, 0.81664864980903, 0.52953523873728, 0.056784705026331
6186, 0.66005342857652, 0.4247724758129, 0.082391190244197
6187, 0.74233847726763, 0.27437600124035, 0.049998894123173
6188, 0.76949654145521, 0.46730143957972, 0.038922501494552
6189, 0.63640110437167, 0.83984343766335, 0.062208235952581
6190, 0.92106445584516, 0.15995618851017, 0.01874616222027
6191, 0.70398542135984, 0.42774618282507, 0.038627880227089
6192, 0.67700434852807, 0.017086723993886, 0.034639302778779
6193, 0.63240471040373, 0.81741848707985, 0.017266903527732
6194, 0.71983956362376, 0.84760823104536, 0.043595786003036
6195, 0.7153172169815, 0.66480443701019, 0.081820373587472
6196, 0.69596842440878, 0.35358249392675, 0.019045856847865
6197, 0.68318180684686, 0.10558369258694, 0.030877370400024
6198, 0.55294476477894, 0.62453221482789, 0.080611013958938
6199, 0.7769803004612, 0.06499315701595, 0.08213343742196
6200, 0.61839391251864, 0.45931051547868, 0.038418989237252
6201, 0.50738720826626, 0.80078307244631, 0.082010276791706
6202, 0.485989824346, 0.4777104929144, 0.018514353773584
6203, 0.70524012199294, 0.52811370539387, 0.063059360627753
6204, 0.81913603752769, 0.79850375141691, 0.081513246088906
6205, 0.54899470157542, 0.48044542357265, 0.081531700935182
6206, 0.78569220591374, 0.13771495960975, 0.082100359493911
6207, 0.63614122018362, 0.37685394522699, 0.080431903541258
6208, 0.63979726765816, 0.41133321263569, 0.038918174780038
6209, 0.89783123396925, 0.8164472034935, 0.050582835161628
6210, 0.89884864010726, 0.45022663610381, 0.018316913698669
6211, 0.64623103806415, 0.73198766658448, 0.037019051593572
6212, 0.87534333243864, 0.095985068444638, 0.056731496801738
6213, 0.45206184178824, 0.50984469601539, 0.018419647559909
6214, 0.76766937745389, 0.76379804003357, 0.082745516524799
6215, 0.49520328228873, 0.62635346608053, 0.036137497863742
6216, 0.91954619704902, 0.64541715110787, 0.051248735120368
6217, 0.89960717936443, 0.75162440665602, 0.018132480431876
6218, 0.77608849159992, 0.45524229713379, 0.017311764607114
6219, 0.70062158596073, 0.76787770114105, 0.042084388119473
6220, 0.67089867462295, 0.64840633011019, 0.054295165683505
6221, 0.90563369834701, 0.20864204160875, 0.059372828649221
6222, 0.8590600386239, 0.3493911413672, 0.081919426318681
6223, 0.84351128659, 0.26084167376942, 0.051079384221547
6224, 0.63792099017159, 0.23531670990837, 0.017213074723418
6225, 0.56459074458647, 0.77200738813762, 0.016372313584032
6226, 0.86344808113123, 0.63736231332875, 0.016996692823824
6227, 0.70260156969431, 0.38435105620696, 0.080746872182013
6228, 0.55973252682394, 0.7834466130351, 0.058459864106248
6229, 0.59298778158662, 0.39120124576845, 0.01810156730197
6230, 0.86262284772484, 0.7964268337863, 0.049539419509219
6231, 0.89523456378097, 0.099534902428876, 0.019968007522979
6232, 0.8774323345344, 0.1433267204216, 0.048788460000258
6233, 0.43512294848752, 0.66769067170007, 0.082252385964862
6234, 0.54476673112466, 0.42533292183796, 0.045856595915504
6235, 0.42390845953686, 0.59731162281231, 0.082812719024289
6236, 0.8650609727344, 0.16602916696172, 0.016694507083281
6237, 0.41205902870848, 0.56142321332312, 0.081854291717307
6238, 0.60847710238981, 0.78031938223388, 0.018307982792926
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
13, 2, 13
14, 13, 14
15, 14, 15
16, 15, 16
17, 16, 17
18, 17, 18
19, 18, 19
20, 19, 20
21, 20, 21
22, 21, 22
23, 22, 23
24, 23, 24
25, 24, 25
26, 25, 26
27, 26, 27
28, 27, 3
*ELEMENT, type=T3D2, ELSET=Line2
29, 3, 28
30, 28, 29
31, 29, 30
32, 30, 31
33, 31, 32
34, 32, 33
35, 33, 34
36, 34, 35
37, 35, 36
38, 36, 37
39, 37, 38
40, 38, 39
41, 39, 40
42, 40, 41
43, 41, 42
44, 42, 43
45, 43, 44
46, 44, 45
47, 45, 46
48, 46, 47
49, 47, 48
50, 48, 49
51, 49, 50
52, 50, 51
53, 51, 52
54, 52, 53
55, 53, 54
56, 54, 55
57, 55, 56
58, 56, 57
59, 57, 58
60, 58, 59
61, 59, 60
62, 60, 61
63, 61, 62
64, 62, 63
65, 63, 64
66, 64, 65
67, 65, 66
68, 66, 67
69, 67, 68
70, 68, 4
*ELEMENT, type=T3D2, ELSET=Line3
71, 4, 69
72, 69, 70
73, 70, 71
74, 71, 72
75, 72, 73
76, 73, 74
77, 74, 75
78, 75, 76
79, 76, 77
80, 77, 78
81, 78, 79
82, 79, 80
83, 80, 81
84, 81, 82
85, 82, 83
86, 83, 84
87, 84, 85
88, 85, 86
89, 86, 87
90, 87, 88
91, 88, 6
*ELEMENT, type=T3D2, ELSET=Line4
92, 6, 89
93, 89, 90
94, 90, 91
95, 91, 92
96, 92, 93
97, 93, 94
98, 94, 95
99, 95, 96
100, 96, 97
101, 97, 98
102, 98, 99
103, 99, 100
104, 100, 101
105, 101, 102
106, 102, 103
107, 103, 104
108, 104, 105
109, 105, 106
110, 106, 107
111, 107, 108
112, 108, 109
113, 109, 110
114, 110, 7
*ELEMENT, type=T3D2, ELSET=Line5
115, 7, 111
116, 111, 112
117, 112, 113
118, 113, 114
119, 114, 115
120, 115, 116
121, 116, 117
122, 117, 118
123, 118, 119
124, 119, 120
125, 120, 121
126, 121, 122
127, 122, 123
128, 123, 124
129, 124, 125
130, 125, 126
131, 126, 127
132, 127, 128
133, 128, 129
134, 129, 130
135, 130, 131
136, 131, 132
137, 132, 133
138, 133, 134
139, 134, 135
140, 135, 136
141, 136, 137
142, 137, 138
143, 138, 139
144, 139, 140
145, 140, 141
146, 141, 142
147, 142, 143
148, 143, 2
*ELEMENT, type=T3D2, ELSET=Line6
149, 2, 144
150, 144, 145
151, 145, 146
152, 146, 147
153, 147, 8
*ELEMENT, type=T3D2, ELSET=Line7
154, 3, 148
155, 148, 149
156, 149, 150
157, 150, 151
158, 151, 9
*ELEMENT, type=T3D2, ELSET=Line8
159, 8, 152
160, 152, 153
161, 153, 154
162, 154, 155
163, 155, 156
164, 156, 157
165, 157, 158
166, 158, 159
167, 159, 160
168, 160, 161
169, 161, 162
170, 162, 163
171, 163, 164
172, 164, 165
173, 165, 166
174, 166, 9
*ELEMENT, type=T3D2, ELSET=Line9
175, 4, 167
176, 167, 168
177, 168, 169
178, 169, 170
179, 170, 10
*ELEMENT, type=T3D2, ELSET=Line10
180, 9, 171
181, 171, 172
182, 172, 173
183, 173, 174
184, 174, 175
185, 175, 176
186, 176, 177
187, 177, 178
188, 178, 179
189, 179, 180
190, 180, 181
191, 181, 182
192, 182, 183
193, 183, 184
194, 184, 185
195, 185, 186
196, 186, 187
197, 187, 188
198, 188, 189
199, 189, 190
200, 190, 191
201, 191, 192
202, 192, 193
203, 193, 194
204, 194, 195
205, 195, 196
206, 196, 197
207, 197, 198
208, 198, 199
209, 199, 200
210, 200, 201
211, 201, 202
212, 202, 203
213, 203, 204
214, 204, 205
215, 205, 206
216, 206, 207
217, 207, 208
218, 208, 209
219, 209, 210
220, 210, 211
221, 211, 10
*ELEMENT, type=T3D2, ELSET=Line11
222, 6, 212
223, 212, 213
224, 213, 214
225, 214, 215
226, 215, 11
*ELEMENT, type=T3D2, ELSET=Line12
227, 10, 216
228, 216, 217
229, 217, 218
230, 218, 219
231, 219, 220
232, 220, 221
233, 221, 222
234, 222, 223
235, 223, 224
236, 224, 225
237, 225, 226
238, 226, 227
239, 227, 228
240, 228, 229
241, 229, 230
242, 230, 231
243, 231, 232
244, 232, 233
245, 233, 234
246, 234, 235
247, 235, 11
*ELEMENT, type=T3D2, ELSET=Line13
248, 7, 236
249, 236, 237
250, 237, 238
251, 238, 239
252, 239, 12
*ELEMENT, type=T3D2, ELSET=Line14
253, 11, 240
254, 240, 241
255, 241, 242
256, 242, 243
257, 243, 244
258, 244, 245
259, 245, 246
260, 246, 247
261, 247, 248
262, 248, 249
263, 249, 250
264, 250, 251
265, 251, 252
266, 252, 253
267, 253, 254
268, 254, 255
269, 255, 256
270, 256, 257
271, 257, 258
272, 258, 259
273, 259, 260
274, 260, 261
275, 261, 12
*ELEMENT, type=T3D2, ELSET=Line15
276, 12, 262
277, 262, 263
278, 263, 264
279, 264, 265
280, 265, 266
281, 266, 267
282, 267, 268
283, 268, 269
284, 269, 270
285, 270, 271
286, 271, 272
287, 272, 273
288, 273, 274
289, 274, 275
290, 275, 276
291, 276, 277
292, 277, 278
293, 278, 279
294, 279, 280
295, 280, 281
296, 281, 282
297, 282, 283
298, 283, 284
299, 284, 285
300, 285, 286
301, 286, 287
302, 287, 288
303, 288, 289
304, 289, 290
305, 290, 291
306, 291, 292
307, 292, 293
308, 293, 294
309, 294, 8
*ELEMENT, type=CPS3, ELSET=Surface1
310, 13, 1375, 2
311, 2, 1375, 143
312, 3, 1386, 27
313, 28, 1386, 3
314, 4, 1371, 68
315, 69, 1371, 4
316, 6, 1372, 88
317, 89, 1372, 6
318, 7, 1370, 110
319, 111, 1370, 7
320, 14, 1297, 13
321, 1297, 1375, 13
322, 15, 342, 14
323, 342, 1297, 14
324, 16, 1387, 15
325, 15, 1387, 342
326, 17, 316, 16
327, 316, 1387, 16
328, 18, 1352, 17
329, 17, 1352, 316
330, 19, 885, 18
331, 885, 1352, 18
332, 20, 306, 19
333, 306, 885, 19
334, 21, 1244, 20
335, 20, 1244, 306
336, 22, 1211, 21
337, 1211, 1244, 21
338, 23, 318, 22
339, 318, 1211, 22
340, 24, 1377, 23
341, 23, 1377, 318
342, 25, 341, 24
343, 341, 1377, 24
344, 26, 1340, 25
345, 25, 1340, 341
346, 27, 1321, 26
347, 1321, 1340, 26
348, 27, 1386, 1321
349, 29, 346, 28
350, 346, 1386, 28
351, 30, 1255, 29
352, 29, 1255, 346
353, 31, 332, 30
354, 332, 1255, 30
355, 32, 959, 31
356, 31, 959, 332
357, 33, 315, 32
358, 315, 959, 32
359, 34, 1410, 33
360, 33, 1410, 315
361, 35, 1393, 34
362, 1393, 1410, 34
363, 36, 310, 35
364, 310, 1393, 35
365, 37, 966, 36
366, 36, 966, 310
367, 38, 333, 37
368, 333, 966, 37
369, 39, 1120, 38
370, 38, 1120, 333
371, 40, 307, 39
372, 307, 1120, 39
373, 41, 1074, 40
374, 40, 1074, 307
375, 42, 334, 41
376, 334, 1074, 41
377, 43, 1085, 42
378, 42, 1085, 334
379, 44, 303, 43
380, 303, 1085, 43
381, 45, 1091, 44
382, 44, 1091, 303
383, 46, 335, 45
384, 335, 1091, 45
385, 47, 1095, 46
386, 46, 1095, 335
387, 48, 301, 47
388, 301, 1095, 47
389, 49, 1099, 48
390, 48, 1099, 301
391, 50, 336, 49
392, 336, 1099, 49
393, 51, 1286, 50
394, 50, 1286, 336
395, 52, 927, 51
396, 927, 1286, 51
397, 53, 299, 52
398, 299, 927, 52
399, 54, 930, 53
400, 53, 930, 299
401, 55, 337, 54
402, 337, 930, 54
403, 56, 1402, 55
404, 55, 1402, 337
405, 57, 1381, 56
406, 1381, 1402, 56
407, 58, 296, 57
408, 296, 1381, 57
409, 59, 1351, 58
410, 58, 1351, 296
411, 60, 338, 59
412, 338, 1351, 59
413, 61, 1330, 60
414, 60, 1330, 338
415, 62, 308, 61
416, 308, 1330, 61
417, 63, 1134, 62
418, 62, 1134, 308
419, 64, 1135, 63
420, 63, 1135, 1134
421, 65, 320, 64
422, 320, 1135, 64
423, 66, 1119, 65
424, 65, 1119, 320
425, 67, 345, 66
426, 345, 1119, 66
427, 68, 1300, 67
428, 67, 1300, 345
429, 68, 1371, 1300
430, 70, 348, 69
431, 348, 1371, 69
432, 71, 1316, 70
433, 70, 1316, 348
434, 72, 324, 71
435, 324, 1316, 71
436, 73, 1331, 72
437, 72, 1331, 324
438, 74, 926, 73
439, 926, 1331, 73
440, 75, 314, 74
441, 314, 926, 74
442, 76, 1299, 75
443, 75, 1299, 314
444, 77, 331, 76
445, 331, 1299, 76
446, 78, 924, 77
447, 77, 924, 331
448, 79, 297, 78
449, 297, 924, 78
450, 80, 1323, 79
451, 79, 1323, 297
452, 81, 330, 80
453, 330, 1323, 80
454, 82, 921, 81
455, 81, 921, 330
456, 83, 313, 82
457, 313, 921, 82
458, 84, 923, 83
459, 83, 923, 313
460, 85, 1395, 84
461, 84, 1395, 923
462, 86, 323, 85
463, 323, 1395, 85
464, 87, 919, 86
465, 86, 919, 323
466, 88, 349, 87
467, 349, 919, 87
468, 88, 1372, 349
469, 90, 1301, 89
470, 1301, 1372, 89
471, 91, 344, 90
472, 344, 1301, 90
473, 92, 1181, 91
474, 91, 1181, 344
475, 93, 319, 92
476, 319, 1181, 92
477, 94, 1335, 93
478, 93, 1335, 319
479, 95, 1178, 94
480, 1178, 1335, 94
481, 96, 309, 95
482, 309, 1178, 95
483, 97, 1171, 96
484, 96, 1171, 309
485, 98, 340, 97
486, 340, 1171, 97
487, 99, 1163, 98
488, 98, 1163, 340
489, 100, 298, 99
490, 298, 1163, 99
491, 101, 1164, 100
492, 100, 1164, 298
493, 102, 339, 101
494, 339, 1164, 101
495, 103, 1378, 102
496, 102, 1378, 339
497, 104, 305, 103
498, 305, 1378, 103
499, 105, 1361, 104
500, 104, 1361, 305
501, 106, 1383, 105
502, 947, 1361, 105
503, 105, 1383, 947
504, 107, 317, 106
505, 317, 1383, 106
506, 108, 1367, 107
507, 107, 1367, 317
508, 109, 343, 108
509, 343, 1367, 108
510, 110, 1295, 109
511, 109, 1295, 343
512, 110, 1370, 1295
513, 112, 347, 111
514, 347, 1370, 111
515, 113, 894, 112
516, 112, 894, 347
517, 114, 322, 113
518, 322, 894, 113
519, 115, 892, 114
520, 114, 892, 322
521, 116, 1347, 115
522, 115, 1347, 892
523, 117, 312, 116
524, 312, 1347, 116
525, 118, 893, 117
526, 117, 893, 312
527, 119, 325, 118
528, 325, 893, 118
529, 120, 899, 119
530, 119, 899, 325
531, 121, 295, 120
532, 295, 899, 120
533, 122, 905, 121
534, 121, 905, 295
535, 123, 326, 122
536, 326, 905, 122
537, 124, 916, 123
538, 123, 916, 326
539, 125, 300, 124
540, 300, 916, 124
541, 126, 900, 125
542, 125, 900, 300
543, 127, 327, 126
544, 327, 900, 126
545, 128, 906, 127
546, 127, 906, 327
547, 129, 302, 128
548, 302, 906, 128
549, 130, 933, 129
550, 129, 933, 302
551, 131, 328, 130
552, 328, 933, 130
553, 132, 913, 131
554, 131, 913, 328
555, 133, 912, 132
556, 912, 913, 132
557, 134, 304, 133
558, 304, 912, 133
559, 135, 889, 134
560, 134, 889, 304
561, 136, 329, 135
562, 329, 889, 135
563, 137, 888, 136
564, 136, 888, 329
565, 138, 311, 137
566, 311, 888, 137
567, 139, 934, 138
568, 138, 934, 311
569, 140, 935, 139
570, 139, 935, 934
571, 141, 321, 140
572, 321, 935, 140
573, 142, 351, 141
574, 141, 351, 321
575, 143, 350, 142
576, 350, 351, 142
577, 143, 1375, 350
578, 295, 1355, 899
579, 905, 1088, 295
580, 1088, 1355, 295
581, 296, 1364, 835
582, 835, 1381, 296
583, 296, 1351, 864
584, 864, 1364, 296
585, 297, 1323, 880
586, 880, 1406, 297
587, 297, 1406, 924
588, 298, 1419, 1163
589, 1164, 1329, 298
590, 1329, 1419, 298
591, 865, 867, 299
592, 299, 930, 865
593, 867, 927, 299
594, 900, 901, 300
595, 901, 902, 300
596, 902, 916, 300
597, 301, 1096, 1095
598, 301, 1097, 1096
599, 301, 1099, 1097
600, 302, 907, 906
601, 302, 908, 907
602, 302, 933, 908
603, 303, 1091, 1084
604, 1084, 1272, 303
605, 303, 1272, 1085
606, 889, 891, 304
607, 891, 931, 304
608, 304, 931, 912
609, 872, 879, 305
610, 305, 1305, 872
611, 879, 1378, 305
612, 305, 1361, 1305
613, 306, 1319, 885
614, 1244, 1382, 306
615, 306, 1382, 1319
616, 307, 1086, 973
617, 973, 1120, 307
618, 1074, 1086, 307
619, 1134, 1162, 308
620, 1162, 1311, 308
621, 1311, 1330, 308
622, 1171, 1379, 309
623, 309, 1413, 1178
624, 309, 1379, 1315
625, 1315, 1413, 309
626, 928, 1393, 310
627, 310, 1408, 928
628, 966, 989, 310
629, 989, 1408, 310
630, 311, 877, 871
631, 871, 888, 311
632, 311, 934, 877
633, 893, 1404, 312
634, 1257, 1347, 312
635, 312, 1404, 1257
636, 313, 922, 921
637, 313, 1376, 922
638, 923, 1376, 313
639, 314, 857, 850
640, 850, 1380, 314
641, 314, 1299, 857
642, 314, 1380, 926
643, 849, 959, 315
644, 315, 1208, 849
645, 929, 1208, 315
646, 315, 1410, 929
647, 884, 936, 316
648, 316, 1352, 884
649, 936, 937, 316
650, 937, 1387, 316
651, 944, 1383, 317
652, 317, 1415, 944
653, 317, 1367, 946
654, 946, 1415, 317
655, 861, 1309, 318
656, 318, 1377, 861
657, 318, 1368, 1211
658, 1309, 1368, 318
659, 319, 1338, 1181
660, 1335, 1414, 319
661, 319, 1414, 1338
662, 1119, 1389, 320
663, 320, 1405, 1135
664, 1389, 1405, 320
665, 351, 352, 321
666, 352, 353, 321
667, 353, 935, 321
668, 892, 1313, 322
669, 322, 895, 894
670, 322, 1313, 895
671, 833, 1395, 323
672, 323, 1407, 833
673, 919, 1392, 323
674, 1392, 1407, 323
675, 324, 1356, 1316
676, 1331, 1416, 324
677, 324, 1416, 1356
678, 325, 1353, 893
679, 899, 1310, 325
680, 1310, 1353, 325
681, 326, 1360, 905
682, 916, 917, 326
683, 917, 1360, 326
684, 327, 911, 900
685, 906, 909, 327
686, 909, 911, 327
687, 913, 914, 328
688, 914, 915, 328
689, 915, 933, 328
690, 888, 1401, 329
691, 329, 890, 889
692, 329, 1401, 890
693, 832, 1323, 330
694, 330, 1341, 832
695, 921, 1399, 330
696, 330, 1399, 1341
697, 924, 925, 331
698, 925, 1346, 331
699, 331, 1346, 1299
700, 959, 960, 332
701, 960, 1304, 332
702, 332, 1304, 1255
703, 333, 967, 966
704, 333, 968, 967
705, 333, 1120, 968
706, 334, 1075, 1074
707, 334, 1076, 1075
708, 334, 1085, 1076
709, 335, 1390, 1091
710, 1095, 1328, 335
711, 1328, 1390, 335
712, 336, 1334, 1099
713, 1286, 1322, 336
714, 1322, 1334, 336
715, 827, 830, 337
716, 337, 965, 827
717, 830, 930, 337
718, 337, 1402, 965
719, 338, 1330, 834
720, 834, 1339, 338
721, 338, 1339, 864
722, 864, 1351, 338
723, 879, 1306, 339
724, 339, 1378, 879
725, 339, 1398, 1164
726, 1306, 1398, 339
727, 1070, 1171, 340
728, 340, 1336, 1070
729, 1163, 1336, 340
730, 341, 860, 859
731, 859, 861, 341
732, 341, 1340, 860
733, 861, 1377, 341
734, 937, 1317, 342
735, 342, 1387, 937
736, 342, 1396, 1297
737, 1317, 1396, 342
738, 343, 1327, 946
739, 946, 1367, 343
740, 1295, 1409, 343
741, 343, 1409, 1327
742, 344, 1181, 862
743, 862, 1363, 344
744, 344, 1363, 1301
745, 345, 1369, 1119
746, 1300, 1357, 345
747, 1357, 1369, 345
748, 346, 1255, 875
749, 875, 1400, 346
750, 1321, 1386, 346
751, 346, 1400, 1321
752, 894, 896, 347
753, 896, 1409, 347
754, 1295, 1370, 347
755, 347, 1409, 1295
756, 348, 1316, 874
757, 874, 1357, 348
758, 348, 1357, 1300
759, 1300, 1371, 348
760, 349, 1388, 919
761, 1301, 1363, 349
762, 349, 1372, 1301
763, 1363, 1388, 349
764, 350, 858, 351
765, 350, 1396, 858
766, 350, 1375, 1297
767, 1297, 1396, 350
768, 351, 858, 352
769, 352, 354, 353
770, 352, 881, 354
771, 858, 881, 352
772, 354, 355, 353
773, 355, 775, 353
774, 775, 935, 353
775, 354, 356, 355
776, 354, 681, 356
777, 354, 881, 681
778, 356, 357, 355
779, 357, 1193, 355
780, 355, 1193, 775
781, 356, 358, 357
782, 356, 1266, 358
783, 681, 1266, 356
784, 358, 359, 357
785, 359, 626, 357
786, 626, 1193, 357
787, 358, 360, 359
788, 358, 585, 360
789, 358, 1266, 585
790, 360, 361, 359
791, 361, 1314, 359
792, 359, 1314, 626
793, 360, 362, 361
794, 360, 951, 362
795, 585, 951, 360
796, 362, 363, 361
797, 363, 1133, 361
798, 1133, 1314, 361
799, 362, 364, 363
800, 362, 995, 364
801, 951, 995, 362
802, 364, 365, 363
803, 365, 366, 363
804, 366, 1133, 363
805, 364, 447, 365
806, 364, 459, 447
807, 364, 995, 459
808, 365, 367, 366
809, 365, 1199, 367
810, 447, 1199, 365
811, 367, 368, 366
812, 368, 1132, 366
813, 1132, 1133, 366
814, 367, 369, 368
815, 367, 687, 369
816, 367, 1199, 687
817, 369, 370, 368
818, 370, 504, 368
819, 504, 1132, 368
820, 369, 371, 370
821, 369, 1285, 371
822, 687, 1285, 369
823, 371, 372, 370
824, 372, 1123, 370
825, 370, 1123, 504
826, 371, 373, 372
827, 371, 445, 373
828, 371, 1285, 445
829, 373, 374, 372
830, 374, 1122, 372
831, 1122, 1123, 372
832, 373, 375, 374
833, 373, 1289, 375
834, 445, 1289, 373
835, 375, 376, 374
836, 376, 479, 374
837, 479, 1122, 374
838, 375, 377, 376
839, 375, 1290, 377
840, 1289, 1290, 375
841, 377, 378, 376
842, 378, 1117, 376
843, 376, 1117, 479
844, 377, 379, 378
845, 377, 443, 379
846, 377, 1290, 443
847, 379, 380, 378
848, 380, 1114, 378
849, 1114, 1117, 378
850, 379, 381, 380
851, 379, 1284, 381
852, 443, 1284, 379
853, 381, 382, 380
854, 382, 456, 380
855, 456, 1114, 380
856, 381, 383, 382
857, 381, 1282, 383
858, 381, 1284, 1282
859, 383, 384, 382
860, 384, 1194, 382
861, 382, 1194, 456
862, 383, 385, 384
863, 383, 439, 385
864, 383, 1282, 439
865, 385, 386, 384
866, 386, 1302, 384
867, 384, 1302, 1194
868, 385, 387, 386
869, 385, 1280, 387
870, 439, 1280, 385
871, 387, 388, 386
872, 388, 446, 386
873, 446, 1302, 386
874, 387, 389, 388
875, 387, 1279, 389
876, 387, 1280, 1279
877, 389, 390, 388
878, 390, 1220, 388
879, 388, 1220, 446
880, 389, 391, 390
881, 389, 437, 391
882, 389, 1279, 437
883, 391, 392, 390
884, 392, 1298, 390
885, 390, 1298, 1220
886, 391, 393, 392
887, 391, 1275, 393
888, 437, 1275, 391
889, 393, 394, 392
890, 394, 433, 392
891, 433, 1298, 392
892, 393, 395, 394
893, 393, 1273, 395
894, 393, 1275, 1273
895, 395, 396, 394
896, 396, 1110, 394
897, 394, 1110, 433
898, 395, 397, 396
899, 395, 436, 397
900, 395, 1273, 436
901, 397, 398, 396
902, 398, 1109, 396
903, 1109, 1110, 396
904, 397, 399, 398
905, 397, 1270, 399
906, 436, 1270, 397
907, 399, 400, 398
908, 400, 426, 398
909, 426, 1109, 398
910, 399, 401, 400
911, 399, 1269, 401
912, 399, 1270, 1269
913, 401, 402, 400
914, 402, 1148, 400
915, 400, 1148, 426
916, 401, 403, 402
917, 401, 434, 403
918, 401, 1269, 434
919, 403, 404, 402
920, 404, 1092, 402
921, 1092, 1148, 402
922, 403, 405, 404
923, 403, 1262, 405
924, 434, 1262, 403
925, 405, 406, 404
926, 406, 528, 404
927, 528, 1092, 404
928, 405, 407, 406
929, 405, 1260, 407
930, 405, 1262, 1260
931, 407, 408, 406
932, 408, 1016, 406
933, 406, 1016, 528
934, 407, 409, 408
935, 407, 430, 409
936, 407, 1260, 430
937, 409, 410, 408
938, 410, 411, 408
939, 411, 1016, 408
940, 409, 418, 410
941, 409, 1263, 418
942, 430, 1263, 409
943, 410, 412, 411
944, 410, 1153, 412
945, 418, 1153, 410
946, 412, 413, 411
947, 413, 718, 411
948, 718, 1016, 411
949, 412, 414, 413
950, 412, 737, 414
951, 412, 1153, 737
952, 414, 415, 413
953, 415, 1042, 413
954, 413, 1042, 718
955, 414, 416, 415
956, 414, 1188, 416
957, 737, 1188, 414
958, 416, 417, 415
959, 417, 423, 415
960, 423, 1042, 415
961, 416, 419, 417
962, 416, 421, 419
963, 416, 1188, 421
964, 419, 420, 417
965, 420, 1210, 417
966, 417, 1210, 423
967, 418, 1268, 1153
968, 418, 1263, 1243
969, 1243, 1268, 418
970, 419, 1112, 420
971, 421, 422, 419
972, 422, 1112, 419
973, 420, 1104, 1039
974, 1039, 1210, 420
975, 420, 1112, 1104
976, 421, 424, 422
977, 421, 543, 424
978, 421, 1188, 543
979, 424, 425, 422
980, 425, 1100, 422
981, 1100, 1112, 422
982, 423, 1033, 1032
983, 1032, 1042, 423
984, 423, 1210, 1033
985, 424, 427, 425
986, 424, 1204, 427
987, 543, 1204, 424
988, 427, 428, 425
989, 428, 429, 425
990, 429, 1100, 425
991, 426, 1148, 1041
992, 1041, 1172, 426
993, 426, 1172, 1109
994, 427, 435, 428
995, 427, 438, 435
996, 427, 1204, 438
997, 428, 431, 429
998, 428, 1155, 431
999, 435, 1155, 428
1000, 431, 432, 429
1001, 432, 640, 429
1002, 640, 1100, 429
1003, 1008, 1254, 430
1004, 430, 1260, 1008
1005, 1254, 1263, 430
1006, 431, 442, 432
1007, 431, 641, 442
1008, 431, 1155, 641
1009, 442, 444, 432
1010, 444, 1147, 432
1011, 432, 1147, 640
1012, 1110, 1296, 433
1013, 433, 1296, 1225
1014, 1225, 1298, 433
1015, 1015, 1265, 434
1016, 434, 1269, 1015
1017, 434, 1265, 1262
1018, 438, 440, 435
1019, 440, 1151, 435
1020, 1151, 1155, 435
1021, 1047, 1271, 436
1022, 436, 1273, 1047
1023, 436, 1271, 1270
1024, 1000, 1276, 437
1025, 437, 1279, 1000
1026, 437, 1276, 1275
1027, 438, 441, 440
1028, 438, 1063, 441
1029, 438, 1204, 1063
1030, 983, 1281, 439
1031, 439, 1282, 983
1032, 439, 1281, 1280
1033, 441, 448, 440
1034, 448, 450, 440
1035, 450, 1151, 440
1036, 441, 449, 448
1037, 441, 736, 449
1038, 441, 1063, 736
1039, 442, 451, 444
1040, 442, 1154, 451
1041, 641, 1154, 442
1042, 886, 1283, 443
1043, 443, 1290, 886
1044, 1283, 1284, 443
1045, 451, 452, 444
1046, 452, 453, 444
1047, 453, 1147, 444
1048, 445, 1285, 878
1049, 878, 1287, 445
1050, 1287, 1289, 445
1051, 920, 1218, 446
1052, 446, 1220, 920
1053, 1218, 1302, 446
1054, 459, 460, 447
1055, 460, 1219, 447
1056, 447, 1219, 1199
1057, 449, 454, 448
1058, 448, 1165, 450
1059, 454, 1165, 448
1060, 449, 455, 454
1061, 449, 1169, 455
1062, 736, 1169, 449
1063, 450, 1249, 1151
1064, 1165, 1245, 450
1065, 1245, 1249, 450
1066, 451, 461, 452
1067, 451, 462, 461
1068, 451, 1154, 462
1069, 452, 457, 453
1070, 452, 1106, 457
1071, 461, 1106, 452
1072, 457, 458, 453
1073, 458, 735, 453
1074, 735, 1147, 453
1075, 455, 465, 454
1076, 465, 531, 454
1077, 531, 1165, 454
1078, 455, 466, 465
1079, 455, 467, 466
1080, 455, 1169, 467
1081, 883, 1115, 456
1082, 456, 1194, 883
1083, 456, 1115, 1114
1084, 457, 463, 458
1085, 457, 1107, 463
1086, 1106, 1107, 457
1087, 463, 464, 458
1088, 464, 1173, 458
1089, 458, 1173, 735
1090, 459, 492, 460
1091, 459, 526, 492
1092, 459, 995, 526
1093, 492, 493, 460
1094, 493, 494, 460
1095, 494, 1219, 460
1096, 462, 495, 461
1097, 495, 1149, 461
1098, 461, 1149, 1106
1099, 462, 496, 495
1100, 462, 1191, 496
1101, 1154, 1191, 462
1102, 463, 480, 464
1103, 463, 525, 480
1104, 463, 1107, 525
1105, 480, 481, 464
1106, 481, 482, 464
1107, 482, 1173, 464
1108, 466, 1174, 465
1109, 465, 541, 531
1110, 465, 1174, 541
1111, 467, 468, 466
1112, 468, 502, 466
1113, 502, 1174, 466
1114, 467, 469, 468
1115, 467, 530, 469
1116, 467, 1169, 530
1117, 469, 470, 468
1118, 470, 1240, 468
1119, 468, 1240, 502
1120, 469, 471, 470
1121, 469, 1143, 471
1122, 530, 1143, 469
1123, 471, 472, 470
1124, 472, 1144, 470
1125, 1144, 1240, 470
1126, 471, 473, 472
1127, 471, 1142, 473
1128, 471, 1143, 1142
1129, 473, 474, 472
1130, 474, 476, 472
1131, 476, 1144, 472
1132, 473, 475, 474
1133, 473, 517, 475
1134, 473, 1142, 517
1135, 475, 1187, 474
1136, 474, 477, 476
1137, 474, 1187, 477
1138, 517, 518, 475
1139, 518, 536, 475
1140, 536, 1187, 475
1141, 477, 478, 476
1142, 478, 1130, 476
1143, 1130, 1144, 476
1144, 477, 505, 478
1145, 477, 1195, 505
1146, 1187, 1195, 477
1147, 505, 523, 478
1148, 523, 524, 478
1149, 524, 1130, 478
1150, 962, 1122, 479
1151, 479, 1307, 962
1152, 1117, 1307, 479
1153, 480, 503, 481
1154, 480, 1113, 503
1155, 525, 1113, 480
1156, 481, 483, 482
1157, 481, 1216, 483
1158, 503, 1216, 481
1159, 483, 484, 482
1160, 484, 608, 482
1161, 608, 1173, 482
1162, 483, 485, 484
1163, 483, 1212, 485
1164, 483, 1216, 1212
1165, 485, 486, 484
1166, 486, 1221, 484
1167, 484, 1221, 608
1168, 485, 487, 486
1169, 485, 489, 487
1170, 485, 1212, 489
1171, 487, 488, 486
1172, 488, 613, 486
1173, 613, 1221, 486
1174, 487, 490, 488
1175, 489, 1087, 487
1176, 487, 1087, 490
1177, 490, 491, 488
1178, 491, 1231, 488
1179, 488, 1231, 613
1180, 489, 1197, 1087
1181, 489, 1205, 1197
1182, 489, 1212, 1205
1183, 490, 497, 491
1184, 490, 529, 497
1185, 490, 1087, 529
1186, 497, 498, 491
1187, 498, 506, 491
1188, 506, 1231, 491
1189, 492, 963, 493
1190, 526, 550, 492
1191, 550, 963, 492
1192, 493, 499, 494
1193, 493, 501, 499
1194, 493, 963, 501
1195, 499, 500, 494
1196, 500, 1160, 494
1197, 1160, 1219, 494
1198, 496, 521, 495
1199, 521, 527, 495
1200, 527, 1149, 495
1201, 496, 522, 521
1202, 496, 551, 522
1203, 496, 1191, 551
1204, 497, 1138, 498
1205, 529, 587, 497
1206, 587, 1138, 497
1207, 498, 507, 506
1208, 498, 508, 507
1209, 498, 1138, 508
1210, 499, 600, 500
1211, 501, 1146, 499
1212, 499, 1146, 600
1213, 600, 601, 500
1214, 601, 621, 500
1215, 621, 1160, 500
1216, 956, 1146, 501
1217, 501, 1213, 956
1218, 963, 1213, 501
1219, 1125, 1126, 502
1220, 502, 1240, 1125
1221, 1126, 1174, 502
1222, 985, 1216, 503
1223, 503, 1222, 985
1224, 1113, 1222, 503
1225, 939, 1132, 504
1226, 504, 1308, 939
1227, 1123, 1308, 504
1228, 505, 605, 523
1229, 505, 642, 605
1230, 505, 1195, 642
1231, 507, 1175, 506
1232, 1175, 1274, 506
1233, 506, 1274, 1231
1234, 508, 509, 507
1235, 509, 510, 507
1236, 510, 1175, 507
1237, 508, 586, 509
1238, 508, 793, 586
1239, 508, 1138, 793
1240, 509, 511, 510
1241, 509, 1118, 511
1242, 586, 1118, 509
1243, 511, 512, 510
1244, 512, 619, 510
1245, 619, 1175, 510
1246, 511, 513, 512
1247, 511, 514, 513
1248, 511, 1118, 514
1249, 513, 516, 512
1250, 516, 1226, 512
1251, 512, 1226, 619
1252, 514, 515, 513
1253, 515, 1234, 513
1254, 513, 1234, 516
1255, 514, 519, 515
1256, 514, 728, 519
1257, 514, 1118, 728
1258, 519, 520, 515
1259, 520, 532, 515
1260, 532, 1234, 515
1261, 1031, 1229, 516
1262, 516, 1234, 1031
1263, 516, 1229, 1226
1264, 517, 1121, 518
1265, 517, 1158, 1121
1266, 1142, 1158, 517
1267, 518, 537, 536
1268, 518, 538, 537
1269, 518, 1121, 538
1270, 519, 1066, 520
1271, 728, 729, 519
1272, 729, 1066, 519
1273, 520, 533, 532
1274, 520, 534, 533
1275, 520, 1066, 534
1276, 522, 1150, 521
1277, 521, 624, 527
1278, 521, 1150, 624
1279, 551, 552, 522
1280, 552, 553, 522
1281, 553, 1150, 522
1282, 523, 1140, 524
1283, 605, 606, 523
1284, 606, 1140, 523
1285, 975, 1130, 524
1286, 524, 1145, 975
1287, 1140, 1145, 524
1288, 1107, 1108, 525
1289, 1108, 1201, 525
1290, 525, 1201, 1113
1291, 526, 627, 550
1292, 526, 1203, 627
1293, 995, 1203, 526
1294, 624, 639, 527
1295, 639, 682, 527
1296, 682, 1149, 527
1297, 1016, 1017, 528
1298, 1017, 1018, 528
1299, 1018, 1092, 528
1300, 529, 588, 587
1301, 529, 1129, 588
1302, 1087, 1129, 529
1303, 1062, 1159, 530
1304, 530, 1169, 1062
1305, 530, 1159, 1143
1306, 541, 542, 531
1307, 542, 745, 531
1308, 745, 1165, 531
1309, 533, 1233, 532
1310, 1233, 1288, 532
1311, 532, 1288, 1234
1312, 534, 535, 533
1313, 535, 607, 533
1314, 607, 1233, 533
1315, 534, 589, 535
1316, 534, 618, 589
1317, 534, 1066, 618
1318, 589, 590, 535
1319, 590, 1177, 535
1320, 535, 1177, 607
1321, 537, 540, 536
1322, 540, 795, 536
1323, 795, 1187, 536
1324, 538, 539, 537
1325, 539, 1215, 537
1326, 537, 1215, 540
1327, 538, 544, 539
1328, 538, 620, 544
1329, 538, 1121, 620
1330, 544, 545, 539
1331, 545, 596, 539
1332, 596, 1215, 539
1333, 540, 1206, 795
1334, 988, 1206, 540
1335, 540, 1215, 988
1336, 541, 611, 542
1337, 541, 1242, 611
1338, 1174, 1242, 541
1339, 611, 612, 542
1340, 612, 1258, 542
1341, 542, 1258, 745
1342, 1188, 1236, 543
1343, 543, 1227, 1204
1344, 543, 1236, 1227
1345, 544, 546, 545
1346, 544, 1049, 546
1347, 620, 1049, 544
1348, 546, 547, 545
1349, 547, 1223, 545
1350, 545, 1223, 596
1351, 546, 548, 547
1352, 546, 684, 548
1353, 546, 1049, 684
1354, 548, 549, 547
1355, 549, 591, 547
1356, 591, 1223, 547
1357, 548, 556, 549
1358, 548, 1004, 556
1359, 684, 1004, 548
1360, 556, 557, 549
1361, 557, 1235, 549
1362, 549, 1235, 591
1363, 627, 630, 550
1364, 630, 1228, 550
1365, 550, 1228, 963
1366, 551, 1176, 552
1367, 992, 1176, 551
1368, 551, 1191, 992
1369, 552, 554, 553
1370, 552, 555, 554
1371, 552, 1176, 555
1372, 554, 1093, 553
1373, 553, 1093, 977
1374, 977, 1150, 553
1375, 555, 597, 554
1376, 597, 598, 554
1377, 598, 1093, 554
1378, 555, 599, 597
1379, 555, 628, 599
1380, 555, 1176, 628
1381, 556, 558, 557
1382, 556, 644, 558
1383, 556, 1004, 644
1384, 558, 559, 557
1385, 559, 1237, 557
1386, 557, 1237, 1235
1387, 558, 560, 559
1388, 558, 1009, 560
1389, 644, 1009, 558
1390, 560, 561, 559
1391, 561, 604, 559
1392, 604, 1237, 559
1393, 560, 562, 561
1394, 560, 1011, 562
1395, 1009, 1011, 560
1396, 562, 563, 561
1397, 563, 1241, 561
1398, 561, 1241, 604
1399, 562, 564, 563
1400, 562, 645, 564
1401, 562, 1011, 645
1402, 564, 565, 563
1403, 565, 603, 563
1404, 603, 1241, 563
1405, 564, 566, 565
1406, 564, 1089, 566
1407, 645, 1089, 564
1408, 566, 567, 565
1409, 567, 1251, 565
1410, 565, 1251, 603
1411, 566, 568, 567
1412, 566, 1156, 568
1413, 1089, 1156, 566
1414, 568, 569, 567
1415, 569, 1256, 567
1416, 567, 1256, 1251
1417, 568, 570, 569
1418, 568, 646, 570
1419, 568, 1156, 646
1420, 570, 571, 569
1421, 571, 629, 569
1422, 629, 1256, 569
1423, 570, 572, 571
1424, 570, 1043, 572
1425, 646, 1043, 570
1426, 572, 573, 571
1427, 573, 1190, 571
1428, 571, 1190, 629
1429, 572, 574, 573
1430, 572, 1161, 574
1431, 1043, 1161, 572
1432, 574, 575, 573
1433, 575, 638, 573
1434, 638, 1190, 573
1435, 574, 576, 575
1436, 574, 647, 576
1437, 574, 1161, 647
1438, 576, 577, 575
1439, 577, 1344, 575
1440, 575, 1344, 638
1441, 576, 578, 577
1442, 576, 996, 578
1443, 647, 996, 576
1444, 578, 579, 577
1445, 579, 654, 577
1446, 654, 1344, 577
1447, 578, 580, 579
1448, 578, 1168, 580
1449, 996, 1168, 578
1450, 580, 581, 579
1451, 581, 1403, 579
1452, 579, 1403, 654
1453, 580, 582, 581
1454, 580, 650, 582
1455, 580, 1168, 650
1456, 582, 583, 581
1457, 583, 667, 581
1458, 667, 1403, 581
1459, 582, 584, 583
1460, 582, 979, 584
1461, 650, 979, 582
1462, 584, 592, 583
1463, 592, 1209, 583
1464, 583, 1209, 667
1465, 584, 593, 592
1466, 584, 1183, 593
1467, 979, 1183, 584
1468, 585, 950, 932
1469, 932, 951, 585
1470, 585, 1266, 950
1471, 793, 994, 586
1472, 994, 1166, 586
1473, 586, 1166, 1118
1474, 588, 631, 587
1475, 631, 1065, 587
1476, 1065, 1138, 587
1477, 588, 634, 631
1478, 588, 635, 634
1479, 588, 1129, 635
1480, 589, 609, 590
1481, 589, 1067, 609
1482, 618, 1067, 589
1483, 609, 610, 590
1484, 610, 614, 590
1485, 614, 1177, 590
1486, 1090, 1224, 591
1487, 591, 1235, 1090
1488, 591, 1224, 1223
1489, 593, 594, 592
1490, 594, 677, 592
1491, 677, 1209, 592
1492, 593, 595, 594
1493, 593, 653, 595
1494, 593, 1183, 653
1495, 595, 602, 594
1496, 602, 1333, 594
1497, 594, 1333, 677
1498, 595, 1291, 602
1499, 653, 655, 595
1500, 655, 1291, 595
1501, 964, 1217, 596
1502, 596, 1223, 964
1503, 596, 1217, 1215
1504, 597, 622, 598
1505, 599, 1192, 597
1506, 597, 1192, 622
1507, 622, 623, 598
1508, 623, 625, 598
1509, 625, 1093, 598
1510, 628, 685, 599
1511, 685, 686, 599
1512, 686, 1192, 599
1513, 600, 651, 601
1514, 600, 652, 651
1515, 600, 1146, 652
1516, 601, 1198, 621
1517, 651, 656, 601
1518, 656, 1198, 601
1519, 602, 991, 990
1520, 990, 1333, 602
1521, 602, 1291, 991
1522, 941, 1246, 603
1523, 603, 1251, 941
1524, 603, 1246, 1241
1525, 949, 1238, 604
1526, 604, 1241, 949
1527, 604, 1238, 1237
1528, 605, 1186, 606
1529, 642, 648, 605
1530, 648, 1186, 605
1531, 1003, 1139, 606
1532, 606, 1186, 1003
1533, 1139, 1140, 606
1534, 1177, 1202, 607
1535, 1202, 1292, 607
1536, 607, 1292, 1233
1537, 1105, 1179, 608
1538, 608, 1221, 1105
1539, 608, 1179, 1173
1540, 609, 1072, 610
1541, 1067, 1349, 609
1542, 609, 1349, 1072
1543, 610, 615, 614
1544, 610, 616, 615
1545, 610, 1072, 616
1546, 611, 678, 612
1547, 611, 679, 678
1548, 611, 1242, 679
1549, 678, 680, 612
1550, 680, 1127, 612
1551, 1127, 1258, 612
1552, 613, 1231, 1038
1553, 1038, 1232, 613
1554, 613, 1232, 1221
1555, 615, 643, 614
1556, 643, 740, 614
1557, 740, 1177, 614
1558, 616, 617, 615
1559, 617, 1152, 615
1560, 615, 1152, 643
1561, 616, 632, 617
1562, 616, 691, 632
1563, 616, 1072, 691
1564, 632, 633, 617
1565, 633, 1180, 617
1566, 617, 1180, 1152
1567, 1066, 1136, 618
1568, 618, 1068, 1067
1569, 618, 1136, 1068
1570, 619, 1277, 1175
1571, 1226, 1278, 619
1572, 619, 1278, 1277
1573, 620, 1050, 1049
1574, 620, 1051, 1050
1575, 620, 1121, 1051
1576, 621, 1324, 1160
1577, 1198, 1326, 621
1578, 621, 1326, 1324
1579, 622, 694, 623
1580, 622, 738, 694
1581, 622, 1192, 738
1582, 623, 668, 625
1583, 623, 1167, 668
1584, 694, 1167, 623
1585, 624, 692, 639
1586, 624, 954, 692
1587, 624, 1150, 954
1588, 668, 699, 625
1589, 699, 714, 625
1590, 714, 1093, 625
1591, 626, 987, 873
1592, 873, 1193, 626
1593, 626, 1314, 987
1594, 627, 700, 630
1595, 627, 709, 700
1596, 627, 1203, 709
1597, 628, 688, 685
1598, 628, 734, 688
1599, 628, 1176, 734
1600, 1190, 1350, 629
1601, 629, 1259, 1256
1602, 629, 1350, 1259
1603, 700, 701, 630
1604, 701, 702, 630
1605, 702, 1228, 630
1606, 634, 695, 631
1607, 695, 696, 631
1608, 696, 1065, 631
1609, 632, 657, 633
1610, 632, 1411, 657
1611, 691, 1411, 632
1612, 657, 658, 633
1613, 658, 659, 633
1614, 659, 1180, 633
1615, 635, 636, 634
1616, 636, 1124, 634
1617, 634, 1124, 695
1618, 635, 637, 636
1619, 635, 1185, 637
1620, 1129, 1185, 635
1621, 637, 669, 636
1622, 669, 774, 636
1623, 774, 1124, 636
1624, 637, 670, 669
1625, 637, 671, 670
1626, 637, 1185, 671
1627, 638, 1318, 1190
1628, 638, 1384, 1318
1629, 1344, 1384, 638
1630, 639, 683, 682
1631, 639, 1069, 683
1632, 692, 1069, 639
1633, 640, 1101, 1100
1634, 640, 1102, 1101
1635, 640, 1147, 1102
1636, 641, 1230, 1154
1637, 1155, 1239, 641
1638, 641, 1239, 1230
1639, 642, 649, 648
1640, 642, 1196, 649
1641, 1195, 1196, 642
1642, 643, 746, 740
1643, 643, 748, 746
1644, 643, 1152, 748
1645, 1004, 1005, 644
1646, 1005, 1006, 644
1647, 1006, 1009, 644
1648, 1011, 1012, 645
1649, 1012, 1013, 645
1650, 1013, 1089, 645
1651, 646, 1044, 1043
1652, 646, 1045, 1044
1653, 646, 1156, 1045
1654, 647, 997, 996
1655, 647, 998, 997
1656, 647, 1161, 998
1657, 649, 693, 648
1658, 693, 703, 648
1659, 703, 1186, 648
1660, 649, 749, 693
1661, 649, 750, 749
1662, 649, 1196, 750
1663, 650, 980, 979
1664, 650, 981, 980
1665, 650, 1168, 981
1666, 652, 697, 651
1667, 651, 1200, 656
1668, 697, 1200, 651
1669, 652, 698, 697
1670, 652, 719, 698
1671, 652, 1146, 719
1672, 653, 753, 655
1673, 653, 755, 753
1674, 653, 1183, 755
1675, 1079, 1080, 654
1676, 654, 1403, 1079
1677, 1080, 1081, 654
1678, 1081, 1344, 654
1679, 753, 754, 655
1680, 754, 770, 655
1681, 770, 1291, 655
1682, 656, 1362, 1198
1683, 1200, 1374, 656
1684, 656, 1374, 1362
1685, 657, 1073, 658
1686, 657, 1294, 1073
1687, 657, 1411, 1294
1688, 658, 660, 659
1689, 658, 661, 660
1690, 658, 1073, 661
1691, 660, 707, 659
1692, 707, 710, 659
1693, 710, 1180, 659
1694, 661, 662, 660
1695, 662, 1116, 660
1696, 660, 1116, 707
1697, 661, 663, 662
1698, 661, 744, 663
1699, 661, 1073, 744
1700, 663, 664, 662
1701, 664, 1303, 662
1702, 662, 1303, 1116
1703, 663, 665, 664
1704, 663, 1337, 665
1705, 744, 1337, 663
1706, 665, 666, 664
1707, 666, 706, 664
1708, 706, 1303, 664
1709, 665, 704, 666
1710, 665, 717, 704
1711, 665, 1337, 717
1712, 704, 705, 666
1713, 705, 1189, 666
1714, 666, 1189, 706
1715, 1077, 1078, 667
1716, 667, 1209, 1077
1717, 1078, 1079, 667
1718, 1079, 1403, 667
1719, 668, 777, 699
1720, 668, 778, 777
1721, 668, 1167, 778
1722, 670, 1342, 669
1723, 669, 779, 774
1724, 669, 1342, 779
1725, 671, 672, 670
1726, 672, 676, 670
1727, 676, 1342, 670
1728, 671, 673, 672
1729, 671, 794, 673
1730, 671, 1185, 794
1731, 673, 674, 672
1732, 674, 1141, 672
1733, 672, 1141, 676
1734, 673, 675, 674
1735, 673, 1170, 675
1736, 794, 1170, 673
1737, 675, 689, 674
1738, 689, 771, 674
1739, 771, 1141, 674
1740, 675, 690, 689
1741, 675, 716, 690
1742, 675, 1170, 716
1743, 1141, 1253, 676
1744, 1253, 1412, 676
1745, 676, 1412, 1342
1746, 974, 1312, 677
1747, 677, 1333, 974
1748, 677, 1312, 1209
1749, 679, 1184, 678
1750, 678, 760, 680
1751, 678, 1184, 760
1752, 679, 1250, 1184
1753, 1242, 1247, 679
1754, 1247, 1250, 679
1755, 760, 784, 680
1756, 784, 799, 680
1757, 799, 1127, 680
1758, 881, 882, 681
1759, 882, 918, 681
1760, 918, 1266, 681
1761, 683, 711, 682
1762, 711, 791, 682
1763, 791, 1149, 682
1764, 683, 712, 711
1765, 683, 806, 712
1766, 683, 1069, 806
1767, 684, 1071, 1004
1768, 1049, 1064, 684
1769, 1064, 1071, 684
1770, 685, 1261, 686
1771, 688, 798, 685
1772, 798, 1261, 685
1773, 686, 1261, 978
1774, 978, 1267, 686
1775, 686, 1267, 1192
1776, 1199, 1248, 687
1777, 1248, 1320, 687
1778, 687, 1320, 1285
1779, 734, 801, 688
1780, 688, 1252, 798
1781, 801, 1252, 688
1782, 690, 1131, 689
1783, 689, 772, 771
1784, 689, 1131, 772
1785, 716, 741, 690
1786, 741, 742, 690
1787, 742, 1131, 690
1788, 691, 1332, 910
1789, 910, 1411, 691
1790, 1072, 1332, 691
1791, 692, 954, 952
1792, 952, 955, 692
1793, 955, 1069, 692
1794, 693, 808, 703
1795, 749, 1162, 693
1796, 693, 1162, 808
1797, 738, 739, 694
1798, 739, 823, 694
1799, 823, 1167, 694
1800, 695, 816, 696
1801, 695, 826, 816
1802, 695, 1124, 826
1803, 816, 961, 696
1804, 961, 993, 696
1805, 993, 1065, 696
1806, 698, 708, 697
1807, 708, 819, 697
1808, 819, 1200, 697
1809, 698, 1208, 708
1810, 719, 720, 698
1811, 720, 1208, 698
1812, 699, 715, 714
1813, 699, 1002, 715
1814, 777, 1002, 699
1815, 700, 953, 701
1816, 709, 756, 700
1817, 756, 953, 700
1818, 701, 804, 702
1819, 701, 807, 804
1820, 701, 953, 807
1821, 804, 805, 702
1822, 805, 938, 702
1823, 938, 1228, 702
1824, 808, 836, 703
1825, 836, 837, 703
1826, 837, 1186, 703
1827, 704, 761, 705
1828, 717, 931, 704
1829, 704, 931, 761
1830, 761, 762, 705
1831, 762, 763, 705
1832, 763, 1189, 705
1833, 1128, 1303, 706
1834, 706, 1307, 1128
1835, 1189, 1307, 706
1836, 707, 786, 710
1837, 707, 883, 786
1838, 707, 1116, 883
1839, 708, 928, 819
1840, 708, 929, 928
1841, 708, 1208, 929
1842, 709, 757, 756
1843, 709, 932, 757
1844, 709, 1203, 932
1845, 786, 1218, 710
1846, 710, 1207, 1180
1847, 710, 1218, 1207
1848, 712, 713, 711
1849, 713, 1108, 711
1850, 711, 1108, 791
1851, 712, 773, 713
1852, 712, 1094, 773
1853, 806, 1094, 712
1854, 773, 789, 713
1855, 789, 1201, 713
1856, 713, 1201, 1108
1857, 715, 790, 714
1858, 790, 977, 714
1859, 977, 1093, 714
1860, 715, 809, 790
1861, 715, 824, 809
1862, 715, 1002, 824
1863, 716, 985, 741
1864, 716, 986, 985
1865, 716, 1170, 986
1866, 717, 1337, 914
1867, 914, 1391, 717
1868, 717, 1391, 931
1869, 718, 1017, 1016
1870, 718, 1157, 1017
1871, 1042, 1157, 718
1872, 719, 721, 720
1873, 719, 956, 721
1874, 719, 1146, 956
1875, 721, 722, 720
1876, 722, 849, 720
1877, 849, 1208, 720
1878, 721, 723, 722
1879, 721, 727, 723
1880, 721, 956, 727
1881, 723, 724, 722
1882, 724, 960, 722
1883, 722, 960, 849
1884, 723, 725, 724
1885, 723, 948, 725
1886, 727, 948, 723
1887, 725, 726, 724
1888, 726, 1304, 724
1889, 724, 1304, 960
1890, 725, 859, 726
1891, 725, 876, 859
1892, 725, 948, 876
1893, 859, 860, 726
1894, 860, 875, 726
1895, 875, 1304, 726
1896, 938, 948, 727
1897, 727, 1213, 938
1898, 956, 1213, 727
1899, 728, 730, 729
1900, 728, 1166, 730
1901, 1118, 1166, 728
1902, 730, 731, 729
1903, 731, 1136, 729
1904, 729, 1136, 1066
1905, 730, 732, 731
1906, 730, 733, 732
1907, 730, 1166, 733
1908, 732, 820, 731
1909, 820, 821, 731
1910, 821, 1136, 731
1911, 733, 796, 732
1912, 796, 1088, 732
1913, 732, 1088, 820
1914, 733, 797, 796
1915, 733, 994, 797
1916, 733, 1166, 994
1917, 734, 802, 801
1918, 734, 992, 802
1919, 734, 1176, 992
1920, 1102, 1147, 735
1921, 735, 1179, 1102
1922, 1173, 1179, 735
1923, 1061, 1062, 736
1924, 736, 1063, 1061
1925, 1062, 1169, 736
1926, 1153, 1264, 737
1927, 737, 1236, 1188
1928, 737, 1264, 1236
1929, 738, 818, 739
1930, 738, 1267, 818
1931, 1192, 1267, 738
1932, 818, 1417, 739
1933, 739, 833, 823
1934, 739, 1417, 833
1935, 746, 747, 740
1936, 747, 1202, 740
1937, 740, 1202, 1177
1938, 741, 743, 742
1939, 741, 1222, 743
1940, 985, 1222, 741
1941, 743, 792, 742
1942, 792, 872, 742
1943, 872, 1131, 742
1944, 743, 957, 792
1945, 743, 958, 957
1946, 743, 1222, 958
1947, 915, 1337, 744
1948, 744, 1354, 915
1949, 1073, 1354, 744
1950, 745, 1245, 1165
1951, 745, 1252, 1245
1952, 745, 1258, 1252
1953, 746, 1225, 747
1954, 748, 787, 746
1955, 787, 1225, 746
1956, 747, 1293, 1202
1957, 1225, 1296, 747
1958, 747, 1296, 1293
1959, 748, 920, 787
1960, 748, 1207, 920
1961, 1152, 1207, 748
1962, 750, 751, 749
1963, 751, 1311, 749
1964, 749, 1311, 1162
1965, 750, 752, 751
1966, 750, 1206, 752
1967, 1196, 1206, 750
1968, 752, 780, 751
1969, 780, 834, 751
1970, 834, 1311, 751
1971, 752, 781, 780
1972, 752, 988, 781
1973, 752, 1206, 988
1974, 753, 1287, 754
1975, 755, 788, 753
1976, 788, 1287, 753
1977, 754, 776, 770
1978, 754, 878, 776
1979, 754, 1287, 878
1980, 755, 886, 788
1981, 755, 887, 886
1982, 755, 1183, 887
1983, 757, 758, 756
1984, 758, 1319, 756
1985, 756, 1319, 953
1986, 757, 759, 758
1987, 757, 950, 759
1988, 932, 950, 757
1989, 759, 884, 758
1990, 884, 885, 758
1991, 885, 1319, 758
1992, 759, 936, 884
1993, 918, 936, 759
1994, 759, 950, 918
1995, 760, 832, 784
1996, 760, 880, 832
1997, 760, 1184, 880
1998, 761, 1343, 762
1999, 761, 931, 891
2000, 891, 1343, 761
2001, 762, 764, 763
2002, 762, 765, 764
2003, 762, 1343, 765
2004, 764, 785, 763
2005, 785, 962, 763
2006, 962, 1189, 763
2007, 765, 766, 764
2008, 766, 1308, 764
2009, 764, 1308, 785
2010, 765, 767, 766
2011, 765, 1366, 767
2012, 1343, 1366, 765
2013, 767, 768, 766
2014, 768, 939, 766
2015, 939, 1308, 766
2016, 767, 769, 768
2017, 767, 825, 769
2018, 767, 1366, 825
2019, 769, 987, 768
2020, 768, 940, 939
2021, 768, 987, 940
2022, 825, 871, 769
2023, 871, 873, 769
2024, 873, 987, 769
2025, 776, 1326, 770
2026, 770, 1348, 1291
2027, 1326, 1348, 770
2028, 772, 944, 771
2029, 944, 945, 771
2030, 945, 1141, 771
2031, 772, 947, 944
2032, 772, 1305, 947
2033, 1131, 1305, 772
2034, 773, 817, 789
2035, 773, 1329, 817
2036, 1094, 1329, 773
2037, 779, 822, 774
2038, 822, 1257, 774
2039, 774, 1257, 1124
2040, 877, 934, 775
2041, 775, 1193, 877
2042, 934, 935, 775
2043, 878, 1320, 776
2044, 1320, 1324, 776
2045, 1324, 1326, 776
2046, 778, 862, 777
2047, 862, 1338, 777
2048, 777, 1338, 1002
2049, 778, 863, 862
2050, 778, 1214, 863
2051, 1167, 1214, 778
2052, 779, 1418, 822
2053, 898, 1313, 779
2054, 779, 1342, 898
2055, 1313, 1418, 779
2056, 781, 782, 780
2057, 782, 1339, 780
2058, 780, 1339, 834
2059, 781, 783, 782
2060, 781, 1217, 783
2061, 988, 1217, 781
2062, 783, 810, 782
2063, 810, 864, 782
2064, 864, 1339, 782
2065, 783, 811, 810
2066, 783, 964, 811
2067, 783, 1217, 964
2068, 784, 800, 799
2069, 784, 1341, 800
2070, 832, 1341, 784
2071, 785, 1122, 962
2072, 785, 1123, 1122
2073, 785, 1308, 1123
2074, 883, 1194, 786
2075, 1194, 1302, 786
2076, 786, 1302, 1218
2077, 920, 1220, 787
2078, 1220, 1298, 787
2079, 787, 1298, 1225
2080, 886, 1290, 788
2081, 788, 1289, 1287
2082, 788, 1290, 1289
2083, 817, 957, 789
2084, 957, 958, 789
2085, 958, 1201, 789
2086, 809, 952, 790
2087, 952, 954, 790
2088, 954, 977, 790
2089, 791, 1107, 1106
2090, 1106, 1149, 791
2091, 791, 1108, 1107
2092, 792, 879, 872
2093, 792, 1306, 879
2094, 957, 1306, 792
2095, 993, 994, 793
2096, 793, 1065, 993
2097, 793, 1138, 1065
2098, 794, 1205, 1170
2099, 1185, 1197, 794
2100, 1197, 1205, 794
2101, 795, 1195, 1187
2102, 795, 1196, 1195
2103, 795, 1206, 1196
2104, 797, 803, 796
2105, 803, 1355, 796
2106, 796, 1355, 1088
2107, 797, 961, 803
2108, 797, 993, 961
2109, 797, 994, 993
2110, 798, 1258, 1127
2111, 1127, 1261, 798
2112, 1252, 1258, 798
2113, 800, 978, 799
2114, 978, 1261, 799
2115, 799, 1261, 1127
2116, 922, 1365, 800
2117, 800, 1399, 922
2118, 800, 1365, 978
2119, 1341, 1399, 800
2120, 802, 1249, 801
2121, 801, 1249, 1245
2122, 1245, 1252, 801
2123, 992, 1230, 802
2124, 1230, 1239, 802
2125, 1239, 1249, 802
2126, 803, 1310, 899
2127, 899, 1355, 803
2128, 961, 1310, 803
2129, 804, 1309, 805
2130, 807, 1368, 804
2131, 804, 1368, 1309
2132, 876, 948, 805
2133, 805, 1309, 876
2134, 805, 948, 938
2135, 1069, 1070, 806
2136, 1070, 1336, 806
2137, 806, 1336, 1094
2138, 953, 1382, 807
2139, 807, 1244, 1211
2140, 1211, 1368, 807
2141, 807, 1382, 1244
2142, 808, 1405, 836
2143, 1134, 1135, 808
2144, 808, 1162, 1134
2145, 1135, 1405, 808
2146, 824, 1413, 809
2147, 809, 1315, 952
2148, 809, 1413, 1315
2149, 811, 812, 810
2150, 812, 1364, 810
2151, 810, 1364, 864
2152, 811, 813, 812
2153, 811, 1224, 813
2154, 964, 1224, 811
2155, 813, 814, 812
2156, 814, 835, 812
2157, 835, 1364, 812
2158, 813, 815, 814
2159, 813, 1090, 815
2160, 813, 1224, 1090
2161, 815, 827, 814
2162, 827, 965, 814
2163, 814, 965, 835
2164, 815, 828, 827
2165, 815, 829, 828
2166, 815, 1090, 829
2167, 826, 1353, 816
2168, 816, 1310, 961
2169, 816, 1353, 1310
2170, 817, 1306, 957
2171, 817, 1398, 1306
2172, 1329, 1398, 817
2173, 818, 1365, 922
2174, 922, 1376, 818
2175, 1267, 1365, 818
2176, 1376, 1417, 818
2177, 928, 1408, 819
2178, 819, 1394, 1200
2179, 819, 1408, 1394
2180, 820, 917, 821
2181, 820, 1360, 917
2182, 1088, 1360, 820
2183, 917, 1358, 821
2184, 1068, 1136, 821
2185, 821, 1358, 1068
2186, 892, 1347, 822
2187, 822, 1418, 892
2188, 822, 1347, 1257
2189, 833, 1407, 823
2190, 823, 1214, 1167
2191, 823, 1407, 1214
2192, 1002, 1414, 824
2193, 824, 1335, 1178
2194, 1178, 1413, 824
2195, 824, 1414, 1335
2196, 825, 888, 871
2197, 825, 1401, 888
2198, 1366, 1401, 825
2199, 1124, 1257, 826
2200, 1257, 1404, 826
2201, 826, 1404, 1353
2202, 828, 830, 827
2203, 829, 1238, 828
2204, 828, 831, 830
2205, 828, 1238, 831
2206, 1090, 1235, 829
2207, 1235, 1237, 829
2208, 1237, 1238, 829
2209, 831, 865, 830
2210, 865, 930, 830
2211, 831, 866, 865
2212, 831, 949, 866
2213, 831, 1238, 949
2214, 880, 1323, 832
2215, 923, 1395, 833
2216, 833, 1417, 923
2217, 834, 1330, 1311
2218, 965, 1402, 835
2219, 835, 1402, 1381
2220, 836, 838, 837
2221, 836, 1389, 838
2222, 836, 1405, 1389
2223, 838, 839, 837
2224, 839, 1003, 837
2225, 1003, 1186, 837
2226, 838, 840, 839
2227, 838, 1369, 840
2228, 838, 1389, 1369
2229, 840, 841, 839
2230, 841, 842, 839
2231, 842, 1003, 839
2232, 840, 874, 841
2233, 840, 1357, 874
2234, 840, 1369, 1357
2235, 841, 843, 842
2236, 841, 1356, 843
2237, 874, 1356, 841
2238, 843, 844, 842
2239, 844, 1139, 842
2240, 842, 1139, 1003
2241, 843, 845, 844
2242, 843, 1416, 845
2243, 1356, 1416, 843
2244, 845, 846, 844
2245, 846, 847, 844
2246, 847, 1139, 844
2247, 845, 1380, 846
2248, 845, 1331, 926
2249, 926, 1380, 845
2250, 845, 1416, 1331
2251, 846, 848, 847
2252, 846, 850, 848
2253, 846, 1380, 850
2254, 848, 1145, 847
2255, 847, 1140, 1139
2256, 847, 1145, 1140
2257, 850, 851, 848
2258, 851, 852, 848
2259, 852, 1145, 848
2260, 849, 960, 959
2261, 850, 857, 851
2262, 851, 853, 852
2263, 851, 1137, 853
2264, 857, 1137, 851
2265, 853, 854, 852
2266, 854, 975, 852
2267, 975, 1145, 852
2268, 853, 855, 854
2269, 853, 856, 855
2270, 853, 1137, 856
2271, 855, 1125, 854
2272, 854, 976, 975
2273, 854, 1125, 976
2274, 856, 1247, 855
2275, 855, 1126, 1125
2276, 855, 1247, 1126
2277, 1137, 1373, 856
2278, 856, 1250, 1247
2279, 856, 1373, 1250
2280, 857, 1346, 1137
2281, 1299, 1346, 857
2282, 858, 1317, 881
2283, 858, 1396, 1317
2284, 859, 876, 861
2285, 860, 1400, 875
2286, 1340, 1400, 860
2287, 876, 1309, 861
2288, 863, 1363, 862
2289, 1181, 1338, 862
2290, 1214, 1392, 863
2291, 863, 1388, 1363
2292, 863, 1392, 1388
2293, 866, 867, 865
2294, 866, 868, 867
2295, 866, 1246, 868
2296, 949, 1246, 866
2297, 868, 869, 867
2298, 869, 927, 867
2299, 868, 870, 869
2300, 868, 941, 870
2301, 868, 1246, 941
2302, 870, 1322, 869
2303, 869, 1286, 927
2304, 869, 1322, 1286
2305, 941, 942, 870
2306, 942, 943, 870
2307, 943, 1322, 870
2308, 871, 877, 873
2309, 872, 1305, 1131
2310, 877, 1193, 873
2311, 1316, 1356, 874
2312, 1255, 1304, 875
2313, 1285, 1320, 878
2314, 1184, 1325, 880
2315, 1325, 1406, 880
2316, 881, 1317, 882
2317, 882, 936, 918
2318, 882, 937, 936
2319, 882, 1317, 937
2320, 883, 1116, 1115
2321, 884, 1352, 885
2322, 887, 1283, 886
2323, 979, 980, 887
2324, 887, 1183, 979
2325, 980, 1283, 887
2326, 890, 891, 889
2327, 890, 1343, 891
2328, 890, 1366, 1343
2329, 890, 1401, 1366
2330, 892, 1418, 1313
2331, 1353, 1404, 893
2332, 895, 896, 894
2333, 895, 897, 896
2334, 895, 898, 897
2335, 895, 1313, 898
2336, 897, 1327, 896
2337, 1327, 1409, 896
2338, 898, 1412, 897
2339, 1253, 1397, 897
2340, 897, 1412, 1253
2341, 897, 1397, 1327
2342, 1342, 1412, 898
2343, 900, 911, 901
2344, 901, 903, 902
2345, 901, 904, 903
2346, 901, 911, 904
2347, 903, 1358, 902
2348, 902, 917, 916
2349, 902, 1358, 917
2350, 904, 1349, 903
2351, 1067, 1068, 903
2352, 903, 1349, 1067
2353, 1068, 1358, 903
2354, 911, 1332, 904
2355, 904, 1332, 1072
2356, 1072, 1349, 904
2357, 905, 1360, 1088
2358, 907, 909, 906
2359, 908, 1294, 907
2360, 907, 910, 909
2361, 907, 1294, 910
2362, 908, 933, 915
2363, 915, 1354, 908
2364, 908, 1354, 1294
2365, 910, 1332, 909
2366, 909, 1332, 911
2367, 1294, 1411, 910
2368, 912, 1391, 913
2369, 931, 1391, 912
2370, 913, 1391, 914
2371, 914, 1337, 915
2372, 950, 1266, 918
2373, 1388, 1392, 919
2374, 1207, 1218, 920
2375, 922, 1399, 921
2376, 923, 1417, 1376
2377, 924, 1406, 925
2378, 1325, 1373, 925
2379, 925, 1406, 1325
2380, 925, 1373, 1346
2381, 929, 1393, 928
2382, 929, 1410, 1393
2383, 932, 1203, 951
2384, 1213, 1228, 938
2385, 940, 1132, 939
2386, 987, 1314, 940
2387, 940, 1133, 1132
2388, 940, 1314, 1133
2389, 941, 1251, 942
2390, 942, 1259, 943
2391, 1251, 1256, 942
2392, 1256, 1259, 942
2393, 1259, 1345, 943
2394, 943, 1334, 1322
2395, 943, 1345, 1334
2396, 944, 1415, 945
2397, 947, 1383, 944
2398, 946, 1397, 945
2399, 945, 1415, 946
2400, 945, 1253, 1141
2401, 945, 1397, 1253
2402, 1327, 1397, 946
2403, 1305, 1361, 947
2404, 1241, 1246, 949
2405, 951, 1203, 995
2406, 952, 1315, 955
2407, 1319, 1382, 953
2408, 954, 1150, 977
2409, 955, 1070, 1069
2410, 955, 1379, 1070
2411, 1315, 1379, 955
2412, 1113, 1201, 958
2413, 958, 1222, 1113
2414, 962, 1307, 1189
2415, 963, 1228, 1213
2416, 1223, 1224, 964
2417, 967, 989, 966
2418, 968, 969, 967
2419, 969, 971, 967
2420, 971, 989, 967
2421, 968, 970, 969
2422, 968, 973, 970
2423, 968, 1120, 973
2424, 970, 990, 969
2425, 969, 972, 971
2426, 969, 990, 972
2427, 973, 974, 970
2428, 974, 1333, 970
2429, 970, 1333, 990
2430, 972, 1374, 971
2431, 971, 1394, 989
2432, 1374, 1394, 971
2433, 990, 991, 972
2434, 991, 1362, 972
2435, 1362, 1374, 972
2436, 973, 1086, 974
2437, 1086, 1312, 974
2438, 976, 1130, 975
2439, 1125, 1240, 976
2440, 976, 1144, 1130
2441, 976, 1240, 1144
2442, 978, 1365, 1267
2443, 981, 982, 980
2444, 982, 1283, 980
2445, 981, 983, 982
2446, 981, 984, 983
2447, 981, 1168, 984
2448, 983, 1282, 982
2449, 1282, 1284, 982
2450, 982, 1284, 1283
2451, 984, 1281, 983
2452, 996, 997, 984
2453, 984, 1168, 996
2454, 997, 1281, 984
2455, 986, 1216, 985
2456, 1170, 1205, 986
2457, 1205, 1212, 986
2458, 1212, 1216, 986
2459, 1215, 1217, 988
2460, 1394, 1408, 989
2461, 1291, 1348, 991
2462, 1348, 1362, 991
2463, 1191, 1230, 992
2464, 998, 999, 997
2465, 999, 1281, 997
2466, 998, 1000, 999
2467, 998, 1001, 1000
2468, 998, 1161, 1001
2469, 1000, 1279, 999
2470, 1279, 1280, 999
2471, 1280, 1281, 999
2472, 1001, 1276, 1000
2473, 1043, 1044, 1001
2474, 1001, 1161, 1043
2475, 1044, 1276, 1001
2476, 1338, 1414, 1002
2477, 1004, 1071, 1005
2478, 1005, 1007, 1006
2479, 1005, 1008, 1007
2480, 1005, 1071, 1008
2481, 1007, 1265, 1006
2482, 1006, 1010, 1009
2483, 1006, 1265, 1010
2484, 1008, 1260, 1007
2485, 1260, 1262, 1007
2486, 1262, 1265, 1007
2487, 1071, 1254, 1008
2488, 1010, 1011, 1009
2489, 1010, 1012, 1011
2490, 1010, 1015, 1012
2491, 1010, 1265, 1015
2492, 1012, 1014, 1013
2493, 1012, 1015, 1014
2494, 1014, 1271, 1013
2495, 1048, 1089, 1013
2496, 1013, 1271, 1048
2497, 1015, 1269, 1014
2498, 1269, 1270, 1014
2499, 1270, 1271, 1014
2500, 1017, 1019, 1018
2501, 1017, 1157, 1019
2502, 1019, 1020, 1018
2503, 1020, 1182, 1018
2504, 1018, 1182, 1092
2505, 1019, 1021, 1020
2506, 1019, 1023, 1021
2507, 1019, 1157, 1023
2508, 1021, 1022, 1020
2509, 1022, 1024, 1020
2510, 1024, 1182, 1020
2511, 1021, 1229, 1022
2512, 1023, 1027, 1021
2513, 1027, 1229, 1021
2514, 1022, 1025, 1024
2515, 1022, 1031, 1025
2516, 1022, 1229, 1031
2517, 1023, 1028, 1027
2518, 1023, 1032, 1028
2519, 1023, 1157, 1032
2520, 1025, 1026, 1024
2521, 1026, 1041, 1024
2522, 1041, 1182, 1024
2523, 1025, 1029, 1026
2524, 1025, 1288, 1029
2525, 1031, 1288, 1025
2526, 1029, 1030, 1026
2527, 1030, 1172, 1026
2528, 1026, 1172, 1041
2529, 1028, 1278, 1027
2530, 1226, 1229, 1027
2531, 1027, 1278, 1226
2532, 1032, 1033, 1028
2533, 1033, 1034, 1028
2534, 1034, 1278, 1028
2535, 1029, 1292, 1030
2536, 1029, 1288, 1233
2537, 1233, 1292, 1029
2538, 1111, 1172, 1030
2539, 1030, 1293, 1111
2540, 1292, 1293, 1030
2541, 1234, 1288, 1031
2542, 1032, 1157, 1042
2543, 1033, 1035, 1034
2544, 1033, 1210, 1035
2545, 1035, 1036, 1034
2546, 1036, 1277, 1034
2547, 1277, 1278, 1034
2548, 1035, 1037, 1036
2549, 1035, 1039, 1037
2550, 1035, 1210, 1039
2551, 1037, 1038, 1036
2552, 1038, 1274, 1036
2553, 1274, 1277, 1036
2554, 1037, 1232, 1038
2555, 1039, 1040, 1037
2556, 1040, 1232, 1037
2557, 1231, 1274, 1038
2558, 1039, 1104, 1040
2559, 1040, 1104, 1103
2560, 1103, 1105, 1040
2561, 1105, 1232, 1040
2562, 1148, 1182, 1041
2563, 1045, 1046, 1044
2564, 1046, 1276, 1044
2565, 1045, 1047, 1046
2566, 1045, 1048, 1047
2567, 1045, 1156, 1048
2568, 1047, 1273, 1046
2569, 1273, 1275, 1046
2570, 1275, 1276, 1046
2571, 1048, 1271, 1047
2572, 1048, 1156, 1089
2573, 1050, 1064, 1049
2574, 1051, 1052, 1050
2575, 1052, 1060, 1050
2576, 1060, 1064, 1050
2577, 1051, 1053, 1052
2578, 1051, 1158, 1053
2579, 1121, 1158, 1051
2580, 1053, 1054, 1052
2581, 1054, 1243, 1052
2582, 1052, 1243, 1060
2583, 1053, 1055, 1054
2584, 1053, 1058, 1055
2585, 1053, 1158, 1058
2586, 1055, 1056, 1054
2587, 1056, 1268, 1054
2588, 1054, 1268, 1243
2589, 1055, 1057, 1056
2590, 1055, 1159, 1057
2591, 1058, 1159, 1055
2592, 1057, 1059, 1056
2593, 1059, 1264, 1056
2594, 1264, 1268, 1056
2595, 1057, 1061, 1059
2596, 1057, 1062, 1061
2597, 1057, 1159, 1062
2598, 1142, 1143, 1058
2599, 1058, 1158, 1142
2600, 1143, 1159, 1058
2601, 1061, 1227, 1059
2602, 1227, 1236, 1059
2603, 1236, 1264, 1059
2604, 1060, 1254, 1064
2605, 1243, 1263, 1060
2606, 1060, 1263, 1254
2607, 1063, 1227, 1061
2608, 1204, 1227, 1063
2609, 1064, 1254, 1071
2610, 1070, 1379, 1171
2611, 1294, 1354, 1073
2612, 1075, 1086, 1074
2613, 1076, 1077, 1075
2614, 1077, 1312, 1075
2615, 1075, 1312, 1086
2616, 1076, 1078, 1077
2617, 1076, 1272, 1078
2618, 1085, 1272, 1076
2619, 1209, 1312, 1077
2620, 1078, 1359, 1079
2621, 1272, 1359, 1078
2622, 1079, 1359, 1080
2623, 1080, 1082, 1081
2624, 1080, 1084, 1082
2625, 1080, 1359, 1084
2626, 1082, 1083, 1081
2627, 1083, 1384, 1081
2628, 1081, 1384, 1344
2629, 1082, 1328, 1083
2630, 1084, 1390, 1082
2631, 1082, 1390, 1328
2632, 1318, 1384, 1083
2633, 1083, 1385, 1318
2634, 1328, 1385, 1083
2635, 1091, 1390, 1084
2636, 1084, 1359, 1272
2637, 1087, 1197, 1129
2638, 1092, 1182, 1148
2639, 1094, 1419, 1329
2640, 1336, 1419, 1094
2641, 1096, 1328, 1095
2642, 1097, 1098, 1096
2643, 1098, 1385, 1096
2644, 1096, 1385, 1328
2645, 1097, 1345, 1098
2646, 1099, 1334, 1097
2647, 1334, 1345, 1097
2648, 1098, 1350, 1318
2649, 1318, 1385, 1098
2650, 1345, 1350, 1098
2651, 1101, 1112, 1100
2652, 1102, 1103, 1101
2653, 1103, 1104, 1101
2654, 1104, 1112, 1101
2655, 1102, 1179, 1103
2656, 1103, 1179, 1105
2657, 1221, 1232, 1105
2658, 1109, 1111, 1110
2659, 1109, 1172, 1111
2660, 1111, 1296, 1110
2661, 1293, 1296, 1111
2662, 1115, 1128, 1114
2663, 1114, 1128, 1117
2664, 1116, 1303, 1115
2665, 1115, 1303, 1128
2666, 1128, 1307, 1117
2667, 1369, 1389, 1119
2668, 1126, 1242, 1174
2669, 1126, 1247, 1242
2670, 1129, 1197, 1185
2671, 1346, 1373, 1137
2672, 1151, 1239, 1155
2673, 1151, 1249, 1239
2674, 1180, 1207, 1152
2675, 1153, 1268, 1264
2676, 1154, 1230, 1191
2677, 1160, 1248, 1219
2678, 1160, 1324, 1248
2679, 1163, 1419, 1336
2680, 1164, 1398, 1329
2681, 1175, 1277, 1274
2682, 1250, 1325, 1184
2683, 1318, 1350, 1190
2684, 1198, 1348, 1326
2685, 1198, 1362, 1348
2686, 1219, 1248, 1199
2687, 1200, 1394, 1374
2688, 1202, 1293, 1292
2689, 1214, 1407, 1392
2690, 1248, 1324, 1320
2691, 1250, 1373, 1325
2692, 1259, 1350, 1345
2693, 1321, 1400, 1340
*ELEMENT, type=CPS3, ELSET=Surface2
2694, 1424, 1466, 1465
2695, 1444, 1446, 1420
2696, 1465, 1467, 1424
2697, 1420, 1448, 1444
2698, 1429, 1468, 15
2699, 1425, 1454, 22
2700, 1428, 1469, 157
2701, 1423, 1442, 1439
2702, 1422, 1463, 1460
2703, 15, 1468, 16
2704, 1423, 1439, 1438
2705, 1422, 1460, 1459
2706, 1421, 1479, 1476
2707, 1476, 1479, 1467
2708, 1441, 1448, 1440
2709, 1451, 1472, 1426
2710, 164, 1453, 163
2711, 22, 1454, 23
2712, 157, 1469, 156
2713, 1448, 1453, 1440
2714, 1427, 1453, 164
2715, 1425, 1471, 1449
2716, 1444, 1448, 1441
2717, 1442, 1443, 1441
2718, 1463, 1464, 1462
2719, 1439, 1442, 1441
2720, 1460, 1463, 1462
2721, 1465, 1470, 1467
2722, 1429, 1483, 1468
2723, 1446, 1473, 1420
2724, 1424, 1485, 1466
2725, 1451, 1480, 1472
2726, 1466, 1468, 1461
2727, 1470, 1480, 1452
2728, 1425, 1486, 1454
2729, 1428, 1487, 1469
2730, 1462, 1466, 1461
2731, 1470, 1487, 1480
2732, 1470, 1497, 1467
2733, 1426, 1490, 1451
2734, 1449, 1486, 1425
2735, 1427, 1484, 1453
2736, 1442, 1454, 1443
2737, 1463, 1469, 1464
2738, 1443, 1444, 1441
2739, 1464, 1465, 1462
2740, 1468, 1483, 1461
2741, 1471, 1492, 1449
2742, 1438, 1481, 1423
2743, 1459, 1482, 1422
2744, 1453, 1484, 1440
2745, 1467, 1479, 1424
2746, 1430, 1456, 1455
2747, 1431, 1435, 1434
2748, 1457, 1458, 1456
2749, 1436, 1437, 1435
2750, 1431, 1436, 1435
2751, 1430, 1457, 1456
2752, 1453, 1491, 163
2753, 1430, 1455, 145
2754, 1431, 1434, 150
2755, 1443, 1445, 1444
2756, 1464, 1470, 1465
2757, 1465, 1466, 1462
2758, 1436, 1438, 1437
2759, 1457, 1459, 1458
2760, 146, 1430, 145
2761, 149, 1431, 150
2762, 1459, 1460, 1458
2763, 1438, 1439, 1437
2764, 1468, 1485, 16
2765, 150, 1434, 151
2766, 145, 1455, 144
2767, 1439, 1440, 1437
2768, 1460, 1461, 1458
2769, 1445, 1446, 1444
2770, 1439, 1441, 1440
2771, 1460, 1462, 1461
2772, 1445, 1447, 1446
2773, 1445, 1449, 1447
2774, 1449, 1450, 1447
2775, 1450, 1451, 1447
2776, 1450, 1452, 1451
2777, 162, 1420, 161
2778, 160, 1426, 159
2779, 20, 1471, 21
2780, 21, 1471, 1425
2781, 155, 1422, 154
2782, 158, 1428, 157
2783, 17, 1424, 18
2784, 21, 1425, 22
2785, 158, 1472, 1428
2786, 1421, 1471, 20
2787, 24, 1423, 25
2788, 19, 1421, 20
2789, 14, 1429, 15
2790, 165, 1427, 164
2791, 1426, 1472, 159
2792, 159, 1472, 158
2793, 1430, 1475, 1457
2794, 1431, 1474, 1436
2795, 1420, 1491, 1448
2796, 26, 1432, 27
2797, 153, 1433, 152
2798, 1452, 1480, 1451
2799, 1475, 1499, 1457
2800, 1474, 1498, 1436
2801, 160, 1473, 1426
2802, 1420, 1473, 161
2803, 148, 1474, 149
2804, 147, 1475, 146
2805, 1423, 1488, 1442
2806, 1422, 1489, 1463
2807, 166, 1478, 165
2808, 13, 1477, 14
2809, 161, 1473, 160
2810, 1432, 1498, 1474
2811, 1433, 1499, 1475
2812, 149, 1474, 1431
2813, 146, 1475, 1430
2814, 1435, 1501, 1434
2815, 1456, 1500, 1455
2816, 1450, 1476, 1452
2817, 1458, 1483, 1456
2818, 1437, 1484, 1435
2819, 14, 1477, 1429
2820, 165, 1478, 1427
2821, 1424, 1479, 18
2822, 19, 1479, 1421
2823, 1448, 1491, 1453
2824, 1422, 1482, 154
2825, 1423, 1481, 25
2826, 17, 1485, 1424
2827, 26, 1481, 1432
2828, 153, 1482, 1433
2829, 1445, 1486, 1449
2830, 151, 1493, 9
2831, 144, 1494, 2
2832, 9, 1493, 166
2833, 2, 1494, 13
2834, 1434, 1501, 1478
2835, 1455, 1500, 1477
2836, 24, 1488, 1423
2837, 155, 1489, 1422
2838, 1451, 1490, 1447
2839, 162, 1491, 1420
2840, 1449, 1492, 1450
2841, 8, 1495, 147
2842, 3, 1496, 148
2843, 1466, 1485, 1468
2844, 1454, 1488, 23
2845, 1469, 1489, 156
2846, 152, 1495, 8
2847, 27, 1496, 3
2848, 1454, 1486, 1443
2849, 1469, 1487, 1464
2850, 18, 1479, 19
2851, 1472, 1480, 1428
2852, 154, 1482, 153
2853, 25, 1481, 26
2854, 1440, 1484, 1437
2855, 1461, 1483, 1458
2856, 16, 1485, 17
2857, 1443, 1486, 1445
2858, 1464, 1487, 1470
2859, 1463, 1489, 1469
2860, 1442, 1488, 1454
2861, 1480, 1487, 1428
2862, 1473, 1490, 1426
2863, 148, 1496, 1474
2864, 147, 1495, 1475
2865, 1421, 1492, 1471
2866, 1446, 1490, 1473
2867, 23, 1488, 24
2868, 156, 1489, 155
2869, 1447, 1490, 1446
2870, 1434, 1493, 151
2871, 1455, 1494, 144
2872, 163, 1491, 162
2873, 1474, 1496, 1432
2874, 1475, 1495, 1433
2875, 1467, 1497, 1476
2876, 1476, 1492, 1421
2877, 1483, 1500, 1456
2878, 1484, 1501, 1435
2879, 1482, 1499, 1433
2880, 1481, 1498, 1432
2881, 1452, 1497, 1470
2882, 166, 1493, 1478
2883, 13, 1494, 1477
2884, 1433, 1495, 152
2885, 1432, 1496, 27
2886, 1436, 1498, 1438
2887, 1457, 1499, 1459
2888, 1450, 1492, 1476
2889, 1478, 1493, 1434
2890, 1477, 1494, 1455
2891, 1476, 1497, 1452
2892, 1477, 1500, 1429
2893, 1478, 1501, 1427
2894, 1459, 1499, 1482
2895, 1438, 1498, 1481
2896, 1429, 1500, 1483
2897, 1427, 1501, 1484
*ELEMENT, type=CPS3, ELSET=Surface3
2898, 1622, 1652, 1548
2899, 1553, 1657, 1519
2900, 1539, 1658, 1531
2901, 1548, 1653, 1622
2902, 1547, 1549, 1511
2903, 1519, 1697, 1553
2904, 1531, 1698, 1539
2905, 1505, 1561, 1560
2906, 1571, 1659, 1533
2907, 1510, 1687, 1653
2908, 1540, 1542, 1537
2909, 1554, 1556, 1536
2910, 1566, 1703, 1502
2911, 1546, 1633, 1544
2912, 1502, 1654, 1566
2913, 1533, 1693, 1571
2914, 1560, 1694, 1505
2915, 1653, 1687, 1622
2916, 62, 1703, 1690
2917, 1518, 1570, 1567
2918, 1549, 1691, 1511
2919, 1633, 1701, 1544
2920, 1542, 1695, 1537
2921, 1556, 1696, 1536
2922, 1567, 1569, 1518
2923, 1690, 1703, 1565
2924, 1510, 1653, 1630
2925, 1505, 1562, 1561
2926, 1511, 1699, 1547
2927, 174, 1551, 173
2928, 1542, 1543, 1516
2929, 1556, 1557, 1506
2930, 1565, 1703, 1566
2931, 173, 1551, 1531
2932, 1543, 1544, 1516
2933, 1557, 1571, 1506
2934, 1558, 1641, 1560
2935, 1564, 1570, 1563
2936, 1567, 1570, 1564
2937, 1552, 1657, 1553
2938, 1538, 1658, 1539
2939, 1558, 1697, 1641
2940, 1537, 1655, 1540
2941, 1536, 1656, 1554
2942, 1566, 1654, 1568
2943, 1659, 1700, 1533
2944, 1517, 1704, 1569
2945, 1545, 1550, 1549
2946, 1569, 1702, 1517
2947, 1562, 1563, 1561
2948, 1543, 1550, 1545
2949, 1551, 1698, 1531
2950, 1550, 1551, 1549
2951, 1543, 1545, 1544
2952, 1641, 1697, 1519
2953, 1652, 1692, 1548
2954, 1562, 1564, 1563
2955, 1545, 1546, 1544
2956, 1665, 1674, 1615
2957, 1663, 1672, 1604
2958, 1661, 1668, 1593
2959, 179, 1686, 1664
2960, 184, 1684, 1662
2961, 191, 1682, 1660
2962, 1506, 1696, 1556
2963, 1516, 1695, 1542
2964, 1552, 1553, 1534
2965, 1538, 1539, 1535
2966, 168, 1552, 1534
2967, 150, 1538, 1535
2968, 1562, 1565, 1564
2969, 1553, 1554, 1534
2970, 1539, 1540, 1535
2971, 1553, 1555, 1554
2972, 1539, 1541, 1540
2973, 1545, 1547, 1546
2974, 167, 1552, 168
2975, 151, 1538, 150
2976, 1541, 1542, 1540
2977, 1555, 1556, 1554
2978, 168, 1534, 169
2979, 150, 1535, 149
2980, 1541, 1543, 1542
2981, 1555, 1557, 1556
2982, 1565, 1566, 1564
2983, 1547, 1548, 1546
2984, 1545, 1549, 1547
2985, 1555, 1558, 1557
2986, 1541, 1550, 1543
2987, 1558, 1559, 1557
2988, 1559, 1571, 1557
2989, 1558, 1560, 1559
2990, 1560, 1561, 1559
2991, 1566, 1567, 1564
2992, 1566, 1568, 1567
2993, 1568, 1569, 1567
2994, 1573, 1577, 1576
2995, 1504, 1574, 1573
2996, 1574, 1578, 1577
2997, 1504, 1643, 1574
2998, 1574, 1577, 1573
2999, 1574, 1643, 1579
3000, 1574, 1579, 1578
3001, 1643, 1648, 1579
3002, 1579, 1580, 1578
3003, 34, 1645, 35
3004, 35, 1645, 1624
3005, 35, 1624, 36
3006, 1513, 1618, 1616
3007, 1616, 1637, 1513
3008, 1614, 1637, 1616
3009, 1527, 1637, 1614
3010, 1527, 1614, 1612
3011, 1609, 1646, 1612
3012, 1612, 1646, 1527
3013, 1513, 1624, 1618
3014, 1528, 1645, 34
3015, 36, 1624, 1513
3016, 40, 1623, 41
3017, 1514, 1607, 1605
3018, 1605, 1634, 1514
3019, 1603, 1634, 1605
3020, 1623, 1646, 1609
3021, 1514, 1623, 1607
3022, 1515, 1634, 1603
3023, 1515, 1603, 1601
3024, 41, 1623, 1514
3025, 1601, 1629, 1515
3026, 1599, 1629, 1601
3027, 40, 1646, 1623
3028, 1507, 1629, 1599
3029, 1507, 1599, 1597
3030, 1594, 1635, 1597
3031, 1597, 1635, 1507
3032, 1607, 1623, 1609
3033, 1618, 1624, 1620
3034, 1523, 1581, 53
3035, 1625, 1635, 1594
3036, 47, 1625, 48
3037, 1523, 1582, 1581
3038, 53, 1581, 54
3039, 48, 1625, 1508
3040, 202, 1626, 201
3041, 1521, 1628, 198
3042, 1517, 1626, 202
3043, 1640, 1642, 1583
3044, 198, 1628, 197
3045, 200, 1639, 199
3046, 1523, 1640, 1583
3047, 1532, 1639, 200
3048, 1509, 1636, 194
3049, 201, 1532, 200
3050, 1523, 1583, 1582
3051, 1520, 1627, 196
3052, 45, 1629, 1507
3053, 201, 1626, 1532
3054, 1624, 1645, 1620
3055, 197, 1628, 1520
3056, 1608, 1611, 1606
3057, 1583, 1584, 1582
3058, 194, 1636, 193
3059, 1589, 1644, 1588
3060, 47, 1635, 1625
3061, 54, 1503, 55
3062, 63, 1505, 64
3063, 66, 1519, 67
3064, 1508, 1590, 1589
3065, 1599, 1601, 1600
3066, 1514, 1634, 42
3067, 50, 1588, 1526
3068, 205, 1518, 204
3069, 54, 1581, 1503
3070, 1508, 1625, 1590
3071, 1594, 1597, 1595
3072, 199, 1521, 198
3073, 209, 1506, 208
3074, 176, 1630, 1511
3075, 181, 1631, 1530
3076, 197, 1520, 196
3077, 1508, 1588, 49
3078, 182, 1631, 181
3079, 1590, 1594, 1592
3080, 1607, 1608, 1606
3081, 1614, 1616, 1615
3082, 190, 1524, 189
3083, 1590, 1592, 1591
3084, 189, 1638, 188
3085, 1508, 1589, 1588
3086, 57, 1504, 58
3087, 177, 1630, 176
3088, 1612, 1613, 1610
3089, 187, 1632, 186
3090, 188, 1638, 1525
3091, 1524, 1638, 189
3092, 193, 1522, 192
3093, 44, 1629, 45
3094, 1510, 1630, 177
3095, 199, 1639, 1521
3096, 1609, 1612, 1610
3097, 1612, 1614, 1613
3098, 1614, 1615, 1613
3099, 1618, 1619, 1617
3100, 1513, 1637, 37
3101, 173, 1531, 172
3102, 186, 1632, 1529
3103, 1526, 1642, 1640
3104, 1591, 1593, 1589
3105, 30, 1516, 31
3106, 33, 1528, 34
3107, 38, 1527, 39
3108, 41, 1514, 42
3109, 42, 1634, 43
3110, 43, 1515, 44
3111, 60, 1502, 61
3112, 176, 1511, 175
3113, 181, 1530, 180
3114, 186, 1529, 185
3115, 188, 1525, 187
3116, 36, 1513, 37
3117, 178, 1510, 177
3118, 183, 1512, 182
3119, 1512, 1631, 182
3120, 1525, 1632, 187
3121, 1619, 1621, 1617
3122, 1618, 1620, 1619
3123, 37, 1637, 38
3124, 1603, 1605, 1604
3125, 1607, 1609, 1608
3126, 38, 1637, 1527
3127, 1583, 1585, 1584
3128, 1616, 1617, 1615
3129, 1594, 1595, 1592
3130, 1605, 1607, 1606
3131, 43, 1634, 1515
3132, 1515, 1629, 44
3133, 1597, 1598, 1595
3134, 1603, 1604, 1602
3135, 1590, 1591, 1589
3136, 1599, 1600, 1598
3137, 193, 1636, 1522
3138, 195, 1509, 194
3139, 45, 1507, 46
3140, 1592, 1596, 1591
3141, 1597, 1599, 1598
3142, 1601, 1602, 1600
3143, 48, 1508, 49
3144, 50, 1526, 51
3145, 52, 1523, 53
3146, 1605, 1606, 1604
3147, 1609, 1610, 1608
3148, 1616, 1618, 1617
3149, 1601, 1603, 1602
3150, 203, 1517, 202
3151, 196, 1627, 195
3152, 49, 1588, 50
3153, 52, 1640, 1523
3154, 207, 1533, 206
3155, 1590, 1625, 1594
3156, 1593, 1644, 1589
3157, 1583, 1642, 1585
3158, 1588, 1644, 1526
3159, 39, 1646, 40
3160, 195, 1627, 1509
3161, 1507, 1635, 46
3162, 1526, 1644, 1642
3163, 46, 1635, 47
3164, 1593, 1647, 1644
3165, 1526, 1640, 51
3166, 51, 1640, 52
3167, 1527, 1646, 39
3168, 1644, 1647, 1642
3169, 1642, 1647, 1585
3170, 1581, 1587, 1503
3171, 1582, 1587, 1581
3172, 1584, 1586, 1582
3173, 1586, 1587, 1582
3174, 56, 1643, 57
3175, 57, 1643, 1504
3176, 1503, 1648, 55
3177, 56, 1648, 1643
3178, 1503, 1649, 1648
3179, 1573, 1576, 1575
3180, 55, 1648, 56
3181, 1648, 1649, 1579
3182, 1579, 1649, 1580
3183, 1587, 1649, 1503
3184, 1649, 1650, 1580
3185, 1587, 1650, 1649
3186, 1586, 1650, 1587
3187, 60, 1651, 1502
3188, 59, 1651, 60
3189, 1504, 1573, 1572
3190, 1504, 1572, 58
3191, 58, 1572, 59
3192, 1572, 1651, 59
3193, 1573, 1575, 1572
3194, 1575, 1651, 1572
3195, 1645, 1652, 1620
3196, 1528, 1652, 1645
3197, 1620, 1622, 1619
3198, 1620, 1652, 1622
3199, 32, 1633, 33
3200, 33, 1633, 1528
3201, 66, 1641, 1519
3202, 65, 1641, 66
3203, 211, 1536, 210
3204, 28, 1537, 29
3205, 1550, 1698, 1551
3206, 1575, 1654, 1651
3207, 1569, 1704, 1518
3208, 1518, 1689, 1570
3209, 1651, 1654, 1502
3210, 174, 1691, 1551
3211, 1571, 1693, 1506
3212, 1641, 1694, 1560
3213, 1540, 1655, 1535
3214, 1554, 1656, 1534
3215, 1563, 1659, 1561
3216, 169, 1656, 170
3217, 149, 1655, 148
3218, 1660, 1682, 1596
3219, 1662, 1684, 1611
3220, 1664, 1686, 1621
3221, 1530, 1674, 1665
3222, 1522, 1668, 1661
3223, 1529, 1672, 1663
3224, 172, 1658, 171
3225, 67, 1657, 68
3226, 1575, 1688, 1654
3227, 1561, 1659, 1559
3228, 191, 1660, 190
3229, 1591, 1661, 1593
3230, 184, 1662, 183
3231, 1606, 1663, 1604
3232, 179, 1664, 178
3233, 1617, 1665, 1615
3234, 1522, 1682, 192
3235, 1592, 1683, 1596
3236, 1529, 1684, 185
3237, 1530, 1686, 180
3238, 1608, 1685, 1611
3239, 1619, 1687, 1621
3240, 1654, 1688, 1568
3241, 1547, 1699, 1548
3242, 1544, 1701, 1516
3243, 1548, 1699, 1653
3244, 1546, 1692, 1633
3245, 1533, 1689, 206
3246, 205, 1689, 1518
3247, 1534, 1656, 169
3248, 1535, 1655, 149
3249, 1519, 1657, 67
3250, 1531, 1658, 172
3251, 1505, 1690, 1562
3252, 1511, 1691, 175
3253, 207, 1693, 1533
3254, 1506, 1693, 208
3255, 1505, 1694, 64
3256, 65, 1694, 1641
3257, 1553, 1697, 1555
3258, 1539, 1698, 1541
3259, 1528, 1692, 1652
3260, 209, 1696, 1506
3261, 30, 1695, 1516
3262, 1536, 1696, 210
3263, 1537, 1695, 29
3264, 1559, 1659, 1571
3265, 62, 1690, 63
3266, 1661, 1682, 1522
3267, 1596, 1683, 1660
3268, 1663, 1684, 1529
3269, 1611, 1685, 1662
3270, 1665, 1686, 1530
3271, 1621, 1687, 1664
3272, 1516, 1701, 31
3273, 32, 1701, 1633
3274, 190, 1660, 1524
3275, 1596, 1661, 1591
3276, 183, 1662, 1512
3277, 1611, 1663, 1606
3278, 178, 1664, 1510
3279, 1621, 1665, 1617
3280, 4, 1705, 167
3281, 9, 1706, 151
3282, 171, 1706, 9
3283, 68, 1705, 4
3284, 61, 1703, 62
3285, 1524, 1683, 1669
3286, 1512, 1685, 1673
3287, 1677, 1678, 1580
3288, 1676, 1677, 1650
3289, 1580, 1678, 1578
3290, 1678, 1679, 1578
3291, 1577, 1680, 1576
3292, 1578, 1679, 1577
3293, 1675, 1676, 1586
3294, 1647, 1668, 1666
3295, 1666, 1667, 1585
3296, 1666, 1668, 1636
3297, 1509, 1666, 1636
3298, 1585, 1667, 1584
3299, 1593, 1668, 1647
3300, 1509, 1667, 1666
3301, 1602, 1672, 1671
3302, 1671, 1672, 1632
3303, 1627, 1667, 1509
3304, 1524, 1669, 1638
3305, 1636, 1668, 1522
3306, 1647, 1666, 1585
3307, 1638, 1670, 1525
3308, 1670, 1671, 1525
3309, 1669, 1670, 1638
3310, 1525, 1671, 1632
3311, 1598, 1669, 1595
3312, 1604, 1672, 1602
3313, 1600, 1671, 1670
3314, 1600, 1670, 1598
3315, 1598, 1670, 1669
3316, 1602, 1671, 1600
3317, 1632, 1672, 1529
3318, 1512, 1673, 1631
3319, 1673, 1674, 1631
3320, 1631, 1674, 1530
3321, 1613, 1673, 1610
3322, 1613, 1674, 1673
3323, 1615, 1674, 1613
3324, 1667, 1675, 1584
3325, 1520, 1675, 1627
3326, 1627, 1675, 1667
3327, 1584, 1675, 1586
3328, 1520, 1676, 1675
3329, 1628, 1676, 1520
3330, 1650, 1677, 1580
3331, 1628, 1677, 1676
3332, 1521, 1677, 1628
3333, 1679, 1680, 1577
3334, 1586, 1676, 1650
3335, 1521, 1678, 1677
3336, 1639, 1678, 1521
3337, 1639, 1679, 1678
3338, 1532, 1679, 1639
3339, 1532, 1680, 1679
3340, 1626, 1680, 1532
3341, 1626, 1681, 1680
3342, 1517, 1681, 1626
3343, 1680, 1681, 1576
3344, 1669, 1683, 1595
3345, 1673, 1685, 1610
3346, 192, 1682, 191
3347, 1595, 1683, 1592
3348, 185, 1684, 184
3349, 1610, 1685, 1608
3350, 180, 1686, 179
3351, 1622, 1687, 1619
3352, 203, 1704, 1517
3353, 1518, 1704, 204
3354, 1551, 1691, 1549
3355, 1533, 1700, 1689
3356, 1576, 1688, 1575
3357, 148, 1707, 3
3358, 170, 1708, 10
3359, 3, 1707, 28
3360, 10, 1708, 211
3361, 63, 1690, 1505
3362, 1570, 1700, 1563
3363, 206, 1689, 205
3364, 1562, 1690, 1565
3365, 1660, 1683, 1524
3366, 1596, 1682, 1661
3367, 1662, 1685, 1512
3368, 1611, 1684, 1663
3369, 1621, 1686, 1665
3370, 1664, 1687, 1510
3371, 1681, 1688, 1576
3372, 1630, 1699, 1511
3373, 1653, 1699, 1630
3374, 1689, 1700, 1570
3375, 175, 1691, 174
3376, 1633, 1692, 1528
3377, 1548, 1692, 1546
3378, 208, 1693, 207
3379, 64, 1694, 65
3380, 210, 1696, 209
3381, 29, 1695, 30
3382, 1555, 1697, 1558
3383, 1541, 1698, 1550
3384, 1517, 1702, 1681
3385, 1568, 1702, 1569
3386, 31, 1701, 32
3387, 1563, 1700, 1659
3388, 1656, 1708, 170
3389, 1655, 1707, 148
3390, 1502, 1703, 61
3391, 1658, 1706, 171
3392, 1657, 1705, 68
3393, 204, 1704, 203
3394, 167, 1705, 1552
3395, 151, 1706, 1538
3396, 28, 1707, 1537
3397, 211, 1708, 1536
3398, 1536, 1708, 1656
3399, 1537, 1707, 1655
3400, 1688, 1702, 1568
3401, 1681, 1702, 1688
3402, 1538, 1706, 1658
3403, 1552, 1705, 1657
*ELEMENT, type=CPS3, ELSET=Surface4
3404, 1729, 1785, 1721
3405, 1742, 1786, 1725
3406, 1766, 1768, 1751
3407, 1751, 1769, 1766
3408, 1737, 1775, 1739
3409, 1736, 1737, 1711
3410, 1721, 1799, 1729
3411, 1725, 1800, 1742
3412, 1730, 1732, 1726
3413, 1743, 1745, 1727
3414, 1749, 1778, 1747
3415, 1735, 1775, 1737
3416, 1711, 1794, 1736
3417, 1723, 1770, 1769
3418, 1732, 1796, 1726
3419, 1745, 1798, 1727
3420, 1778, 1802, 1747
3421, 1723, 1801, 1770
3422, 1737, 1738, 1711
3423, 1732, 1733, 1714
3424, 1745, 1746, 1718
3425, 1733, 1736, 1714
3426, 1746, 1747, 1718
3427, 1782, 1793, 1752
3428, 1739, 1773, 1740
3429, 1775, 1795, 1739
3430, 1728, 1785, 1729
3431, 1734, 1799, 1779
3432, 1741, 1786, 1742
3433, 1752, 1800, 1782
3434, 1726, 1783, 1730
3435, 1727, 1784, 1743
3436, 1750, 1806, 1751
3437, 1791, 1804, 1740
3438, 1740, 1805, 1791
3439, 1739, 1795, 1773
3440, 1710, 1793, 1782
3441, 1751, 1806, 1769
3442, 1746, 1752, 1748
3443, 1779, 1803, 1734
3444, 1737, 1739, 1738
3445, 1746, 1748, 1747
3446, 1779, 1799, 1721
3447, 1782, 1800, 1725
3448, 1739, 1740, 1738
3449, 1748, 1749, 1747
3450, 1714, 1796, 1732
3451, 1718, 1798, 1745
3452, 1728, 1729, 1724
3453, 1741, 1742, 1716
3454, 169, 1728, 1724
3455, 1729, 1730, 1724
3456, 213, 1741, 1716
3457, 1742, 1743, 1716
3458, 1729, 1731, 1730
3459, 1742, 1744, 1743
3460, 1748, 1750, 1749
3461, 1744, 1745, 1743
3462, 170, 1728, 169
3463, 1744, 1746, 1745
3464, 169, 1724, 168
3465, 1731, 1732, 1730
3466, 213, 1716, 214
3467, 212, 1741, 213
3468, 1731, 1733, 1732
3469, 1744, 1752, 1746
3470, 1731, 1734, 1733
3471, 1734, 1735, 1733
3472, 1750, 1751, 1749
3473, 1735, 1736, 1733
3474, 1735, 1737, 1736
3475, 1769, 1770, 1766
3476, 1771, 1773, 1772
3477, 1765, 1781, 1756
3478, 1756, 1781, 1755
3479, 1754, 1760, 225
3480, 1757, 1760, 1754
3481, 225, 1760, 224
3482, 1755, 1757, 1754
3483, 79, 1777, 80
3484, 1722, 1779, 219
3485, 226, 1754, 225
3486, 1720, 1774, 221
3487, 1755, 1758, 1757
3488, 71, 1714, 72
3489, 221, 1774, 220
3490, 224, 1719, 223
3491, 84, 1753, 1710
3492, 1713, 1776, 76
3493, 78, 1780, 79
3494, 79, 1780, 1777
3495, 75, 1713, 76
3496, 82, 1723, 83
3497, 80, 1777, 1709
3498, 233, 1718, 232
3499, 76, 1776, 77
3500, 77, 1712, 78
3501, 1717, 1755, 1754
3502, 84, 1710, 85
3503, 218, 1721, 217
3504, 227, 1717, 226
3505, 220, 1774, 1722
3506, 219, 1779, 218
3507, 1723, 1753, 83
3508, 230, 1715, 229
3509, 80, 1709, 81
3510, 83, 1753, 84
3511, 222, 1720, 221
3512, 218, 1779, 1721
3513, 77, 1776, 1712
3514, 1712, 1780, 78
3515, 1717, 1754, 226
3516, 73, 1711, 74
3517, 220, 1722, 219
3518, 224, 1760, 1719
3519, 1755, 1781, 1758
3520, 1759, 1761, 1757
3521, 1764, 1765, 1756
3522, 1758, 1759, 1757
3523, 1717, 1763, 1756
3524, 1764, 1766, 1765
3525, 1717, 1756, 1755
3526, 1757, 1761, 1760
3527, 229, 1767, 228
3528, 1771, 1772, 1719
3529, 227, 1763, 1717
3530, 1719, 1772, 223
3531, 223, 1772, 222
3532, 222, 1772, 1720
3533, 1763, 1764, 1756
3534, 1715, 1767, 229
3535, 1760, 1761, 1719
3536, 228, 1763, 227
3537, 228, 1767, 1763
3538, 1759, 1762, 1761
3539, 1763, 1767, 1764
3540, 1772, 1773, 1720
3541, 1764, 1768, 1766
3542, 1715, 1768, 1767
3543, 1767, 1768, 1764
3544, 1761, 1771, 1719
3545, 231, 1778, 230
3546, 230, 1778, 1715
3547, 1762, 1771, 1761
3548, 1774, 1775, 1722
3549, 85, 1782, 86
3550, 1710, 1782, 85
3551, 86, 1725, 87
3552, 69, 1726, 70
3553, 235, 1727, 234
3554, 86, 1782, 1725
3555, 1768, 1797, 1751
3556, 1738, 1792, 1711
3557, 1736, 1794, 1714
3558, 1730, 1783, 1724
3559, 1743, 1784, 1716
3560, 1748, 1793, 1750
3561, 168, 1783, 167
3562, 214, 1784, 215
3563, 217, 1785, 216
3564, 87, 1786, 88
3565, 1770, 1801, 1709
3566, 1711, 1792, 74
3567, 75, 1792, 1713
3568, 1747, 1802, 1718
3569, 1724, 1783, 168
3570, 1716, 1784, 214
3571, 1721, 1785, 217
3572, 1725, 1786, 87
3573, 73, 1794, 1711
3574, 1714, 1794, 72
3575, 1773, 1805, 1740
3576, 1773, 1795, 1720
3577, 1774, 1795, 1775
3578, 71, 1796, 1714
3579, 1729, 1799, 1731
3580, 1749, 1797, 1778
3581, 233, 1798, 1718
3582, 1742, 1800, 1744
3583, 1726, 1796, 70
3584, 1727, 1798, 234
3585, 1780, 1790, 1777
3586, 1777, 1790, 1789
3587, 1758, 1787, 1759
3588, 1765, 1789, 1781
3589, 1787, 1788, 1759
3590, 1789, 1790, 1781
3591, 1759, 1788, 1762
3592, 1712, 1787, 1780
3593, 1712, 1788, 1787
3594, 1776, 1788, 1712
3595, 1758, 1790, 1787
3596, 1787, 1790, 1780
3597, 1777, 1789, 1709
3598, 1788, 1791, 1762
3599, 1713, 1791, 1776
3600, 1776, 1791, 1788
3601, 1781, 1790, 1758
3602, 1715, 1797, 1768
3603, 10, 1807, 170
3604, 6, 1808, 212
3605, 216, 1807, 10
3606, 88, 1808, 6
3607, 1709, 1801, 81
3608, 82, 1801, 1723
3609, 1718, 1802, 232
3610, 231, 1802, 1778
3611, 1722, 1803, 1779
3612, 1752, 1793, 1748
3613, 1771, 1805, 1773
3614, 167, 1809, 4
3615, 215, 1810, 11
3616, 4, 1809, 69
3617, 11, 1810, 235
3618, 74, 1792, 75
3619, 1770, 1812, 1766
3620, 1766, 1812, 1765
3621, 1713, 1804, 1791
3622, 1709, 1812, 1770
3623, 1735, 1803, 1775
3624, 1750, 1811, 1806
3625, 1734, 1803, 1735
3626, 1793, 1811, 1750
3627, 72, 1794, 73
3628, 1778, 1797, 1715
3629, 1720, 1795, 1774
3630, 70, 1796, 71
3631, 1751, 1797, 1749
3632, 234, 1798, 233
3633, 1792, 1804, 1713
3634, 1731, 1799, 1734
3635, 1791, 1805, 1762
3636, 1744, 1800, 1752
3637, 81, 1801, 82
3638, 232, 1802, 231
3639, 1775, 1803, 1722
3640, 1783, 1809, 167
3641, 1784, 1810, 215
3642, 1740, 1804, 1738
3643, 1762, 1805, 1771
3644, 1785, 1807, 216
3645, 1769, 1806, 1723
3646, 1786, 1808, 88
3647, 1723, 1806, 1753
3648, 170, 1807, 1728
3649, 212, 1808, 1741
3650, 1806, 1811, 1753
3651, 69, 1809, 1726
3652, 235, 1810, 1727
3653, 1789, 1812, 1709
3654, 1738, 1804, 1792
3655, 1753, 1811, 1710
3656, 1726, 1809, 1783
3657, 1727, 1810, 1784
3658, 1728, 1807, 1785
3659, 1741, 1808, 1786
3660, 1765, 1812, 1789
3661, 1710, 1811, 1793
*ELEMENT, type=CPS3, ELSET=Surface5
3662, 1835, 1902, 1827
3663, 1852, 1903, 1831
3664, 1827, 1914, 1835
3665, 1842, 1843, 1817
3666, 1836, 1838, 1832
3667, 1831, 1915, 1852
3668, 1853, 1855, 1833
3669, 1850, 1922, 1904
3670, 1848, 1922, 1850
3671, 1838, 1912, 1832
3672, 1855, 1913, 1833
3673, 1817, 1911, 1842
3674, 1859, 1877, 1857
3675, 1843, 1844, 1817
3676, 1891, 1909, 1862
3677, 1849, 1863, 1819
3678, 1839, 1842, 1820
3679, 1838, 1839, 1820
3680, 1877, 1917, 1857
3681, 1855, 1856, 1822
3682, 1856, 1857, 1822
3683, 1849, 1905, 1863
3684, 1865, 1922, 1847
3685, 1832, 1900, 1836
3686, 1840, 1914, 1864
3687, 1834, 1902, 1835
