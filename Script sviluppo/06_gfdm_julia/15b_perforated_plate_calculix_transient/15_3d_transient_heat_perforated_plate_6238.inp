*Heading
 Z:\Documenti\Università\Tesi\Script sviluppo\06_gfdm_julia\15b_perforated_plate_calculix_transient\15_3d_transient_heat_perforated_plate.inp
*NODE
1, 0, 0, 0
2, 0.635, 0, 0
3, 0.9395, 0, 0
4, 0.9395, 0.83376173371096, 0
5, 0.9395, 1.627261733711, 0
6, 0.54275, 0.94007057580801, 0
7, 0.3175, 0.54992613140312, 0
8, 0.635, 0, 0.1
9, 0.9395, 0, 0.1
10, 0.9395, 0.83376173371096, 0.1
11, 0.54275, 0.94007057580801, 0.1
12, 0.3175, 0.54992613140312, 0.1
13, 0.65403125, 0, 0
14, 0.6730625, 0, 0
15, 0.69209375, 0, 0
16, 0.711125, 0, 0
17, 0.73015625, 0, 0
18, 0.7491875, 0, 0
19, 0.76821875, 0, 0
20, 0.78725, 0, 0
21, 0.80628125, 0, 0
22, 0.8253125, 0, 0
23, 0.84434375, 0, 0
24, 0.863375, 0, 0
25, 0.88240625, 0, 0
26, 0.9014375, 0, 0
27, 0.92046875, 0, 0
28, 0.9395, 0.019851469850261, 0
29, 0.9395, 0.039702939700522, 0
30, 0.9395, 0.059554409550783, 0
31, 0.9395, 0.079405879401044, 0
32, 0.9395, 0.099257349251305, 0
33, 0.9395, 0.11910881910157, 0
34, 0.9395, 0.13896028895183, 0
35, 0.9395, 0.15881175880209, 0
36, 0.9395, 0.17866322865235, 0
37, 0.9395, 0.19851469850261, 0
38, 0.9395, 0.21836616835287, 0
39, 0.9395, 0.23821763820313, 0
40, 0.9395, 0.25806910805339, 0
41, 0.9395, 0.27792057790365, 0
42, 0.9395, 0.29777204775391, 0
43, 0.9395, 0.31762351760418, 0
44, 0.9395, 0.33747498745444, 0
45, 0.9395, 0.3573264573047, 0
46, 0.9395, 0.37717792715496, 0
47, 0.9395, 0.39702939700522, 0
48, 0.9395, 0.41688086685548, 0
49, 0.9395, 0.43673233670574, 0
50, 0.9395, 0.456583806556, 0
51, 0.9395, 0.47643527640626, 0
52, 0.9395, 0.49628674625652, 0
53, 0.9395, 0.51613821610679, 0
54, 0.9395, 0.53598968595705, 0
55, 0.9395, 0.55584115580731, 0
56, 0.9395, 0.57569262565757, 0
57, 0.9395, 0.59554409550783, 0
58, 0.9395, 0.61539556535809, 0
59, 0.9395, 0.63524703520835, 0
60, 0.9395, 0.65509850505861, 0
61, 0.9395, 0.67494997490887, 0
62, 0.9395, 0.69480144475913, 0
63, 0.9395, 0.71465291460939, 0
64, 0.9395, 0.73450438445966, 0
65, 0.9395, 0.75435585430992, 0
66, 0.9395, 0.77420732416018, 0
67, 0.9395, 0.79405879401044, 0
68, 0.9395, 0.8139102638607, 0
69, 0.91971749610584, 0.83400836779331, 0
70, 0.89994728972824, 0.83474811672375, 0
71, 0.88020167073917, 0.83598052064769, 0
72, 0.86049291372622, 0.83770481345851, 0
73, 0.84083327036222, 0.83991992327372, 0
74, 0.82123496178921, 0.84262447310132, 0
75, 0.80171017102129, 0.84581678169577, 0
76, 0.78227103537128, 0.84949486460314, 0
77, 0.76292963890566, 0.85365643539468, 0
78, 0.74369800493275, 0.85829890708819, 0
79, 0.72458808852853, 0.86341939375613, 0
80, 0.70561176910495, 0.86901471231966, 0
81, 0.68678084302529, 0.87508138452734, 0
82, 0.66810701627108, 0.88161563911734, 0
83, 0.64960189716527, 0.88861341416178, 0
84, 0.63127698915603, 0.89607035959179, 0
85, 0.61314368366586, 0.90398183990165, 0
86, 0.59521325301022, 0.91234293703039, 0
87, 0.57749684339027, 0.92114845341906, 0
88, 0.56000546796398, 0.93039291524168, 0
89, 0.53295652173913, 0.92310777387736, 0
90, 0.52316304347826, 0.90614497194671, 0
91, 0.51336956521739, 0.88918217001607, 0
92, 0.50357608695652, 0.87221936808542, 0
93, 0.49378260869565, 0.85525656615477, 0
94, 0.48398913043478, 0.83829376422412, 0
95, 0.47419565217391, 0.82133096229348, 0
96, 0.46440217391304, 0.80436816036283, 0
97, 0.45460869565217, 0.78740535843218, 0
98, 0.4448152173913, 0.77044255650153, 0
99, 0.43502173913043, 0.75347975457089, 0
100, 0.42522826086957, 0.73651695264024, 0
101, 0.4154347826087, 0.71955415070959, 0
102, 0.40564130434783, 0.70259134877894, 0
103, 0.39584782608696, 0.6856285468483, 0
104, 0.38605434782609, 0.66866574491765, 0
105, 0.37626086956522, 0.651702942987, 0
106, 0.36646739130435, 0.63474014105636, 0
107, 0.35667391304348, 0.61777733912571, 0
108, 0.34688043478261, 0.60081453719506, 0
109, 0.33708695652174, 0.58385173526441, 0
110, 0.32729347826087, 0.56688893333377, 0
111, 0.33428442342712, 0.53988788118831, 0
112, 0.35075175782992, 0.52933751461541, 0
113, 0.36688638294424, 0.5182850393462, 0
114, 0.38267299410083, 0.50674093932295, 0
115, 0.39809661674276, 0.4947161648238, 0
116, 0.41314262062969, 0.48222212207574, 0
117, 0.42779673371556, 0.46927066243512, 0
118, 0.44204505568646, 0.45587407114592, 0
119, 0.45587407114592, 0.44204505568646, 0
120, 0.46927066243512, 0.42779673371556, 0
121, 0.48222212207574, 0.41314262062969, 0
122, 0.4947161648238, 0.39809661674276, 0
123, 0.50674093932295, 0.38267299410083, 0
124, 0.5182850393462, 0.36688638294424, 0
125, 0.52933751461541, 0.35075175782992, 0
126, 0.5398878811883, 0.33428442342712, 0
127, 0.54992613140312, 0.3175, 0
128, 0.55944274337147, 0.30041440859087, 0
129, 0.56842869001046, 0.2830438559181, 0
130, 0.5768754476054, 0.26540481900311, 0
131, 0.58477500389505, 0.24751402954085, 0
132, 0.59211986567177, 0.22938845802884, 0
133, 0.59890306588926, 0.21104529766958, 0
134, 0.60511817027124, 0.19250194806178, 0
135, 0.61075928341474, 0.17377599869577, 0
136, 0.61582105438223, 0.15488521226882, 0
137, 0.62029868177735, 0.13584750783613, 0
138, 0.62418791829928, 0.11668094381352, 0
139, 0.6274850747716, 0.097403700847966, 0
140, 0.63018702364168, 0.078034064572094, 0
141, 0.63229120194735, 0.058590408259197, 0
142, 0.63379561374802, 0.039091175395054, 0
143, 0.63469883201799, 0.019554862183168, 0
144, 0.635, 0, 0.02
145, 0.635, 0, 0.04
146, 0.635, 0, 0.06
147, 0.635, 0, 0.08
148, 0.9395, 0, 0.02
149, 0.9395, 0, 0.04
150, 0.9395, 0, 0.06
151, 0.9395, 0, 0.08
152, 0.65403125, 0, 0.1
153, 0.6730625, 0, 0.1
154, 0.69209375, 0, 0.1
155, 0.711125, 0, 0.1
156, 0.73015625, 0, 0.1
157, 0.7491875, 0, 0.1
158, 0.76821875, 0, 0.1
159, 0.78725, 0, 0.1
160, 0.80628125, 0, 0.1
161, 0.8253125, 0, 0.1
162, 0.84434375, 0, 0.1
163, 0.863375, 0, 0.1
164, 0.88240625, 0, 0.1
165, 0.9014375, 0, 0.1
166, 0.92046875, 0, 0.1
167, 0.9395, 0.83376173371096, 0.02
168, 0.9395, 0.83376173371096, 0.04
169, 0.9395, 0.83376173371096, 0.06
170, 0.9395, 0.83376173371096, 0.08
171, 0.9395, 0.019851469850261, 0.1
172, 0.9395, 0.039702939700522, 0.1
173, 0.9395, 0.059554409550783, 0.1
174, 0.9395, 0.079405879401044, 0.1
175, 0.9395, 0.099257349251305, 0.1
176, 0.9395, 0.11910881910157, 0.1
177, 0.9395, 0.13896028895183, 0.1
178, 0.9395, 0.15881175880209, 0.1
179, 0.9395, 0.17866322865235, 0.1
180, 0.9395, 0.19851469850261, 0.1
181, 0.9395, 0.21836616835287, 0.1
182, 0.9395, 0.23821763820313, 0.1
183, 0.9395, 0.25806910805339, 0.1
184, 0.9395, 0.27792057790365, 0.1
185, 0.9395, 0.29777204775391, 0.1
186, 0.9395, 0.31762351760418, 0.1
187, 0.9395, 0.33747498745444, 0.1
188, 0.9395, 0.3573264573047, 0.1
189, 0.9395, 0.37717792715496, 0.1
190, 0.9395, 0.39702939700522, 0.1
191, 0.9395, 0.41688086685548, 0.1
192, 0.9395, 0.43673233670574, 0.1
193, 0.9395, 0.456583806556, 0.1
194, 0.9395, 0.47643527640626, 0.1
195, 0.9395, 0.49628674625652, 0.1
196, 0.9395, 0.51613821610679, 0.1
197, 0.9395, 0.53598968595705, 0.1
198, 0.9395, 0.55584115580731, 0.1
199, 0.9395, 0.57569262565757, 0.1
200, 0.9395, 0.59554409550783, 0.1
201, 0.9395, 0.61539556535809, 0.1
202, 0.9395, 0.63524703520835, 0.1
203, 0.9395, 0.65509850505861, 0.1
204, 0.9395, 0.67494997490887, 0.1
205, 0.9395, 0.69480144475913, 0.1
206, 0.9395, 0.71465291460939, 0.1
207, 0.9395, 0.73450438445966, 0.1
208, 0.9395, 0.75435585430992, 0.1
209, 0.9395, 0.77420732416018, 0.1
210, 0.9395, 0.79405879401044, 0.1
211, 0.9395, 0.8139102638607, 0.1
212, 0.54275, 0.94007057580801, 0.02
213, 0.54275, 0.94007057580801, 0.04
214, 0.54275, 0.94007057580801, 0.06
215, 0.54275, 0.94007057580801, 0.08
216, 0.91971749610584, 0.83400836779331, 0.1
217, 0.89994728972824, 0.83474811672375, 0.1
218, 0.88020167073917, 0.83598052064769, 0.1
219, 0.86049291372622, 0.83770481345851, 0.1
220, 0.84083327036222, 0.83991992327372, 0.1
221, 0.82123496178921, 0.84262447310132, 0.1
222, 0.80171017102129, 0.84581678169577, 0.1
223, 0.78227103537128, 0.84949486460314, 0.1
224, 0.76292963890566, 0.85365643539468, 0.1
225, 0.74369800493275, 0.85829890708819, 0.1
226, 0.72458808852853, 0.86341939375613, 0.1
227, 0.70561176910495, 0.86901471231966, 0.1
228, 0.68678084302529, 0.87508138452734, 0.1
229, 0.66810701627108, 0.88161563911734, 0.1
230, 0.64960189716527, 0.88861341416178, 0.1
231, 0.63127698915603, 0.89607035959179, 0.1
232, 0.61314368366586, 0.90398183990165, 0.1
233, 0.59521325301022, 0.91234293703039, 0.1
234, 0.57749684339027, 0.92114845341906, 0.1
235, 0.56000546796398, 0.93039291524168, 0.1
236, 0.3175, 0.54992613140312, 0.02
237, 0.3175, 0.54992613140312, 0.04
238, 0.3175, 0.54992613140312, 0.06
239, 0.3175, 0.54992613140312, 0.08
240, 0.53295652173913, 0.92310777387736, 0.1
241, 0.52316304347826, 0.90614497194671, 0.1
242, 0.51336956521739, 0.88918217001607, 0.1
243, 0.50357608695652, 0.87221936808542, 0.1
244, 0.49378260869565, 0.85525656615477, 0.1
245, 0.48398913043478, 0.83829376422412, 0.1
246, 0.47419565217391, 0.82133096229348, 0.1
247, 0.46440217391304, 0.80436816036283, 0.1
248, 0.45460869565217, 0.78740535843218, 0.1
249, 0.4448152173913, 0.77044255650153, 0.1
250, 0.43502173913043, 0.75347975457089, 0.1
251, 0.42522826086957, 0.73651695264024, 0.1
252, 0.4154347826087, 0.71955415070959, 0.1
253, 0.40564130434783, 0.70259134877894, 0.1
254, 0.39584782608696, 0.6856285468483, 0.1
255, 0.38605434782609, 0.66866574491765, 0.1
256, 0.37626086956522, 0.651702942987, 0.1
257, 0.36646739130435, 0.63474014105636, 0.1
258, 0.35667391304348, 0.61777733912571, 0.1
259, 0.34688043478261, 0.60081453719506, 0.1
260, 0.33708695652174, 0.58385173526441, 0.1
261, 0.32729347826087, 0.56688893333377, 0.1
262, 0.33428442342712, 0.53988788118831, 0.1
263, 0.35075175782992, 0.52933751461541, 0.1
264, 0.36688638294424, 0.5182850393462, 0.1
265, 0.38267299410083, 0.50674093932295, 0.1
266, 0.39809661674276, 0.4947161648238, 0.1
267, 0.41314262062969, 0.48222212207574, 0.1
268, 0.42779673371556, 0.46927066243512, 0.1
269, 0.44204505568646, 0.45587407114592, 0.1
270, 0.45587407114592, 0.44204505568646, 0.1
271, 0.46927066243512, 0.42779673371556, 0.1
272, 0.48222212207574, 0.41314262062969, 0.1
273, 0.4947161648238, 0.39809661674276, 0.1
274, 0.50674093932295, 0.38267299410083, 0.1
275, 0.5182850393462, 0.36688638294424, 0.1
276, 0.52933751461541, 0.35075175782992, 0.1
277, 0.5398878811883, 0.33428442342712, 0.1
278, 0.54992613140312, 0.3175, 0.1
279, 0.55944274337147, 0.30041440859087, 0.1
280, 0.56842869001046, 0.2830438559181, 0.1
281, 0.5768754476054, 0.26540481900311, 0.1
282, 0.58477500389505, 0.24751402954085, 0.1
283, 0.59211986567177, 0.22938845802884, 0.1
284, 0.59890306588926, 0.21104529766958, 0.1
285, 0.60511817027124, 0.19250194806178, 0.1
286, 0.61075928341474, 0.17377599869577, 0.1
287, 0.61582105438223, 0.15488521226882, 0.1
288, 0.62029868177735, 0.13584750783613, 0.1
289, 0.62418791829928, 0.11668094381352, 0.1
290, 0.6274850747716, 0.097403700847966, 0.1
291, 0.63018702364168, 0.078034064572094, 0.1
292, 0.63229120194735, 0.058590408259197, 0.1
293, 0.63379561374802, 0.039091175395054, 0.1
294, 0.63469883201799, 0.019554862183168, 0.1
295, 0.49010530071153, 0.4303722136375, 0
296, 0.92299090816313, 0.60463959566353, 0
297, 0.72970857519646, 0.8443094773519, 0
298, 0.44454728597475, 0.73691196404579, 0
299, 0.92056528951285, 0.50523629685956, 0
300, 0.53781717726652, 0.36821209045345, 0
301, 0.92230904877108, 0.40694707002069, 0
302, 0.57905960372086, 0.29935420177969, 0
303, 0.92208352769214, 0.327406086332, 0
304, 0.61831933738185, 0.20668500372103, 0
305, 0.40722760146771, 0.67038512080802, 0
306, 0.777734375, 0.016481545965773, 0
307, 0.9223084566416, 0.24811924144711, 0
308, 0.92230812280721, 0.684875709834, 0
309, 0.48557652960763, 0.80376812013285, 0
310, 0.9223320369444, 0.1680945750138, 0
311, 0.63977105120272, 0.12880326912159, 0
312, 0.43160266311671, 0.48800192214794, 0
313, 0.65301122730137, 0.87003493306484, 0
314, 0.80858554372455, 0.82430699412955, 0
315, 0.92060428504426, 0.11245867822071, 0
316, 0.72030327944567, 0.016507708498079, 0
317, 0.37556325955749, 0.61679407441458, 0
318, 0.8362141265947, 0.017453635767373, 0
319, 0.51162780543908, 0.85622099282025, 0
320, 0.92284507293249, 0.74442970658781, 0
321, 0.64813676878989, 0.069736513950306, 0
322, 0.38443915404929, 0.52623527696785, 0
323, 0.59927685587102, 0.89271428239434, 0
324, 0.86905416730206, 0.82250119448792, 0
325, 0.46023299104651, 0.461110737078, 0
326, 0.5135814157889, 0.40018738159897, 0
327, 0.55959649118361, 0.33445928792331, 0
328, 0.5965984295758, 0.26300583521281, 0
329, 0.62893913649945, 0.16929273347993, 0
330, 0.69032930853858, 0.85459188856934, 0
331, 0.76868040019758, 0.83537404626557, 0
332, 0.92177159852883, 0.069688021746149, 0
333, 0.92232426835704, 0.20841391957794, 0
334, 0.92231082216338, 0.28783994326436, 0
335, 0.92352764753454, 0.367249826964, 0
336, 0.92261655653855, 0.44609301375486, 0
337, 0.92230812280721, 0.54591542088218, 0
338, 0.92158976450031, 0.64453300924827, 0
339, 0.42514557699265, 0.70206198849899, 0
340, 0.4643715981406, 0.77016670719822, 0
341, 0.87240024066051, 0.01731187553427, 0
342, 0.68483576760285, 0.016410711645138, 0
343, 0.35738533190224, 0.58463112503701, 0
344, 0.53268627591827, 0.88906876909692, 0
345, 0.92270749844714, 0.78410590997729, 0
346, 0.92080259226209, 0.029683563203451, 0
347, 0.35275212515914, 0.55066516535015, 0
348, 0.90869550376239, 0.81572781119956, 0
349, 0.55989794171843, 0.90944645471585, 0
350, 0.65314812892216, 0.02953869772195, 0
351, 0.65023297262544, 0.049583596882867, 0
352, 0.66588834556637, 0.061031274908335, 0
353, 0.66410528295818, 0.080928690643418, 0
354, 0.68178043562672, 0.07246863645208, 0
355, 0.67999629271064, 0.092277828600127, 0
356, 0.69773857835288, 0.083834088557008, 0
357, 0.69592447392025, 0.10344358410973, 0
358, 0.71367069187623, 0.094982439262052, 0
359, 0.71165053577912, 0.11459304439481, 0
360, 0.72960364369793, 0.10602450101749, 0
361, 0.72746150754939, 0.12558315367606, 0
362, 0.7455844942814, 0.11708102907333, 0
363, 0.74358137718553, 0.13650242938623, 0
364, 0.76160783368828, 0.12816489818903, 0
365, 0.75997146788985, 0.14762637652036, 0
366, 0.74195301438191, 0.15592143241776, 0
367, 0.75834659944371, 0.16709920339928, 0
368, 0.7406425540514, 0.17542715759645, 0
369, 0.75672212098636, 0.18659906976764, 0
370, 0.73875986802775, 0.19492562933782, 0
371, 0.75505183513314, 0.20612050131011, 0
372, 0.7370640222127, 0.21445508019426, 0
373, 0.75340007019707, 0.22566151716081, 0
374, 0.73569722701357, 0.2340196326511, 0
375, 0.75185893583946, 0.24522249579831, 0
376, 0.73411132445954, 0.25358668030855, 0
377, 0.75019331771537, 0.26479178730793, 0
378, 0.73246719794929, 0.27316206365881, 0
379, 0.74855206119166, 0.28437229913429, 0
380, 0.73081978032661, 0.29274539287864, 0
381, 0.74694428084437, 0.30396268899401, 0
382, 0.72906107839563, 0.31252729136037, 0
383, 0.7452544430925, 0.32359057477816, 0
384, 0.72723084751865, 0.33225307375881, 0
385, 0.74357718172185, 0.34322151694555, 0
386, 0.72566059840941, 0.35169614982174, 0
387, 0.74196497763429, 0.36279210503111, 0
388, 0.72408877675715, 0.37134915608896, 0
389, 0.74031278273662, 0.38242612342907, 0
390, 0.72232782442028, 0.39105363020886, 0
391, 0.73865229403891, 0.40206542614948, 0
392, 0.72075005838632, 0.41053207288196, 0
393, 0.73703580876014, 0.42165518019515, 0
394, 0.71927859697377, 0.4300289747383, 0
395, 0.73540261833969, 0.4412726270282, 0
396, 0.71761759564348, 0.44966439181749, 0
397, 0.73375984972301, 0.46090532284634, 0
398, 0.71596656208852, 0.46929801750567, 0
399, 0.73213529969514, 0.48054284433602, 0
400, 0.71431975716543, 0.48893708396737, 0
401, 0.73046987946081, 0.50018158486053, 0
402, 0.71266615785301, 0.50857749010915, 0
403, 0.72882407873171, 0.51982368592883, 0
404, 0.7110143414348, 0.52821761270452, 0
405, 0.7271910660791, 0.53946783139899, 0
406, 0.70936577825296, 0.54786025607873, 0
407, 0.72552930760258, 0.55911197779787, 0
408, 0.70771236812437, 0.56750552143095, 0
409, 0.72388894750971, 0.57873648112888, 0
410, 0.70606103624811, 0.58714766480671, 0
411, 0.68987945786314, 0.57589868443263, 0
412, 0.68822689385877, 0.59553828346926, 0
413, 0.67204774013788, 0.58428762472318, 0
414, 0.67039684696313, 0.60392097791419, 0
415, 0.65422458868602, 0.5926750179051, 0
416, 0.65257452311549, 0.61230013994801, 0
417, 0.63640888483788, 0.60103765443577, 0
418, 0.72223719706217, 0.59830315114437, 0
419, 0.63476024308421, 0.62067498863417, 0
420, 0.61859989141094, 0.60939089535055, 0
421, 0.65092243375711, 0.63191810216137, 0
422, 0.63310541344984, 0.6402959484182, 0
423, 0.63806557541311, 0.5813721606502, 0
424, 0.64926648720079, 0.65153670009108, 0
425, 0.63145195781408, 0.65991492151337, 0
426, 0.69814540113302, 0.47768499431017, 0
427, 0.64761383417353, 0.67115672452268, 0
428, 0.62979726265516, 0.67953219414985, 0
429, 0.61363886540619, 0.66829266707498, 0
430, 0.74173336336248, 0.57019043624108, 0
431, 0.61198336404989, 0.68790303121224, 0
432, 0.5958284968317, 0.67666754518251, 0
433, 0.70286123456905, 0.41902157796127, 0
434, 0.74665904913978, 0.51122870284494, 0
435, 0.64596283367254, 0.69077840402661, 0
436, 0.75162723768739, 0.45219658731935, 0
437, 0.7565585386995, 0.39324774385563, 0
438, 0.66378878503187, 0.68238485750248, 0
439, 0.76150037139558, 0.33431835958912, 0
440, 0.66213531014671, 0.70203216705794, 0
441, 0.67997347285555, 0.69363891095481, 0
442, 0.59417594981364, 0.69626941589357, 0
443, 0.76645384086331, 0.27542011258226, 0
444, 0.5780289223432, 0.68504137536868, 0
445, 0.77128808742036, 0.21731202549841, 0
446, 0.70757462661702, 0.36057919016232, 0
447, 0.77769810215921, 0.13929167779983, 0
448, 0.67831640437963, 0.71329602215755, 0
449, 0.69616257733099, 0.70490342428733, 0
450, 0.66047529646438, 0.7216704817994, 0
451, 0.57637639218361, 0.70463351441251, 0
452, 0.56023668859117, 0.693405918278, 0
453, 0.56188740448777, 0.67382079211826, 0
454, 0.69450577642254, 0.7245635906025, 0
455, 0.71236239863056, 0.71616636336713, 0
456, 0.71279060804409, 0.30153101346088, 0
457, 0.54410542582869, 0.6821840058623, 0
458, 0.54575411513144, 0.66260695593855, 0
459, 0.77934050608983, 0.11982307691726, 0
460, 0.79539009663932, 0.13095968195459, 0
461, 0.55858518641505, 0.71299613803462, 0
462, 0.57471884938696, 0.72422046525374, 0
463, 0.52798095591773, 0.67096540853289, 0
464, 0.52962802438459, 0.65139759320376, 0
465, 0.71070481979646, 0.73582966036422, 0
466, 0.72856690249538, 0.72743177039081, 0
467, 0.73022341426864, 0.70776278475175, 0
468, 0.74642041280993, 0.71903032904857, 0
469, 0.74809040886781, 0.69935403513721, 0
470, 0.76427449211336, 0.71065363338438, 0
471, 0.76596067788508, 0.69094514870891, 0
472, 0.78216730315982, 0.70225480706477, 0
473, 0.78384336715157, 0.68253230903924, 0
474, 0.80007524278073, 0.69381788792387, 0
475, 0.80173518298016, 0.67411143472641, 0
476, 0.79839861061072, 0.71354837218903, 0
477, 0.81631181302008, 0.70510987765162, 0
478, 0.81465243598601, 0.72482045873824, 0
479, 0.71763267905009, 0.24270392098442, 0
480, 0.51186021338805, 0.65974995779745, 0
481, 0.5135116122125, 0.64017325454711, 0
482, 0.53127226522598, 0.63183281090284, 0
483, 0.51516288310931, 0.62060427789978, 0
484, 0.53291393309449, 0.6122762462183, 0
485, 0.51680505362788, 0.60106627992069, 0
486, 0.53455079095603, 0.59271926300007, 0
487, 0.5184449681047, 0.58152023680456, 0
488, 0.53618830909707, 0.57316694759758, 0
489, 0.50070124532826, 0.58984536994241, 0
490, 0.52008888445314, 0.56196924474129, 0
491, 0.53782980375693, 0.5536166001441, 0
492, 0.79699045468302, 0.11149581657687, 0
493, 0.81305851021796, 0.12261555613404, 0
494, 0.81146143109015, 0.14212165790768, 0
495, 0.5569296632739, 0.73258382826079, 0
496, 0.5730652854438, 0.74380951516643, 0
497, 0.52173382197321, 0.54241934537265, 0
498, 0.53948483163589, 0.53406903197182, 0
499, 0.82916541058011, 0.13375449669477, 0
500, 0.82756272336338, 0.15329714475953, 0
501, 0.83076723988293, 0.11422349894527, 0
502, 0.74474991583868, 0.73875946791565, 0
503, 0.49575782769301, 0.64847215401732, 0
504, 0.72213160390148, 0.18418218270139, 0
505, 0.83256003923975, 0.71639797569508, 0
506, 0.55556554647996, 0.54522600225864, 0
507, 0.55723322946023, 0.52570682484472, 0
508, 0.54112498255727, 0.51451595455258, 0
509, 0.55887756798971, 0.5061608250895, 0
510, 0.57499293645006, 0.51735643856432, 0
511, 0.57663377893919, 0.49779558786695, 0
512, 0.5927469279109, 0.50899744059044, 0
513, 0.59438183979234, 0.48943312902049, 0
514, 0.5782698481789, 0.47823296197334, 0
515, 0.59601678173114, 0.46986983954608, 0
516, 0.61054391932992, 0.50057216959507, 0
517, 0.78550001790079, 0.66281755900255, 0
518, 0.80339094056463, 0.65440063357166, 0
519, 0.57990634402108, 0.45867328884429, 0
520, 0.59766300497936, 0.45030737393345, 0
521, 0.55527261752839, 0.75216681280027, 0
522, 0.57140973243696, 0.76340192943302, 0
523, 0.83089742197518, 0.7361298027874, 0
524, 0.81298340453428, 0.74458856646626, 0
525, 0.51020393476448, 0.67933464637603, 0
526, 0.78099928850035, 0.10039163486713, 0
527, 0.53914225978976, 0.74094312210012, 0
528, 0.69318632154922, 0.53660967020639, 0
529, 0.503986263949, 0.55077003249343, 0
530, 0.73187803262815, 0.6880452978656, 0
531, 0.6928430154639, 0.74422674793496, 0
532, 0.61374190373053, 0.46145108324246, 0
533, 0.61540484904143, 0.44193058984543, 0
534, 0.59929535471349, 0.43074165260562, 0
535, 0.61705406687445, 0.42237617039331, 0
536, 0.8196326257631, 0.66569134670603, 0
537, 0.82128147744611, 0.64597905602634, 0
538, 0.8050426645896, 0.63469129867746, 0
539, 0.82293273072253, 0.62626718455558, 0
540, 0.83752769612075, 0.65724620436205, 0
541, 0.70902924831411, 0.75549731430483, 0
542, 0.69119069337674, 0.76387566609175, 0
543, 0.66707832924501, 0.64314100928201, 0
544, 0.80669402616399, 0.61498323743963, 0
545, 0.82458120165494, 0.60655630307717, 0
546, 0.80834520269317, 0.59527249341766, 0
547, 0.82623185936595, 0.58684583874789, 0
548, 0.80999683430117, 0.57556288362093, 0
549, 0.82788010394045, 0.56713574400196, 0
550, 0.7985622366833, 0.092082503769141, 0
551, 0.58921395534168, 0.75503490435038, 0
552, 0.58756104628532, 0.77464263813154, 0
553, 0.56974100942762, 0.78301624974501, 0
554, 0.5858906548176, 0.79426605397825, 0
555, 0.60372285647436, 0.78589015408773, 0
556, 0.81164834139449, 0.55585128937865, 0
557, 0.82953638675887, 0.54742627773035, 0
558, 0.81329731902025, 0.53614547879417, 0
559, 0.83118090894715, 0.52771738742948, 0
560, 0.81494118034694, 0.51644420449457, 0
561, 0.83282657726288, 0.50801002549192, 0
562, 0.81659405117632, 0.49673425349303, 0
563, 0.83447698431877, 0.48830217045349, 0
564, 0.81825314736626, 0.47701924474532, 0
565, 0.83612596448997, 0.468593717783, 0
566, 0.81990675494274, 0.45730839429898, 0
567, 0.83778737328002, 0.44888797475208, 0
568, 0.82156068896319, 0.43760253084706, 0
569, 0.83942868919082, 0.42918226738983, 0
570, 0.8232106946405, 0.41790248794181, 0
571, 0.84109701239529, 0.40948120172125, 0
572, 0.8248626149309, 0.39820003543309, 0
573, 0.84275058921998, 0.38978004190517, 0
574, 0.82651907070516, 0.3784960001178, 0
575, 0.8439301549356, 0.37004021100188, 0
576, 0.82809126872222, 0.3587962458985, 0
577, 0.8454886935832, 0.35033558509267, 0
578, 0.82971720584503, 0.33909345948163, 0
579, 0.8465043634198, 0.33058654268235, 0
580, 0.8312600824626, 0.31938726636688, 0
581, 0.84803036534875, 0.31088286996615, 0
582, 0.83287081461978, 0.29969976277624, 0
583, 0.85073640510215, 0.29128280101952, 0
584, 0.83469592698275, 0.28002139619916, 0
585, 0.73143591786075, 0.086619797168299, 0
586, 0.54277087562765, 0.49494579209143, 0
587, 0.50563391906087, 0.53122804459275, 0
588, 0.48789356308516, 0.53957727189001, 0
589, 0.60093013701991, 0.41118531069806, 0
590, 0.61868272518065, 0.4028175801141, 0
591, 0.84413286032769, 0.57834806943939, 0
592, 0.85258997419087, 0.27161366162685, 0
593, 0.83641305757182, 0.26034031642956, 0
594, 0.85398010225865, 0.25191136185835, 0
595, 0.83798967821695, 0.24072661665693, 0
596, 0.8408309995991, 0.6177930838753, 0
597, 0.60205384455753, 0.80551661103525, 0
598, 0.5842192783653, 0.81388213069811, 0
599, 0.61989081754575, 0.7971433769131, 0
600, 0.84532181700401, 0.14490494751962, 0
601, 0.84369855964765, 0.16448523369085, 0
602, 0.85484969692807, 0.23110350236065, 0
603, 0.85238567917826, 0.47974050876537, 0
604, 0.84908483116158, 0.51918281241835, 0
605, 0.84881299804306, 0.72769455132669, 0
606, 0.84714433189373, 0.74745642653793, 0
607, 0.63314034474165, 0.43351581988001, 0
608, 0.5490422822719, 0.62343192522252, 0
609, 0.60279280638676, 0.39212022900887, 0
610, 0.62035112379421, 0.38334019867052, 0
611, 0.70737004932323, 0.77516765836557, 0
612, 0.68952779753006, 0.78354821156621, 0
613, 0.55233204057589, 0.58425821845948, 0
614, 0.63644344017946, 0.39446453248005, 0
615, 0.63807139433648, 0.37490623353699, 0
616, 0.62194869240122, 0.36371739762513, 0
617, 0.63968892645464, 0.35533636571127, 0
618, 0.58317597795241, 0.41955681453374, 0
619, 0.59111397198487, 0.52856409226027, 0
620, 0.78880504715436, 0.62340599764655, 0
621, 0.82585272862902, 0.17248340740149, 0
622, 0.60038489439679, 0.82514271137327, 0
623, 0.58255149281648, 0.83350245377328, 0
624, 0.53748490539611, 0.76051852176115, 0
625, 0.56639939331298, 0.82225565772247, 0
626, 0.69417470260637, 0.12281439386332, 0
627, 0.78263233814922, 0.081022062037532, 0
628, 0.62155766366403, 0.77750862114246, 0
629, 0.85677840341756, 0.4206422414035, 0
630, 0.80012789115158, 0.072742402962588, 0
631, 0.4895369647392, 0.52004392658264, 0
632, 0.6246962833085, 0.3442462452626, 0
633, 0.64149771608936, 0.33579778559833, 0
634, 0.47180232213369, 0.52838800748195, 0
635, 0.47015972512212, 0.54791529414104, 0
636, 0.45407467814488, 0.53672964325058, 0
637, 0.45243110817357, 0.55624811603047, 0
638, 0.85900056541548, 0.38122597699573, 0
639, 0.52135771551326, 0.74930601262036, 0
640, 0.59748111709055, 0.65706278607626, 0
641, 0.61032075292953, 0.70750265193513, 0
642, 0.85047459304144, 0.70796785074639, 0
643, 0.65419891255989, 0.38608564126756, 0
644, 0.79540830044554, 0.54457695687263, 0
645, 0.80035996929646, 0.48545060077362, 0
646, 0.8053312414918, 0.42632149346744, 0
647, 0.81028850999837, 0.36722010244787, 0
648, 0.86673432495392, 0.71926831344159, 0
649, 0.86839856802666, 0.69953372317372, 0
650, 0.81523504601133, 0.30813118573849, 0
651, 0.86147761598822, 0.15609227920216, 0
652, 0.8630762137708, 0.13649293753205, 0
653, 0.82021778540624, 0.24908140096486, 0
654, 0.86351832686162, 0.34037482624413, 0
655, 0.8218255415284, 0.22949414594881, 0
656, 0.85929549446353, 0.1748802371922, 0
657, 0.62647325148772, 0.3249517992957, 0
658, 0.64317766799062, 0.31629079932687, 0
659, 0.65910423059645, 0.327421314891, 0
660, 0.6608502225215, 0.30768956298209, 0
661, 0.64462478448787, 0.29666269260454, 0
662, 0.66241220626446, 0.2879999144184, 0
663, 0.64663895279204, 0.27711866355088, 0
664, 0.66394167142684, 0.26865861679472, 0
665, 0.64831003736413, 0.25761280090214, 0
666, 0.66561021261566, 0.24921477000965, 0
667, 0.86801958475582, 0.30343189571344, 0
668, 0.56473048834206, 0.84185696576744, 0
669, 0.43681780678569, 0.54510450840176, 0
670, 0.43524988084526, 0.56462885375844, 0
671, 0.45087798225824, 0.57577525229178, 0
672, 0.4331639124984, 0.58411331914654, 0
673, 0.44917577893933, 0.59529303489828, 0
674, 0.43143414843325, 0.60363034449242, 0
675, 0.44750724578413, 0.61481643272888, 0
676, 0.41803487265644, 0.57402961151628, 0
677, 0.87043175055151, 0.26095184155199, 0
678, 0.70572634703257, 0.79484736624796, 0
679, 0.72356506419699, 0.78648586002721, 0
680, 0.68785132772596, 0.80324983405971, 0
681, 0.69947421766972, 0.06438557084755, 0
682, 0.52301753512632, 0.72973004087398, 0
683, 0.50524079511202, 0.73809022284784, 0
684, 0.79210755344022, 0.58399416701179, 0
685, 0.63771181822905, 0.78876500811242, 0
686, 0.63598456077682, 0.8084616822546, 0
687, 0.7743332492086, 0.17807667090725, 0
688, 0.63937692474814, 0.76912757985865, 0
689, 0.42976987728833, 0.62315403865952, 0
690, 0.44585414591137, 0.63434508990452, 0
691, 0.60889180632972, 0.3503830199277, 0
692, 0.51969064301303, 0.76891033437436, 0
693, 0.88466800151352, 0.7108385405203, 0
694, 0.59871210473967, 0.84476850641156, 0
695, 0.4734451178184, 0.50886732563253, 0
696, 0.49118488990901, 0.50049336366498, 0
697, 0.87926892944359, 0.14768655489363, 0
698, 0.88086045569562, 0.12806346748381, 0
699, 0.5485940770209, 0.83061378089046, 0
700, 0.78422883933645, 0.061721137494049, 0
701, 0.80170117154368, 0.053477025144292, 0
702, 0.81758809582809, 0.064462158241883, 0
703, 0.88299993890692, 0.73058363995803, 0
704, 0.64913419304868, 0.23721735846387, 0
705, 0.6670993176437, 0.22955593529941, 0
706, 0.68168836822039, 0.25995741641458, 0
707, 0.67696792700782, 0.31883142637357, 0
708, 0.89707559754049, 0.13926430368908, 0
709, 0.76675360573204, 0.069966873556494, 0
710, 0.6752144592253, 0.33855908036849, 0
711, 0.50689855506984, 0.71850694774435, 0
712, 0.48913476296523, 0.72686702838571, 0
713, 0.49078410027151, 0.70729810927876, 0
714, 0.55025970476957, 0.81101658611574, 0
715, 0.53246970984032, 0.81937710421584, 0
716, 0.46359053128086, 0.62600424894564, 0
717, 0.6326977292297, 0.24707170283588, 0
718, 0.67370472531076, 0.56463702158871, 0
719, 0.86467504442367, 0.11686791584181, 0
720, 0.88244837376202, 0.10845275841107, 0
721, 0.86630046904359, 0.097285039558727, 0
722, 0.88439340291565, 0.088716084743442, 0
723, 0.86797042314746, 0.077722731344839, 0
724, 0.88597982674998, 0.069081882243152, 0
725, 0.86949402134302, 0.05797332051651, 0
726, 0.88715966602189, 0.049742931285248, 0
727, 0.85004836891742, 0.086265472996488, 0
728, 0.56215679765137, 0.46703352626362, 0
729, 0.5637894688266, 0.44748519149446, 0
730, 0.54605047783369, 0.45584086597943, 0
731, 0.54768095806109, 0.43630676410794, 0
732, 0.52995080756625, 0.44465914237282, 0
733, 0.52831565085286, 0.46418741427044, 0
734, 0.62321566606024, 0.75786541214776, 0
735, 0.5635349279128, 0.65423725666466, 0
736, 0.69782085532442, 0.68518119335045, 0
737, 0.6865527535238, 0.61513462044656, 0
738, 0.61652855593191, 0.83640490937083, 0
739, 0.61394794882465, 0.85571315646408, 0
740, 0.65256443684435, 0.40565161430125, 0
741, 0.4619351412936, 0.64553563094522, 0
742, 0.44420271071347, 0.65387522422723, 0
743, 0.46027954900846, 0.66512144365471, 0
744, 0.62891193489568, 0.28634824833446, 0
745, 0.67501160417616, 0.7525387716571, 0
746, 0.67032880783626, 0.39727847462528, 0
747, 0.66867819965442, 0.41680876872846, 0
748, 0.67195843743037, 0.37770618721002, 0
749, 0.88618408383687, 0.69107971683368, 0
750, 0.87005267537865, 0.67978223803333, 0
751, 0.88781633901247, 0.67133006043851, 0
752, 0.87168439090624, 0.6600429110194, 0
753, 0.8041035889169, 0.23784032001853, 0
754, 0.8057647597348, 0.21821508417343, 0
755, 0.80240561218607, 0.25745958273094, 0
756, 0.76824187723366, 0.050896952744241, 0
757, 0.75086641414161, 0.058981962319521, 0
758, 0.75238099129432, 0.039957635753953, 0
759, 0.73493970674374, 0.048095856269967, 0
760, 0.70406576524119, 0.81453590386531, 0
761, 0.65164974184895, 0.21657566256298, 0
762, 0.66931310339829, 0.20986359022599, 0
763, 0.68493498904894, 0.22125863577455, 0
764, 0.68645751643614, 0.2018088533221, 0
765, 0.67104421833396, 0.19068457621264, 0
766, 0.68804588806648, 0.18229172264485, 0
767, 0.67286500266158, 0.17122302587737, 0
768, 0.6898098125757, 0.16281256301225, 0
769, 0.67376175572225, 0.15168155407141, 0
770, 0.82284135020645, 0.21002707801579, 0
771, 0.41368473547621, 0.61196543729225, 0
772, 0.41210264538476, 0.63138896701776, 0
773, 0.47320222784817, 0.71541355002371, 0
774, 0.43808253723511, 0.52557899120718, 0
775, 0.66155209156913, 0.10109867422367, 0
776, 0.806706600596, 0.19915853245148, 0
777, 0.5471918634932, 0.84987074086653, 0
778, 0.56309823437611, 0.86139245732362, 0
779, 0.4199254636791, 0.53457907929394, 0
780, 0.8891668636019, 0.65155715510541, 0
781, 0.87329181203857, 0.64028927497528, 0
782, 0.89076603895043, 0.63180306464676, 0
783, 0.87493233378921, 0.62053825351737, 0
784, 0.68598766769679, 0.82251746929483, 0
785, 0.70249872123589, 0.21248976035199, 0
786, 0.69292264605278, 0.33008302970923, 0
787, 0.68805738912934, 0.38881655749946, 0
788, 0.78622349237904, 0.24620673076825, 0
789, 0.47470767460847, 0.6960705286263, 0
790, 0.53413807138965, 0.79976932946408, 0
791, 0.52467369968348, 0.71013271033356, 0
792, 0.44258132425994, 0.67336116085463, 0
793, 0.5250215913215, 0.50331395218571, 0
794, 0.46689024554324, 0.586958728353, 0
795, 0.8358773974427, 0.67697010552141, 0
796, 0.51249061255716, 0.45357485239522, 0
797, 0.51062369985285, 0.47264105049759, 0
798, 0.65550487071984, 0.78046969278706, 0
799, 0.66994036261609, 0.81152544070378, 0
800, 0.66659884828606, 0.83239326542479, 0
801, 0.6410283599785, 0.74951266524545, 0
802, 0.62483282007358, 0.73827613366452, 0
803, 0.49446822275402, 0.46140507628313, 0
804, 0.81940003567205, 0.046035114754719, 0
805, 0.8350242566751, 0.05617366637484, 0
806, 0.48785583500293, 0.74642464535657, 0
807, 0.80394181470389, 0.033557257381768, 0
808, 0.90234664630203, 0.72174970639319, 0
809, 0.51706713770118, 0.80691489451232, 0
810, 0.8921071145379, 0.61202687044378, 0
811, 0.87653660534137, 0.60078661260297, 0
812, 0.89370429373382, 0.59227245117327, 0
813, 0.87817625099333, 0.58103566842157, 0
814, 0.89611718759954, 0.57257678487046, 0
815, 0.87995239977768, 0.56128154504133, 0
816, 0.47595784233719, 0.48925812465542, 0
817, 0.45773326418074, 0.70302487992101, 0
818, 0.63336493618319, 0.84748699161354, 0
819, 0.89496438486399, 0.15806052892053, 0
820, 0.53209718553097, 0.42509642604431, 0
821, 0.54930770729813, 0.41677832992334, 0
822, 0.42191814056434, 0.51437545123076, 0
823, 0.59671757039046, 0.8634188983211, 0
824, 0.51388729770477, 0.82605460537316, 0
825, 0.65701300830492, 0.16004624393893, 0
826, 0.459011498147, 0.49806743345229, 0
827, 0.89899316400183, 0.55308592696708, 0
828, 0.88184127886003, 0.54159071143479, 0
829, 0.86373348531392, 0.55006641033834, 0
830, 0.90104516397273, 0.53363054706071, 0
831, 0.88360427877408, 0.52189878004144, 0
832, 0.69910399439373, 0.83476265930727, 0
833, 0.61320504068197, 0.87571360885804, 0
834, 0.9051620210642, 0.65966001175985, 0
835, 0.91287615637426, 0.58403803103396, 0
836, 0.89822966422915, 0.74211593086738, 0
837, 0.88115835455843, 0.75037182875496, 0
838, 0.89677092570145, 0.7618814515518, 0
839, 0.87949697625563, 0.7701352375731, 0
840, 0.89498367393155, 0.78173859328477, 0
841, 0.87818287157013, 0.78936416351746, 0
842, 0.86173908781286, 0.77845132809645, 0
843, 0.86024892382124, 0.79664334302267, 0
844, 0.8438465219825, 0.78666815341628, 0
845, 0.84087880517547, 0.80694313998413, 0
846, 0.82530903362964, 0.79454806614278, 0
847, 0.82747022878652, 0.77546374073425, 0
848, 0.80954074633812, 0.78390539377571, 0
849, 0.90205108285983, 0.099677298223108, 0
850, 0.80786492880909, 0.80293765589833, 0
851, 0.79170923429325, 0.79232354619661, 0
852, 0.79339172346512, 0.77273957882124, 0
853, 0.77550068068974, 0.7811628752548, 0
854, 0.77716907793288, 0.76148861816273, 0
855, 0.75928674069868, 0.76988188515417, 0
856, 0.75726005592855, 0.78878186872725, 0
857, 0.79059427365686, 0.8118365292342, 0
858, 0.66874348929125, 0.042378573106499, 0
859, 0.87101015116977, 0.037931064571752, 0
860, 0.88850517919911, 0.030930252463062, 0
861, 0.85375495327484, 0.027910641624104, 0
862, 0.54387970784526, 0.87162118561833, 0
863, 0.56369806098558, 0.87999934368425, 0
864, 0.90924128217605, 0.6235052779877, 0
865, 0.9019437155649, 0.51374225410526, 0
866, 0.88498469818781, 0.50203127253063, 0
867, 0.90339774389253, 0.49385358219814, 0
868, 0.88664421331029, 0.48227934527549, 0
869, 0.90457991046436, 0.47384052078498, 0
870, 0.88810120926357, 0.46251347899998, 0
871, 0.65663726261975, 0.14043051222928, 0
872, 0.42628921136225, 0.66207666072243, 0
873, 0.67542891814433, 0.13203215196632, 0
874, 0.89310010979175, 0.80108633322603, 0
875, 0.90470572162948, 0.041557599444151, 0
876, 0.85287215161904, 0.047372593053533, 0
877, 0.65891747354696, 0.12085605666016, 0
878, 0.78932923381607, 0.20744272062108, 0
879, 0.42555379681622, 0.6814014648651, 0
880, 0.72006160755996, 0.82720290556671, 0
881, 0.68383770425928, 0.053038788479478, 0
882, 0.7016378193688, 0.045185040340375, 0
883, 0.69481083522276, 0.31025493246315, 0
884, 0.73679267705867, 0.029183420856464, 0
885, 0.75557851177418, 0.019269908635487, 0
886, 0.78457022757222, 0.26582865958367, 0
887, 0.80073381588174, 0.2770796539784, 0
888, 0.63750236007484, 0.15106610487156, 0
889, 0.62447981549176, 0.1876306615512, 0
890, 0.64257927498378, 0.18342823641874, 0
891, 0.63725514076775, 0.20256431225606, 0
892, 0.40079856561284, 0.51408580109967, 0
893, 0.44515562131488, 0.47352586731116, 0
894, 0.36861258960087, 0.53793461034252, 0
895, 0.38626528117272, 0.54588205209153, 0
896, 0.3716749023345, 0.55718692636457, 0
897, 0.38858290788581, 0.56575026318085, 0
898, 0.4037602869537, 0.55140183548259, 0
899, 0.47789978068681, 0.44824727362325, 0
900, 0.54917755946768, 0.35133264671168, 0
901, 0.55785305960895, 0.36905627927261, 0
902, 0.54575118940644, 0.38546873191172, 0
903, 0.56757057157691, 0.38823369784843, 0
904, 0.57943351771772, 0.36998791178374, 0
905, 0.50206030480428, 0.41622736264232, 0
906, 0.56968584955921, 0.31684728036847, 0
907, 0.58943555442146, 0.31591675070729, 0
908, 0.59853179935965, 0.2985974420518, 0
909, 0.57966354172658, 0.33447879440413, 0
910, 0.59817842925026, 0.33424104828936, 0
911, 0.5709697365323, 0.35090421023578, 0
912, 0.61073520310196, 0.22531872501035, 0
913, 0.60321280499415, 0.24413889691258, 0
914, 0.6154040849393, 0.25634358728207, 0
915, 0.60918641889239, 0.27855759932802, 0
916, 0.52610730916404, 0.3846414456433, 0
917, 0.53394852340303, 0.40420565442242, 0
918, 0.71734958028156, 0.056273463035132, 0
919, 0.57904565651725, 0.90227787558973, 0
920, 0.68971577870343, 0.36925460210631, 0
921, 0.67079506372204, 0.86305030755505, 0
922, 0.65452973463828, 0.85111002956985, 0
923, 0.63277583637808, 0.87820155613093, 0
924, 0.7494774046759, 0.84059459730382, 0
925, 0.75319727949643, 0.82464609290308, 0
926, 0.8304002316085, 0.82459192478667, 0
927, 0.92169273990671, 0.48553840139699, 0
928, 0.91214060663588, 0.15107437158735, 0
929, 0.91430592734833, 0.13339024287639, 0
930, 0.92016252017422, 0.5253816551724, 0
931, 0.63124729295775, 0.22488720054759, 0
932, 0.74913729446305, 0.078271051504346, 0
933, 0.58842023594998, 0.28119779059191, 0
934, 0.64297859686078, 0.10906422264938, 0
935, 0.64574080643188, 0.089377644481138, 0
936, 0.7190800221815, 0.036823352512728, 0
937, 0.70235664555467, 0.026739025383621, 0
938, 0.83377972936119, 0.075353763847649, 0
939, 0.70585358009336, 0.17366623799089, 0
940, 0.70734950115583, 0.15399325951526, 0
941, 0.87037282305972, 0.47096638255235, 0
942, 0.87200970801046, 0.45127424949432, 0
943, 0.88946132812579, 0.44326905131488, 0
944, 0.39423703058836, 0.61995732445236, 0
945, 0.39655351328607, 0.59985574545721, 0
946, 0.37636073113798, 0.59601273311209, 0
947, 0.39485018906509, 0.64010214218526, 0
948, 0.85153149184387, 0.06681025802231, 0
949, 0.86707132522786, 0.51055837381778, 0
950, 0.73318891921774, 0.067338814612181, 0
951, 0.74737233954129, 0.097660158990091, 0
952, 0.51816982555353, 0.78827829079252, 0
953, 0.78577022593682, 0.043329505791251, 0
954, 0.53583569063573, 0.78010393681877, 0
955, 0.50288434938179, 0.77712419828039, 0
956, 0.84848669352623, 0.10579664611874, 0
957, 0.45879505691363, 0.68440872729387, 0
958, 0.47637920807229, 0.67636616812295, 0
959, 0.92122319818326, 0.089989749169059, 0
960, 0.90391222266666, 0.079451268172042, 0
961, 0.4929310307954, 0.48089050615282, 0
962, 0.701102858586, 0.23208032152697, 0
963, 0.81459234990101, 0.1031375667104, 0
964, 0.85875969231085, 0.60922290582159, 0
965, 0.91182069845491, 0.56427661089722, 0
966, 0.92233515875922, 0.18847275466172, 0
967, 0.90517473950768, 0.19846113277831, 0
968, 0.90514941703097, 0.21828318912326, 0
969, 0.8880266324344, 0.20834914860104, 0
970, 0.88789705068582, 0.22903432923965, 0
971, 0.88829543898444, 0.18899007339641, 0
972, 0.87134873743981, 0.19916371282168, 0
973, 0.9050836584425, 0.238069171068, 0
974, 0.88796503347595, 0.24958679241617, 0
975, 0.79507339412747, 0.75303095237501, 0
976, 0.77881853148508, 0.74172094641022, 0
977, 0.55193868728652, 0.79138409933689, 0
978, 0.65146984208034, 0.819331338756, 0
979, 0.81686204851358, 0.28842010708781, 0
980, 0.79905192462558, 0.29686791276264, 0
981, 0.79740075486908, 0.31652464270829, 0
982, 0.78121044667185, 0.30526693887271, 0
983, 0.77956016093643, 0.32491123094909, 0
984, 0.79574400840495, 0.33616951872326, 0
985, 0.47966764512661, 0.63721348503297, 0
986, 0.4813186838975, 0.61768427107884, 0
987, 0.69139801445773, 0.14316507765132, 0
988, 0.85544154396673, 0.64872211199918, 0
989, 0.90518531045831, 0.17866319871747, 0
990, 0.87087460509625, 0.21820805903314, 0
991, 0.85448525675034, 0.20943531663696, 0
992, 0.60702107711303, 0.74665715837101, 0
993, 0.50895216470405, 0.49212196679405, 0
994, 0.52668301985793, 0.48376455467306, 0
995, 0.76334362120946, 0.10871899203951, 0
996, 0.81192662254519, 0.34751305302082, 0
997, 0.79414284493005, 0.35592154103113, 0
998, 0.79244011946315, 0.37561331518891, 0
999, 0.77622279039685, 0.36435423883372, 0
1000, 0.77457276799698, 0.3840125005558, 0
1001, 0.79076866122053, 0.39527628867019, 0
1002, 0.53163785546595, 0.83734827634132, 0
1003, 0.86337811725559, 0.75877952433083, 0
1004, 0.79375764860312, 0.56428530881987, 0
1005, 0.77752962024431, 0.55300420549523, 0
1006, 0.77918829446903, 0.53333813554561, 0
1007, 0.76128896677104, 0.54181139699439, 0
1008, 0.75966233690797, 0.56140652572605, 0
1009, 0.79705373771925, 0.52488543656274, 0
1010, 0.78081000951963, 0.51361770404272, 0
1011, 0.79869734576781, 0.50517203146056, 0
1012, 0.7824761762084, 0.49386860276897, 0
1013, 0.78418776846107, 0.47414858136774, 0
1014, 0.76626684910985, 0.48256926815734, 0
1015, 0.76459929576238, 0.50230277448758, 0
1016, 0.69153439640946, 0.55625158658588, 0
1017, 0.67536167927428, 0.54499836494828, 0
1018, 0.67701024331236, 0.52537152355215, 0
1019, 0.65919557983323, 0.5337531849115, 0
1020, 0.66084051591867, 0.51413994475741, 0
1021, 0.64304145731815, 0.52253294512557, 0
1022, 0.64468943478715, 0.50292884975931, 0
1023, 0.64138803328218, 0.54212749561438, 0
1024, 0.66248394868162, 0.49453748250783, 0
1025, 0.64626086237052, 0.48336412416144, 0
1026, 0.66411292688425, 0.47494164053528, 0
1027, 0.6251454463054, 0.53103947921601, 0
1028, 0.62351644449311, 0.55055987989455, 0
1029, 0.64775686950448, 0.46393337148647, 0
1030, 0.66557617211793, 0.4554579636186, 0
1031, 0.62837802070959, 0.49194858233703, 0
1032, 0.63971823263089, 0.56175721482785, 0
1033, 0.62190965818973, 0.57011372123295, 0
1034, 0.60567110722862, 0.55895781452382, 0
1035, 0.60410613304083, 0.57847115787946, 0
1036, 0.58788081969478, 0.56732397798902, 0
1037, 0.58632354759697, 0.58684719156147, 0
1038, 0.57009135914758, 0.57580361152604, 0
1039, 0.60247763578867, 0.59803893926594, 0
1040, 0.58466533667392, 0.60649386459573, 0
1041, 0.68028088954644, 0.48615403072815, 0
1042, 0.65588445211588, 0.57301586602992, 0
1043, 0.80698764755596, 0.40660744053212, 0
1044, 0.7891690223913, 0.41502508791546, 0
1045, 0.78747116488077, 0.43472230436307, 0
1046, 0.77124677097399, 0.42345926159499, 0
1047, 0.76959671891961, 0.44312642763614, 0
1048, 0.78586032528119, 0.45443561645452, 0
1049, 0.79045632086044, 0.60370132034677, 0
1050, 0.77257464157896, 0.61212446351856, 0
1051, 0.77092247614444, 0.63181794508742, 0
1052, 0.75470879461327, 0.62056327555246, 0
1053, 0.75304630890726, 0.6402265483057, 0
1054, 0.7368246730124, 0.62900958285287, 0
1055, 0.73518069851889, 0.64863738094373, 0
1056, 0.71893872396292, 0.63743358712732, 0
1057, 0.71731845664608, 0.65704178777204, 0
1058, 0.75139640691928, 0.65992763321799, 0
1059, 0.70108853501772, 0.6458752606351, 0
1060, 0.75635003889091, 0.6009216789428, 0
1061, 0.69946426457883, 0.66550631953378, 0
1062, 0.71566981338408, 0.67676264286117, 0
1063, 0.68162341543532, 0.6739551508786, 0
1064, 0.77423338153976, 0.59246215065224, 0
1065, 0.5072849901434, 0.511679714747, 0
1066, 0.5815393924514, 0.43911894840718, 0
1067, 0.58489448559167, 0.40047549360009, 0
1068, 0.56717044688882, 0.40898527917857, 0
1069, 0.50379793130747, 0.75763749702627, 0
1070, 0.48493299979898, 0.76848055912078, 0
1071, 0.7758888852961, 0.57274339178883, 0
1072, 0.60134718046345, 0.37131726323764, 0
1073, 0.6277130339829, 0.30555222903121, 0
1074, 0.92231402341225, 0.26799328263864, 0
1075, 0.90529498539958, 0.27791842937172, 0
1076, 0.90513712958567, 0.2977108318402, 0
1077, 0.88796584993776, 0.28783418248349, 0
1078, 0.88807565301391, 0.30801821132947, 0
1079, 0.87547919977335, 0.32277572864686, 0
1080, 0.88421681902624, 0.33921355345836, 0
1081, 0.87714506992678, 0.3571662639854, 0
1082, 0.89519274615412, 0.35686200381123, 0
1083, 0.88834817443702, 0.37337444040947, 0
1084, 0.90425165336046, 0.3384917352788, 0
1085, 0.92225401179632, 0.3076169617558, 0
1086, 0.90531373398004, 0.25828146317284, 0
1087, 0.50234062689011, 0.57031778838724, 0
1088, 0.51179543675532, 0.43307386199084, 0
1089, 0.80202127998703, 0.46573465897339, 0
1090, 0.86207759507198, 0.56972334431853, 0
1091, 0.92330685776226, 0.34754522941058, 0
1092, 0.69483797373445, 0.51696540192415, 0
1093, 0.56805882951268, 0.80264695532769, 0
1094, 0.47280990570707, 0.73433142491402, 0
1095, 0.92275509915023, 0.38710109371399, 0
1096, 0.90600774683221, 0.39734235641584, 0
1097, 0.90587684759466, 0.41656591452395, 0
1098, 0.89013942752544, 0.40549089096432, 0
1099, 0.92275255795752, 0.42653279418034, 0
1100, 0.61529275045479, 0.64867916081022, 0
1101, 0.59913295258854, 0.63745541228187, 0
1102, 0.58133210761416, 0.64583472350049, 0
1103, 0.5829798057648, 0.62622851913885, 0
1104, 0.60079048586551, 0.61780135965093, 0
1105, 0.5668594422983, 0.61491408995259, 0
1106, 0.54245461401035, 0.70177218132861, 0
1107, 0.52632761763986, 0.69054407939309, 0
1108, 0.50854948731772, 0.69893071400782, 0
1109, 0.69978768531073, 0.45807334579177, 0
1110, 0.70130225002955, 0.43853631145099, 0
1111, 0.68335216811619, 0.44705130130955, 0
1112, 0.61694695614231, 0.62904962752432, 0
1113, 0.494099110441, 0.66808569599123, 0
1114, 0.71465449903901, 0.28159701426556, 0
1115, 0.6966268385319, 0.2902387365157, 0
1116, 0.67856846807941, 0.29906102592226, 0
1117, 0.71607806321623, 0.26211818779426, 0
1118, 0.56051786947824, 0.48658995002208, 0
1119, 0.92301221542738, 0.76427781602901, 0
1120, 0.92232128037705, 0.22826911369854, 0
1121, 0.78715383458493, 0.64310500679109, 0
1122, 0.71892999242559, 0.22315453456751, 0
1123, 0.72021246514661, 0.2035969755865, 0
1124, 0.45601885776552, 0.5172997897089, 0
1125, 0.76093802039835, 0.7501273404862, 0
1126, 0.74307211093887, 0.75851461541978, 0
1127, 0.67166518548326, 0.79183020484324, 0
1128, 0.69796833692579, 0.27076950415196, 0
1129, 0.48624773908596, 0.5591139395557, 0
1130, 0.79672540393279, 0.73329764612525, 0
1131, 0.42816850973517, 0.64254202980328, 0
1132, 0.72398389337114, 0.16452622142022, 0
1133, 0.72510661483049, 0.14510850780402, 0
1134, 0.92207961217714, 0.70536444269179, 0
1135, 0.9223100406487, 0.72457532773563, 0
1136, 0.56544399191307, 0.42803855460754, 0
1137, 0.77377522357855, 0.79950825482805, 0
1138, 0.52338041112574, 0.52287703466188, 0
1139, 0.84546597486204, 0.76712375097079, 0
1140, 0.82921434482775, 0.75587321039035, 0
1141, 0.41535098062788, 0.59248132346769, 0
1142, 0.76761808272101, 0.6712307177952, 0
1143, 0.74974483680184, 0.67963240181137, 0
1144, 0.78049020792284, 0.72196199433387, 0
1145, 0.81129759246993, 0.76431087812414, 0
1146, 0.84693567005238, 0.12532405088771, 0
1147, 0.57968216271336, 0.66544407981848, 0
1148, 0.69649398728233, 0.49733851247793, 0
1149, 0.54079966030434, 0.72136565030658, 0
1150, 0.55361377378522, 0.77176525831585, 0
1151, 0.64429838827856, 0.71037476989619, 0
1152, 0.65581651189579, 0.36652392936505, 0
1153, 0.70437660339506, 0.60671271193, 0
1154, 0.59251170435023, 0.71585402210667, 0
1155, 0.62813349688467, 0.69912819033575, 0
1156, 0.80368295939095, 0.44600746220902, 0
1157, 0.65754318377227, 0.55337713374802, 0
1158, 0.76927285452962, 0.65152090169999, 0
1159, 0.73353137414972, 0.66834119074532, 0
1160, 0.80972929234209, 0.16137904701463, 0
1161, 0.80864514223609, 0.38689521959477, 0
1162, 0.9028454321617, 0.70162052080087, 0
1163, 0.45318749209773, 0.75429142330834, 0
1164, 0.43485376734592, 0.72074892555822, 0
1165, 0.67665790902825, 0.73294280264349, 0
1166, 0.54441578188362, 0.47539368388334, 0
1167, 0.58083008064108, 0.8529379364718, 0
1168, 0.8135472866897, 0.32780318767323, 0
1169, 0.71401951526114, 0.6964702844139, 0
1170, 0.46523795149359, 0.60648320481358, 0
1171, 0.4738751113326, 0.78668094303524, 0
1172, 0.68191835549969, 0.46655323513467, 0
1173, 0.5474010472108, 0.64302901615047, 0
1174, 0.72687976009738, 0.7471325965616, 0
1175, 0.5733419763388, 0.53689064003139, 0
1176, 0.60538573941504, 0.76626841491829, 0
1177, 0.63480463084474, 0.41400612851768, 0
1178, 0.49358945651282, 0.82315975665194, 0
1179, 0.56519160217879, 0.63461258843826, 0
1180, 0.65747923548641, 0.34696451997706, 0
1181, 0.52264361548178, 0.8724765013846, 0
1182, 0.67864467900507, 0.50576215255377, 0
1183, 0.81856942867292, 0.26872736975892, 0
1184, 0.72167286029636, 0.80636003878213, 0
1185, 0.46853498191114, 0.56744089882202, 0
1186, 0.86506399264611, 0.73899206582625, 0
1187, 0.81796973811965, 0.68539719601799, 0
1188, 0.66873287564451, 0.62352583780884, 0
1189, 0.68324253662231, 0.24057019436103, 0
1190, 0.85787610044881, 0.40095560050677, 0
1191, 0.59085989649286, 0.73543796987026, 0
1192, 0.61817790384193, 0.81678027067889, 0
1193, 0.67764245313181, 0.11231193602394, 0
1194, 0.71086707094989, 0.32141918569419, 0
1195, 0.83421362621987, 0.69668854338671, 0
1196, 0.85213579520724, 0.68824873911633, 0
1197, 0.4846100103792, 0.5786365396562, 0
1198, 0.84124472120861, 0.18277532606405, 0
1199, 0.77610280900388, 0.15876467562149, 0
1200, 0.87658962335386, 0.16562862403679, 0
1201, 0.49245391924591, 0.68768097706718, 0
1202, 0.65090608222625, 0.42514493246376, 0
1203, 0.76503974793257, 0.089338462165851, 0
1204, 0.66543745866292, 0.66275128184928, 0
1205, 0.48297189262745, 0.59816520918498, 0
1206, 0.85378658317038, 0.66850205167528, 0
1207, 0.67357246707789, 0.35813450940684, 0
1208, 0.89909977391089, 0.11992672260575, 0
1209, 0.86885618924035, 0.28288775611888, 0
1210, 0.62026129644686, 0.58973742146914, 0
1211, 0.81519388164851, 0.016280119945739, 0
1212, 0.49907005947063, 0.60938107272856, 0
1213, 0.83220155108204, 0.094810510961022, 0
1214, 0.58028703133644, 0.87057566801809, 0
1215, 0.8391708622826, 0.63752865141641, 0
1216, 0.49741478525159, 0.62892141921743, 0
1217, 0.8571251112315, 0.62903332350245, 0
1218, 0.69130100015659, 0.34957569839194, 0
1219, 0.79375125104067, 0.15039913392803, 0
1220, 0.70593420553325, 0.38022603964186, 0
1221, 0.55068184607361, 0.60385117458349, 0
1222, 0.47801974693916, 0.65679909629407, 0
1223, 0.84246771175802, 0.59808928862919, 0
1224, 0.86045083112579, 0.5895500005947, 0
1225, 0.68643230445476, 0.40819301616487, 0
1226, 0.60890044473187, 0.52006330354374, 0
1227, 0.68325390089098, 0.65433324881882, 0
1228, 0.81614197566787, 0.083764817748781, 0
1229, 0.62678312053035, 0.51151422159612, 0
1230, 0.60866410511359, 0.72706767112368, 0
1231, 0.55393430624443, 0.56471784226398, 0
1232, 0.56849226206105, 0.59536135844647, 0
1233, 0.63149295912689, 0.45294311145893, 0
1234, 0.61213836448327, 0.48094445145418, 0
1235, 0.84574478578654, 0.55867324614768, 0
1236, 0.68489679547283, 0.6347140037084, 0
1237, 0.8474273436602, 0.53892640858609, 0
1238, 0.86546042383295, 0.5303705827728, 0
1239, 0.62648186630241, 0.71871572152082, 0
1240, 0.76261526342804, 0.73037561859648, 0
1241, 0.85076867842891, 0.49943914067238, 0
1242, 0.72522865483081, 0.76683504342573, 0
1243, 0.73849932481092, 0.60940448290667, 0
1244, 0.796765625, 0.016431467037307, 0
1245, 0.65885504296611, 0.74122992291439, 0
1246, 0.86876667342409, 0.49084095308735, 0
1247, 0.74135912939017, 0.77804892881935, 0
1248, 0.79199338638252, 0.16961414841338, 0
1249, 0.64265200586584, 0.72995428479063, 0
1250, 0.73907699706121, 0.7969495783162, 0
1251, 0.8540089882325, 0.460036705668, 0
1252, 0.65719528011837, 0.76084140601122, 0
1253, 0.39998989530533, 0.58113220059478, 0
1254, 0.75804277104124, 0.58130799302782, 0
1255, 0.92153651141727, 0.05011038055075, 0
1256, 0.85559089779451, 0.44039007450399, 0
1257, 0.43815529071894, 0.50449786681995, 0
1258, 0.67334923856741, 0.77218399215943, 0
1259, 0.87261015125014, 0.43217147730127, 0
1260, 0.74334454094551, 0.55056581366332, 0
1261, 0.65371277331757, 0.80006389457619, 0
1262, 0.74500836603012, 0.53091359960345, 0
1263, 0.74012527377957, 0.5898107038986, 0
1264, 0.70272679542248, 0.62629144838357, 0
1265, 0.76303248141775, 0.52222488372125, 0
1266, 0.71547631754315, 0.075572362247037, 0
1267, 0.63397074226472, 0.82734037622706, 0
1268, 0.72060055294433, 0.61785916072413, 0
1269, 0.74831680401716, 0.49149352141326, 0
1270, 0.75005135004671, 0.47176363470835, 0
1271, 0.76806412545754, 0.46295883310437, 0
1272, 0.90529808642382, 0.31718950216373, 0
1273, 0.75319702046776, 0.43259781279668, 0
1274, 0.57169412178971, 0.55630680442055, 0
1275, 0.75498558859493, 0.4127973147257, 0
1276, 0.77304986377398, 0.40386623712487, 0
1277, 0.5894701734781, 0.54792627950086, 0
1278, 0.60725039207361, 0.53951729566803, 0
1279, 0.75811879107046, 0.37366399289586, 0
1280, 0.75993901705733, 0.35383403858609, 0
1281, 0.77804669525858, 0.34478878168933, 0
1282, 0.76305196752198, 0.31476168944586, 0
1283, 0.78274293295768, 0.28600471303756, 0
1284, 0.76463559700064, 0.29525874529199, 0
1285, 0.77265875605683, 0.19759176253867, 0
1286, 0.92215199803898, 0.46541279903349, 0
1287, 0.78784062341371, 0.22710954472966, 0
1288, 0.62996149665421, 0.47243078735675, 0
1289, 0.7693147761411, 0.23683531054247, 0
1290, 0.76798260476828, 0.25591266768519, 0
1291, 0.83837565852602, 0.22033424202793, 0
1292, 0.64929398568128, 0.4445109505433, 0
1293, 0.66707394452747, 0.43609839402882, 0
1294, 0.60951630855355, 0.31516319643473, 0
1295, 0.34550033616158, 0.56816724680389, 0
1296, 0.68495001689191, 0.42761822827399, 0
1297, 0.66450766053729, 0.014588529253401, 0
1298, 0.70429020753604, 0.39963356475661, 0
1299, 0.78844491264483, 0.83121314394644, 0
1300, 0.92404209626543, 0.80349565452295, 0
1301, 0.54097695994279, 0.9065330635938, 0
1302, 0.70925946495072, 0.34093438792304, 0
1303, 0.6802009815748, 0.27944753570294, 0
1304, 0.90382375257308, 0.060092128883829, 0
1305, 0.41079246775088, 0.65041219828822, 0
1306, 0.44113740227791, 0.69230120852997, 0
1307, 0.69961880710347, 0.2513665908722, 0
1308, 0.70397078118157, 0.19311254750993, 0
1309, 0.83665224957137, 0.037530668510426, 0
1310, 0.47750388047658, 0.46978725000544, 0
1311, 0.90387701404609, 0.6812521132607, 0
1312, 0.88800315883396, 0.26912677787429, 0
1313, 0.40119701482217, 0.53318685307963, 0
1314, 0.7091315584798, 0.13451582772007, 0
1315, 0.50142614395272, 0.7957533823263, 0
1316, 0.88907253113414, 0.81931105499349, 0
1317, 0.68601650631862, 0.034948601882934, 0
1318, 0.87594742601051, 0.39066124423249, 0
1319, 0.77061102855569, 0.03283636951472, 0
1320, 0.79028606160374, 0.18851743130517, 0
1321, 0.91052286105064, 0.014150409097313, 0
1322, 0.90560398287868, 0.45451773785158, 0
1323, 0.71156722388703, 0.84888350614517, 0
1324, 0.80799535385763, 0.1803108058957, 0
1325, 0.73738332269511, 0.81525913329262, 0
1326, 0.82381719700393, 0.19099565706282, 0
1327, 0.3730311154047, 0.57547192985433, 0
1328, 0.90544972579521, 0.37546897077721, 0
1329, 0.45526028495827, 0.72249820689754, 0
1330, 0.92198948706964, 0.66672822067839, 0
1331, 0.84954604297754, 0.82384871256892, 0
1332, 0.58930094013728, 0.35314022791616, 0
1333, 0.87099970649938, 0.24013264774333, 0
1334, 0.90623878699077, 0.4355627150228, 0
1335, 0.50156090876751, 0.83945722789402, 0
1336, 0.47076436774771, 0.75298030641116, 0
1337, 0.63266054550687, 0.26617946778341, 0
1338, 0.52899046349128, 0.85486076684372, 0
1339, 0.90318519405858, 0.6422117037496, 0
1340, 0.891921875, 0.013958511503488, 0
1341, 0.68251379003436, 0.83833253488113, 0
1342, 0.42048921543791, 0.55498808399694, 0
1343, 0.65513088346415, 0.19716828151668, 0
1344, 0.85945113832501, 0.36142285880363, 0
1345, 0.88936058693834, 0.42418519223057, 0
1346, 0.7721048833053, 0.81797949317926, 0
1347, 0.41590880905273, 0.49939661671191, 0
1348, 0.83869896573972, 0.20112924203063, 0
1349, 0.5872077123473, 0.38442691909575, 0
1350, 0.87283104602175, 0.41220416727505, 0
1351, 0.9265643909679, 0.62466409669319, 0
1352, 0.73876599546836, 0.012984772829953, 0
1353, 0.46064009522324, 0.48012968334595, 0
1354, 0.61441258244936, 0.29419751280959, 0
1355, 0.49763654366162, 0.44526296876749, 0
1356, 0.87445164590904, 0.80682484485234, 0
1357, 0.90910783739184, 0.7940024157835, 0
1358, 0.55266773469835, 0.40091797013433, 0
1359, 0.88998654309441, 0.32389318644613, 0
1360, 0.51827535478581, 0.41619541232913, 0
1361, 0.39521912602027, 0.65612776759828, 0
1362, 0.85630729930601, 0.19189824147827, 0
1363, 0.55031985969067, 0.8918425854509, 0
1364, 0.90618395099703, 0.60329644526045, 0
1365, 0.64798682069052, 0.83553240031825, 0
1366, 0.65763498630608, 0.17886328173898, 0
1367, 0.36239464657076, 0.60316593746334, 0
1368, 0.82264797359248, 0.030238359487987, 0
1369, 0.90978451464559, 0.77379088958304, 0
1370, 0.33742914820572, 0.55509118326192, 0
1371, 0.92474173799121, 0.81916873230622, 0
1372, 0.54824074083539, 0.92021659701698, 0
1373, 0.75496982249961, 0.80648439587723, 0
1374, 0.87380898036881, 0.18241691684757, 0
1375, 0.64870662363604, 0.013833098900193, 0
1376, 0.63936009412262, 0.86204693379383, 0
1377, 0.85391704231269, 0.011879309992773, 0
1378, 0.41128479741056, 0.68829227229235, 0
1379, 0.48973902681474, 0.78636144057911, 0
1380, 0.82227108390011, 0.81041949479679, 0
1381, 0.92873518520582, 0.58513624771906, 0
1382, 0.78727979149922, 0.027778024090452, 0
1383, 0.38134475403565, 0.63202105581367, 0
1384, 0.87197847482296, 0.37277015688535, 0
1385, 0.89181735504424, 0.38888418269871, 0
1386, 0.92592675590692, 0.013503705600606, 0
1387, 0.70174825294685, 0.011354730761673, 0
1388, 0.56493810911948, 0.89544135414117, 0
1389, 0.91053118656537, 0.75374408814753, 0
1390, 0.91081364913355, 0.35727055211091, 0
1391, 0.61893970532533, 0.23877763898296, 0
1392, 0.58297608587322, 0.88718452172379, 0
1393, 0.92769654563422, 0.14828079202896, 0
1394, 0.89123304495581, 0.17308377684679, 0
1395, 0.61777391237234, 0.88985770783708, 0
1396, 0.67311056364951, 0.027362729377111, 0
1397, 0.38562482031107, 0.58392744626788, 0
1398, 0.44246920115305, 0.70691272927021, 0
1399, 0.67177577298482, 0.84765158231483, 0
1400, 0.90312625252196, 0.026416362304705, 0
1401, 0.64403632573745, 0.16815725522624, 0
1402, 0.92770870320039, 0.56675685353629, 0
1403, 0.85969709645125, 0.32166538948605, 0
1404, 0.4459787380173, 0.48902868757342, 0
1405, 0.91161162572226, 0.73523609685207, 0
1406, 0.73707387764024, 0.83120762154201, 0
1407, 0.59449251683062, 0.87792139586307, 0
1408, 0.90855453170544, 0.16474331916194, 0
1409, 0.36055180614052, 0.56754326720154, 0
1410, 0.92915329610107, 0.1290345540267, 0
1411, 0.61421682163212, 0.3335280417904, 0
1412, 0.40498274362167, 0.56669114763119, 0
1413, 0.50232255897313, 0.81033402758182, 0
1414, 0.51696193322239, 0.84162690403129, 0
1415, 0.38506251183424, 0.60693519120705, 0
1416, 0.85705127183491, 0.81204297986646, 0
1417, 0.6265307712381, 0.86383244937208, 0
1418, 0.41095979616961, 0.524056796176, 0
1419, 0.45830215024631, 0.74003880294629, 0
1420, 0.83526934217005, 0, 0.082334942096126
1421, 0.77881022425454, 0, 0.015702614638775
1422, 0.70188538317662, 0, 0.082406548728514
1423, 0.87261461682338, 0, 0.017593451271486
1424, 0.73907255419789, 0, 0.018175548160309
1425, 0.815796875, 0, 0.016481545965772
1426, 0.79668010426624, 0, 0.083595129824201
1427, 0.89232536769978, 0, 0.084064923389097
1428, 0.75821297073808, 0, 0.083782700298456
1429, 0.68242466971277, 0, 0.016039679027361
1430, 0.65210280134577, 0, 0.04975809328482
1431, 0.92239719865423, 0, 0.05024190671518
1432, 0.91067812499166, 0, 0.014390144194509
1433, 0.66382187500834, 0, 0.085609855805491
1434, 0.92051814751705, 0, 0.070441184768798
1435, 0.9041572332211, 0, 0.058655328143929
1436, 0.90463008019235, 0, 0.041374074385731
1437, 0.88798981454108, 0, 0.049809806175159
1438, 0.88843413405502, 0, 0.03178026516324
1439, 0.8717906669673, 0, 0.040737620185094
1440, 0.87187132958727, 0, 0.059851784040526
1441, 0.85480329617031, 0, 0.049603204640809
1442, 0.8551140946778, 0, 0.029747302589778
1443, 0.83910222009346, 0, 0.038720322177872
1444, 0.83759437621358, 0, 0.057943551311827
1445, 0.82209405533472, 0, 0.047451052425278
1446, 0.82016326142294, 0, 0.066274653836279
1447, 0.80509697967431, 0, 0.054715443960311
1448, 0.85411446898843, 0, 0.069595078802592
1449, 0.80593075983945, 0, 0.034170059448678
1450, 0.78871452804455, 0, 0.044682511012341
1451, 0.78768793477022, 0, 0.065561862320473
1452, 0.77184413201769, 0, 0.052481874916896
1453, 0.87216084643055, 0, 0.081227899619701
1454, 0.83734072348155, 0, 0.018613161384859
1455, 0.65398185248295, 0, 0.029558815231202
1456, 0.6703427667789, 0, 0.041344671856071
1457, 0.66986991980765, 0, 0.058625925614269
1458, 0.68651018545892, 0, 0.050190193824841
1459, 0.68606586594498, 0, 0.06821973483676
1460, 0.7027093330327, 0, 0.059262379814906
1461, 0.70366472119185, 0, 0.040535395262346
1462, 0.71981259278388, 0, 0.050991301081708
1463, 0.71940558660981, 0, 0.070352033384071
1464, 0.73539910340344, 0, 0.061279709362645
1465, 0.73718558369743, 0, 0.040853541180186
1466, 0.72155644516038, 0, 0.03067794796499
1467, 0.75411202337265, 0, 0.033084889429876
1468, 0.70326757555585, 0, 0.019567797657309
1469, 0.73711185237263, 0, 0.081424246268608
1470, 0.75335977625775, 0, 0.052841623570311
1471, 0.79703513319221, 0, 0.015908172217173
1472, 0.77771141829576, 0, 0.083697805448331
1473, 0.81555617157122, 0, 0.083984628823121
1474, 0.9205868875139, 0, 0.02956333033598
1475, 0.6539131124861, 0, 0.07043666966402
1476, 0.77175712818478, 0, 0.033165821420023
1477, 0.66429535317449, 0, 0.014439399076615
1478, 0.9102463197276, 0, 0.085578034659461
1479, 0.75946328061308, 0, 0.015529411055736
1480, 0.76776042097241, 0, 0.068911483907132
1481, 0.89240632454729, 0, 0.014695953424193
1482, 0.68209367545271, 0, 0.085304046575807
1483, 0.68732586626164, 0, 0.032786037400254
1484, 0.88775123061042, 0, 0.067524265666601
1485, 0.72103556498282, 0, 0.013684258756521
1486, 0.82456997491349, 0, 0.030618610642664
1487, 0.74993196716624, 0, 0.069380230558546
1488, 0.85455763699655, 0, 0.013190783049225
1489, 0.71993681443181, 0, 0.086836565676239
1490, 0.80552667438878, 0, 0.07069248224848
1491, 0.85385459394129, 0, 0.086985288218615
1492, 0.78822182975205, 0, 0.028998765378503
1493, 0.92556927560742, 0, 0.086046268845121
1494, 0.64893289395224, 0, 0.013954638783788
1495, 0.64860855190555, 0, 0.086419115332183
1496, 0.92589144809445, 0, 0.013580884667817
1497, 0.76276826495822, 0, 0.042893552334277
1498, 0.90334711026004, 0, 0.026360753500731
1499, 0.67115288973996, 0, 0.073639246499269
1500, 0.67167410168215, 0, 0.026833720518301
1501, 0.90299965975519, 0, 0.073252747325577
1502, 0.9395, 0.66470077114365, 0.017628731332044
1503, 0.9395, 0.54591542029925, 0.017191876584057
1504, 0.9395, 0.60546982939131, 0.017191879397915
1505, 0.9395, 0.72690100680851, 0.018872535115036
1506, 0.9395, 0.76446620810048, 0.081775693164094
1507, 0.9395, 0.36725219222983, 0.017191877192788
1508, 0.9395, 0.42680660178061, 0.017191877192787
1509, 0.9395, 0.48636101133139, 0.082808122807213
1510, 0.9395, 0.14772681393723, 0.082858845362506
1511, 0.9395, 0.10664518848454, 0.080656308158798
1512, 0.9395, 0.24814337312826, 0.082808122807213
1513, 0.9395, 0.18858896357748, 0.017191877192796
1514, 0.9395, 0.28784631282878, 0.017191877192792
1515, 0.9395, 0.32754925252931, 0.017191877192789
1516, 0.9395, 0.069439563657422, 0.017390068886759
1517, 0.9395, 0.64759262745505, 0.082128624773234
1518, 0.9395, 0.68372609577609, 0.081722763068592
1519, 0.9395, 0.78579769278039, 0.017869194505516
1520, 0.9395, 0.52606395103192, 0.082808122807213
1521, 0.9395, 0.56576689073244, 0.082808122807213
1522, 0.9395, 0.44650342827465, 0.08346935142054
1523, 0.9395, 0.50621248118166, 0.017191877192787
1524, 0.9395, 0.38710366208009, 0.082808122807213
1525, 0.9395, 0.34740072237957, 0.082808122807213
1526, 0.9395, 0.46650954148113, 0.017191877192787
1527, 0.9395, 0.228291903278, 0.017191877192792
1528, 0.9395, 0.12904955980099, 0.016637307355343
1529, 0.9395, 0.30754313932282, 0.083469351420542
1530, 0.9395, 0.20828579007152, 0.083469351420544
1531, 0.9395, 0.048209979123703, 0.081652790797073
1532, 0.9395, 0.60546983043296, 0.082808122807213
1533, 0.9395, 0.72767082106013, 0.081439518893232
1534, 0.9395, 0.81655164881077, 0.049821111143272
1535, 0.9395, 0.017210084900187, 0.050178888856728
1536, 0.9395, 0.8021032931958, 0.081895054976526
1537, 0.9395, 0.031658440515157, 0.018104945023474
1538, 0.9395, 0.016744985376385, 0.069903517828784
1539, 0.9395, 0.036150203981335, 0.063116067522062
1540, 0.9395, 0.03450924123578, 0.040159615585677
1541, 0.9395, 0.05183380803292, 0.050037033440435
1542, 0.9395, 0.051255441500873, 0.029961127359676
1543, 0.9395, 0.069173482260439, 0.039225662417294
1544, 0.9395, 0.08801152375637, 0.029046414754117
1545, 0.9395, 0.087064053539283, 0.04900109309567
1546, 0.9395, 0.10442451763202, 0.038643191244257
1547, 0.9395, 0.10433483074285, 0.058664194058341
1548, 0.9395, 0.12142065509002, 0.047909459672808
1549, 0.9395, 0.08768857787138, 0.068871218044718
1550, 0.9395, 0.070074040363349, 0.058949884232734
1551, 0.9395, 0.069713254600446, 0.080296121211213
1552, 0.9395, 0.81701674833457, 0.030096482171216
1553, 0.9395, 0.79764662586084, 0.036815642114013
1554, 0.9395, 0.79915744570791, 0.059936450578217
1555, 0.9395, 0.78192792567804, 0.049962966559565
1556, 0.9395, 0.78275023740214, 0.069990938913858
1557, 0.9395, 0.76481470176536, 0.060255526220838
1558, 0.9395, 0.76434934739865, 0.040139829328743
1559, 0.9395, 0.74770782496247, 0.050035237054978
1560, 0.9395, 0.74667214500205, 0.030007374664568
1561, 0.9395, 0.7297303411076, 0.040689292399248
1562, 0.9395, 0.71084671374286, 0.033348971766432
1563, 0.9395, 0.71401218945593, 0.052783352040355
1564, 0.9395, 0.69574978523619, 0.046521220720191
1565, 0.9395, 0.69411576835923, 0.029977487127188
1566, 0.9395, 0.67620830791832, 0.036395658407429
1567, 0.9395, 0.68057933979165, 0.059553932710641
1568, 0.9395, 0.66206679067185, 0.052583912133392
1569, 0.9395, 0.6652940901833, 0.07163979558537
1570, 0.9395, 0.69915626346522, 0.065762433330177
1571, 0.9395, 0.74700444101255, 0.069920874006967
1572, 0.9395, 0.62532130028322, 0.017191877192787
1573, 0.9395, 0.61539556657335, 0.034383765111283
1574, 0.9395, 0.59554409025741, 0.034383758614825
1575, 0.9395, 0.63500669630189, 0.034211384379706
1576, 0.9395, 0.62521911965805, 0.051323218777714
1577, 0.9395, 0.60546982209973, 0.051575643117756
1578, 0.9395, 0.58561834999211, 0.051575635287244
1579, 0.9395, 0.5756926200567, 0.034383754984021
1580, 0.9395, 0.56576687981206, 0.051575630465472
1581, 0.9395, 0.52606395093476, 0.017191877091332
1582, 0.9395, 0.51613821609059, 0.034383754368665
1583, 0.9395, 0.49628674625383, 0.034383754382755
1584, 0.9395, 0.50621248118165, 0.051575631578361
1585, 0.9395, 0.48636101133139, 0.05157563157836
1586, 0.9395, 0.52606395103192, 0.051575631578361
1587, 0.9395, 0.53598968513612, 0.03438375388397
1588, 0.9395, 0.44665807163087, 0.017191877192787
1589, 0.9395, 0.43673233670574, 0.034383754385574
1590, 0.9395, 0.41688086685548, 0.034383754385574
1591, 0.9395, 0.4265901010819, 0.051450634841678
1592, 0.9395, 0.40691904848057, 0.051291897782753
1593, 0.9395, 0.44640548748237, 0.05116719678917
1594, 0.9395, 0.39702338309692, 0.03433646541964
1595, 0.9395, 0.3871018356988, 0.051424476661276
1596, 0.9395, 0.41640576809997, 0.067648965963525
1597, 0.9395, 0.37717662044003, 0.034350680405072
1598, 0.9395, 0.36725205630139, 0.051430922253503
1599, 0.9395, 0.35732621686414, 0.034354123834682
1600, 0.9395, 0.34740070605091, 0.051431351285758
1601, 0.9395, 0.33747494465957, 0.034354769244994
1602, 0.9395, 0.32754924996425, 0.051431397900129
1603, 0.9395, 0.31762351004419, 0.034354884582442
1604, 0.9395, 0.30748128029282, 0.051159178998396
1605, 0.9395, 0.29773596276288, 0.034309533988395
1606, 0.9395, 0.28758771423386, 0.051368856012161
1607, 0.9395, 0.27787146397266, 0.034336921725017
1608, 0.9395, 0.26794355755754, 0.051270462534414
1609, 0.9395, 0.25805237482806, 0.03432508743483
1610, 0.9395, 0.24814042215964, 0.051423053068983
1611, 0.9395, 0.27743592917024, 0.067631763617219
1612, 0.9395, 0.23821435750414, 0.034348546808893
1613, 0.9395, 0.22829163291897, 0.051430767925956
1614, 0.9395, 0.21836557650987, 0.034353742514066
1615, 0.9395, 0.20822378902869, 0.051158883657975
1616, 0.9395, 0.19847849246227, 0.034309294420266
1617, 0.9395, 0.18833032113887, 0.051368766860741
1618, 0.9395, 0.17861408723919, 0.034336866938431
1619, 0.9395, 0.16868619641859, 0.051270438544751
1620, 0.9395, 0.15879501901512, 0.034325074305461
1621, 0.9395, 0.17817857063038, 0.067631744760375
1622, 0.9395, 0.14888602387696, 0.051575631578383
1623, 0.9395, 0.26798386845247, 0.017174293924238
1624, 0.9395, 0.1687265135272, 0.017174282604916
1625, 0.9395, 0.4069541296123, 0.017183995698465
1626, 0.9395, 0.62560937853579, 0.083102385152986
1627, 0.9395, 0.50621248118165, 0.082808122807213
1628, 0.9395, 0.54591542088218, 0.082808122807212
1629, 0.9395, 0.34740072237957, 0.017191877192787
1630, 0.9395, 0.12721574930543, 0.082612674808304
1631, 0.9395, 0.22827875333274, 0.083132314284259
1632, 0.9395, 0.32753610258405, 0.083132314284259
1633, 0.9395, 0.10691174823082, 0.018330186082764
1634, 0.9395, 0.30769778267905, 0.017191877192787
1635, 0.9395, 0.38710227492321, 0.017177169785994
1636, 0.9395, 0.46649639153588, 0.083132314284258
1637, 0.9395, 0.20844043342774, 0.017191877192787
1638, 0.9395, 0.36725219222983, 0.082808122807213
1639, 0.9395, 0.5856183605827, 0.082808122807213
1640, 0.9395, 0.48636101133094, 0.017191877192317
1641, 0.9395, 0.76426366712937, 0.019280342046312
1642, 0.9395, 0.47643527640574, 0.034383754385025
1643, 0.9395, 0.58561835916687, 0.017191877835616
1644, 0.9395, 0.45654170919783, 0.034315681920617
1645, 0.9395, 0.14888390484151, 0.017086736441884
1646, 0.9395, 0.24813820838653, 0.017173300893459
1647, 0.9395, 0.46648448352984, 0.051267147699838
1648, 0.9395, 0.56576688941134, 0.017191876561107
1649, 0.9395, 0.55584115186677, 0.034383753164708
1650, 0.9395, 0.54591541542199, 0.05157562842592
1651, 0.9395, 0.64517277013348, 0.017191877192786
1652, 0.9395, 0.13770566939533, 0.033098424119126
1653, 0.9395, 0.13330403350577, 0.063596743406316
1654, 0.9395, 0.6546574375543, 0.034618040140687
1655, 0.9395, 0.016314089587886, 0.030498410719859
1656, 0.9395, 0.81743180299519, 0.069517600307457
1657, 0.9395, 0.80415064354637, 0.016595406314662
1658, 0.9395, 0.029951819270237, 0.083343239944409
1659, 0.9395, 0.73076475631428, 0.060403550857331
1660, 0.9395, 0.40687594880443, 0.083672120058183
1661, 0.9395, 0.43654919887925, 0.067552259175313
1662, 0.9395, 0.26791406818962, 0.083669253000467
1663, 0.9395, 0.29758631557545, 0.067534426014215
1664, 0.9395, 0.16817065110541, 0.083643532077001
1665, 0.9395, 0.19832893379997, 0.067534358789436
1666, 0.9395, 0.47642890842351, 0.067194495125874
1667, 0.9395, 0.49628568492606, 0.067192313514968
1668, 0.9395, 0.45647798302092, 0.067297127415832
1669, 0.9395, 0.37717792715496, 0.067191877192788
1670, 0.9395, 0.3573264573047, 0.067191877192788
1671, 0.9395, 0.33747498745444, 0.067191877192789
1672, 0.9395, 0.31752851253231, 0.067319757635055
1673, 0.9395, 0.23821490965765, 0.067196039668899
1674, 0.9395, 0.21827063480159, 0.067320285957845
1675, 0.9395, 0.51613803921838, 0.067191949939656
1676, 0.9395, 0.53598965556561, 0.067191889277536
1677, 0.9395, 0.55584114801197, 0.067191879366048
1678, 0.9395, 0.57569262438612, 0.067191881626212
1679, 0.9395, 0.59554409463166, 0.067191884995437
1680, 0.9395, 0.61542654676109, 0.067198858997181
1681, 0.9395, 0.63524703520835, 0.06719189913198
1682, 0.9395, 0.42665792460325, 0.083723782769594
1683, 0.9395, 0.39702939700522, 0.067190102734182
1684, 0.9395, 0.28769534631928, 0.083717465675407
1685, 0.9395, 0.2580691080534, 0.067190102734188
1686, 0.9395, 0.1883569787937, 0.083713164507893
1687, 0.9395, 0.15813843708966, 0.066972102676724
1688, 0.9395, 0.64373072714622, 0.050743075824731
1689, 0.9395, 0.70602508841953, 0.082955690451105
1690, 0.9395, 0.70609747111475, 0.015618773146374
1691, 0.9395, 0.089331614326175, 0.085974709478487
1692, 0.9395, 0.11970140823484, 0.030961605599435
1693, 0.9395, 0.74473473787806, 0.086447777693626
1694, 0.9395, 0.74443011938479, 0.0135702596009
1695, 0.9395, 0.050322158984951, 0.013091228253982
1696, 0.9395, 0.78351717137381, 0.086732337410896
1697, 0.9395, 0.77915023322664, 0.032974206714724
1698, 0.9395, 0.055196257220351, 0.066810379440703
1699, 0.9395, 0.11781870305273, 0.068075741910413
1700, 0.9395, 0.71591807572178, 0.068758218121556
1701, 0.9395, 0.088605212859393, 0.012953333944728
1702, 0.9395, 0.65078625413295, 0.064857461489741
1703, 0.9395, 0.68305230383834, 0.015759403667379
1704, 0.9395, 0.66502423998374, 0.087779376192449
1705, 0.9395, 0.81913512211567, 0.014665965574376
1706, 0.9395, 0.014626611595293, 0.085334034425624
1707, 0.9395, 0.014506770876193, 0.014547014853274
1708, 0.9395, 0.81925496283477, 0.085452985146728
1709, 0.69471055388152, 0.87246349771076, 0.018231074957891
1710, 0.6230458545117, 0.89959489799336, 0.016106364583077
1711, 0.83297144132269, 0.84094505692855, 0.018971532104901
1712, 0.75329935272887, 0.85591773201275, 0.017133371368507
1713, 0.79195777013057, 0.84759928084744, 0.015700160336897
1714, 0.8704613028183, 0.83677080505241, 0.01839725666392
1715, 0.65888643492705, 0.88503651378304, 0.083535934751525
1716, 0.55773257274139, 0.93163548242056, 0.049793830437884
1717, 0.71508248988878, 0.866157909548, 0.082866645175357
1718, 0.60409967963011, 0.90813109530388, 0.082391489405602
1719, 0.77258728414753, 0.85151538645127, 0.082866593823081
1720, 0.81142200013347, 0.8441664164282, 0.083542974417413
1721, 0.89173056516302, 0.83520092096022, 0.082011228122962
1722, 0.85002529310335, 0.83882243558728, 0.083175642169742
1723, 0.6609354041653, 0.88426508772428, 0.017876194111868
1724, 0.92230981435997, 0.83394795750531, 0.050208375253195
1725, 0.58484515108858, 0.9174292266055, 0.017988409525543
1726, 0.90804016144628, 0.83438562197712, 0.01817026418319
1727, 0.5703090258528, 0.92487987559656, 0.081834621997262
1728, 0.92271203310512, 0.83393934390494, 0.069891414041646
1729, 0.90350771389641, 0.83457843923514, 0.063367323437576
1730, 0.90492280740888, 0.83451545163042, 0.040092622374476
1731, 0.88776031133982, 0.83545035805553, 0.050053974826311
1732, 0.88861965752702, 0.83539467368773, 0.030170116329483
1733, 0.87073837962963, 0.83674665506664, 0.039787335931333
1734, 0.87065112147187, 0.83675424992259, 0.059964720523706
1735, 0.85467617924807, 0.83830852252981, 0.050705517624364
1736, 0.85271205755008, 0.83852216766567, 0.03040047350366
1737, 0.83654958227953, 0.84046858332696, 0.040190139991966
1738, 0.81762320004859, 0.84317736603513, 0.033759997332321
1739, 0.82081507870185, 0.84268787520148, 0.052425929804286
1740, 0.80241850649933, 0.84569221400102, 0.045591566738091
1741, 0.55737840083191, 0.93182997325619, 0.030108765659085
1742, 0.574337343673, 0.92277718141459, 0.036636208781064
1743, 0.573078292049, 0.92343122716676, 0.059920435132028
1744, 0.58842327902679, 0.91565272168912, 0.049953737594426
1745, 0.58766336599833, 0.91602813426955, 0.069974302264167
1746, 0.60395773595392, 0.90819731445575, 0.060844367286433
1747, 0.62100019986732, 0.90048795369723, 0.070906941876907
1748, 0.61989826032047, 0.9009718618321, 0.051673675040813
1749, 0.63618241978135, 0.8940218715033, 0.061677723341635
1750, 0.6364900224273, 0.8938947018017, 0.042031216256652
1751, 0.65304184604465, 0.88727256079524, 0.051409756071748
1752, 0.60402866118509, 0.9081642223582, 0.040576036487314
1753, 0.6407465221999, 0.89215044315534, 0.015596114146395
1754, 0.73412708771116, 0.86079959055058, 0.082866631098239
1755, 0.72458809498676, 0.86341939193906, 0.065733232312555
1756, 0.705611747558, 0.86901471896601, 0.06573323367731
1757, 0.74369800587893, 0.85829890684726, 0.065733270561044
1758, 0.73412708771115, 0.86079959055058, 0.048599885894478
1759, 0.75329935272896, 0.85591773201273, 0.048599885894504
1760, 0.75329934933875, 0.85591773283111, 0.082866633589135
1761, 0.76292955673546, 0.8536564541495, 0.065733232044263
1762, 0.77198405828238, 0.85164542439916, 0.049502645118955
1763, 0.69617737625571, 0.87198936510862, 0.082866633318374
1764, 0.68678076864339, 0.87508140951834, 0.065733241751107
1765, 0.69707783648312, 0.87169986024473, 0.04937407183116
1766, 0.67720286899444, 0.87836757225271, 0.047497170383293
1767, 0.67743105096608, 0.878287691469, 0.082966468359034
1768, 0.66724297719019, 0.88193069079732, 0.066869026193192
1769, 0.66298541673583, 0.88349971851911, 0.036041821833571
1770, 0.6782619853721, 0.8779974614323, 0.028287006435459
1771, 0.78149806399389, 0.84965152401826, 0.066264410752861
1772, 0.79194744532756, 0.84760123476951, 0.082925418808989
1773, 0.80235730524086, 0.84570295071751, 0.064376484626841
1774, 0.83096568847404, 0.84121939819614, 0.083690512547745
1775, 0.83938777882936, 0.84010241491185, 0.064342099271642
1776, 0.77258699048559, 0.85151544963682, 0.016379451152212
1777, 0.7150824898888, 0.86615790954799, 0.017133371368507
1778, 0.63846818677262, 0.89308049081175, 0.081682275495995
1779, 0.87078309779022, 0.83674276660727, 0.079832135765983
1780, 0.73412708771115, 0.86079959055058, 0.017133371368507
1781, 0.71511762653095, 0.86614755011142, 0.04877034092607
1782, 0.60409572496964, 0.90813293975861, 0.020430789700984
1783, 0.92319287827577, 0.83392931424162, 0.030513078283033
1784, 0.55695770710207, 0.93206129919988, 0.069490370228015
1785, 0.90990321383031, 0.83431389163783, 0.083379264981893
1786, 0.56865946613164, 0.92574940421116, 0.016621041683171
1787, 0.74369802498269, 0.85829890198285, 0.032866637290478
1788, 0.76292963890566, 0.85365643539468, 0.032866507801977
1789, 0.70635118065406, 0.86878702876847, 0.033647030986092
1790, 0.72458822131277, 0.86341935639644, 0.03286674946027
1791, 0.78435887185965, 0.84907571458742, 0.03444652693232
1792, 0.81129237796651, 0.84418762760572, 0.01613200876955
1793, 0.61864452696543, 0.90152485616941, 0.033984526974398
1794, 0.85065618821203, 0.83875109516067, 0.013661805884509
1795, 0.820984841903, 0.84266221338148, 0.069627389493755
1796, 0.89007063920071, 0.83530277752006, 0.013575731498032
1797, 0.65007013222639, 0.88842981666856, 0.069094216426353
1798, 0.58689825978193, 0.91640713339161, 0.086746178170004
1799, 0.88567860020959, 0.83558913286854, 0.066759907188331
1800, 0.59099548654191, 0.91438947720259, 0.033160498067553
1801, 0.67742356433858, 0.87829031111127, 0.012931730936776
1802, 0.62218567870229, 0.89996958367813, 0.087149321740489
1803, 0.85678673233541, 0.83808446252771, 0.067826421810904
1804, 0.80155741565131, 0.84584373198384, 0.029201564741589
1805, 0.78785683319934, 0.84838651908241, 0.051023188902612
1806, 0.64825247239898, 0.88914444786386, 0.031374971551096
1807, 0.92614582764928, 0.83387411338857, 0.086653536101254
1808, 0.55437173740716, 0.93349053846557, 0.013346542258331
1809, 0.92505495658945, 0.83389322493281, 0.014504634617156
1810, 0.55532552016389, 0.93296192884086, 0.085495365382664
1811, 0.63127698915603, 0.89607035959179, 0.028257755204478
1812, 0.69086086432671, 0.87372286264216, 0.035315295387651
1813, 0.36226101564112, 0.62745448469193, 0.016238295329927
1814, 0.38117109483017, 0.6602077026225, 0.08369297015037
1815, 0.44977439489811, 0.77903210390707, 0.016469629518019
1816, 0.42037608685529, 0.72811274072035, 0.016591172872935
1817, 0.48982696600821, 0.84840519204354, 0.018873780404659
1818, 0.40068217417776, 0.69400188336305, 0.016742691331607
1819, 0.46929891304348, 0.81284956132815, 0.016962801930647
1820, 0.50845284795595, 0.8806661659128, 0.018393870029988
1821, 0.32609689805508, 0.56481639562201, 0.049803196777033
1822, 0.35179877498194, 0.60933335230921, 0.082363995663707
1823, 0.41053804347826, 0.71107274974427, 0.083037198069353
1824, 0.43991847826087, 0.76196115553621, 0.083037198069353
1825, 0.47909239130435, 0.8298123632588, 0.083037198069353
1826, 0.45950543478261, 0.79588675939751, 0.0841209585993
1827, 0.51903709756385, 0.89899862399367, 0.082231434533054
1828, 0.49836094265498, 0.86318647318634, 0.083404860691857
1829, 0.38130034052688, 0.66043156273588, 0.016797989408281
1830, 0.53415926463247, 0.92519098567706, 0.05020596490112
1831, 0.34122513123341, 0.59101926411562, 0.017769479402212
1832, 0.52707914068244, 0.91292785127173, 0.01808771782582
1833, 0.33317598393778, 0.57707773204198, 0.081930067670941
1834, 0.53451138583065, 0.92580087748273, 0.069882803483855
1835, 0.52483782457052, 0.90904577789005, 0.063279142434344
1836, 0.52560547497627, 0.91037538739526, 0.04035430988103
1837, 0.51694843896336, 0.89538096117795, 0.050103966015741
1838, 0.51746321433049, 0.89627257826831, 0.030161672205834
1839, 0.50852854102229, 0.88079727014947, 0.039876461439058
1840, 0.50852840820127, 0.88079704009673, 0.059818136606114
1841, 0.49915936469729, 0.8645693807295, 0.051289323790524
1842, 0.49951252094999, 0.86518106530219, 0.030459558571029
1843, 0.49144477123443, 0.8512073128921, 0.040365764595596
1844, 0.4820335833354, 0.83490665729141, 0.03333936990745
1845, 0.48325002930049, 0.8370136035076, 0.051688225003086
1846, 0.47447494639855, 0.82181471408081, 0.045392264645278
1847, 0.47443627562143, 0.82174773433006, 0.065767545006601
1848, 0.46717776782562, 0.80917563004059, 0.053908799705696
1849, 0.46525063551482, 0.80583773896538, 0.034874621390104
1850, 0.45830020003152, 0.79379923157358, 0.050640050062559
1851, 0.32572493014166, 0.56417212829717, 0.030115730435696
1852, 0.33542869677377, 0.58097954512878, 0.036735901678484
1853, 0.33466124139141, 0.57965027341399, 0.059686157593403
1854, 0.34334421556383, 0.59468962584143, 0.049932279560569
1855, 0.34280643596486, 0.59375816425274, 0.069998959915949
1856, 0.35186747509433, 0.60945234439435, 0.060088820119649
1857, 0.36110917690285, 0.62545944147512, 0.071219317573065
1858, 0.36095114617747, 0.62518572422961, 0.051738068645117
1859, 0.36927438641358, 0.63960199920215, 0.062545743714444
1860, 0.36950752291714, 0.6400058034714, 0.043420780200667
1861, 0.37705894551404, 0.65308525107867, 0.053727508970787
1862, 0.35186746296404, 0.60945232338407, 0.04011372780156
1863, 0.45965725144563, 0.7961497135713, 0.016765662186619
1864, 0.50866298519728, 0.88103013429134, 0.080078022968768
1865, 0.4693390169514, 0.81291902333425, 0.084053977159786
1866, 0.40074456521739, 0.69410994781362, 0.083037198069353
1867, 0.40564130434783, 0.70259134877894, 0.066074396138705
1868, 0.4154347826087, 0.71955415070959, 0.066074396138705
1869, 0.41053804347826, 0.71107274974427, 0.049111594208058
1870, 0.40070000018908, 0.69403275892035, 0.049483223055708
1871, 0.42039391290175, 0.72814361633852, 0.049331704657229
1872, 0.42523865939667, 0.73653496341751, 0.066111081213567
1873, 0.43019952277758, 0.74512743084265, 0.049226424825727
1874, 0.43503589268121, 0.75350426923994, 0.066099648754127
1875, 0.43976060311737, 0.76168770776641, 0.049482468648823
1876, 0.43513267660844, 0.75367190391925, 0.03282201264503
1877, 0.37031362250891, 0.64140200892032, 0.082116962842297
1878, 0.41053507249102, 0.71106760384341, 0.016568043390541
1879, 0.44971195652174, 0.77892395746686, 0.083414291163499
1880, 0.44461856426881, 0.77010194330191, 0.066599148735914
1881, 0.4888328020367, 0.84668324953382, 0.083588703654704
1882, 0.49370853995049, 0.85512827532489, 0.068276884261266
1883, 0.43012909201298, 0.74500544117995, 0.083047521017733
1884, 0.39090208604883, 0.67706227382123, 0.01682660511003
1885, 0.38663377048943, 0.66966933440961, 0.032905560446365
1886, 0.42033152173913, 0.72803555167492, 0.083037198069353
1887, 0.39095333464561, 0.67715103899467, 0.083146493416189
1888, 0.38519749191545, 0.66718162694566, 0.064861298667807
1889, 0.37175869974285, 0.64390495611036, 0.015867791732975
1890, 0.39584782608696, 0.6856285468483, 0.066074396138706
1891, 0.35189218916196, 0.60949515041515, 0.020226580036342
1892, 0.42527699695862, 0.73660136602265, 0.032847098564813
1893, 0.43994741922874, 0.76201128276298, 0.016400541248946
1894, 0.39591840370157, 0.68575079086269, 0.033165932494642
1895, 0.40563474610773, 0.70257998957389, 0.033018113758318
1896, 0.41545914313211, 0.71959634437385, 0.032911287908649
1897, 0.44464992481406, 0.77015626135963, 0.032961610657968
1898, 0.43016386327518, 0.74506566677273, 0.016443470888621
1899, 0.39139264356417, 0.67791194436184, 0.048978131203704
1900, 0.53466012338278, 0.92605849848002, 0.030504736876147
1901, 0.32559454389646, 0.56394629269588, 0.069506498898744
1902, 0.52797013661535, 0.91447110149687, 0.083490953450994
1903, 0.33212640029681, 0.57525979984903, 0.016527854467371
1904, 0.45450292006319, 0.78722214973786, 0.067381679544703
1905, 0.45449440927212, 0.78720740861532, 0.032992544748261
1906, 0.47897727148903, 0.82961296988972, 0.016018444177227
1907, 0.3767804241514, 0.65260283792758, 0.03419024915866
1908, 0.44903903023751, 0.77775841495282, 0.050155791670839
1909, 0.36013816428417, 0.62377759828477, 0.034270431185723
1910, 0.48433100358554, 0.83888590589098, 0.068550888041043
1911, 0.49903020611327, 0.86434567149974, 0.013545441801135
1912, 0.51790556233291, 0.89703874748312, 0.013328652012328
1913, 0.34234971723778, 0.59296710421268, 0.086858604650119
1914, 0.51610313985707, 0.89391686017827, 0.066811357076624
1915, 0.34440049116248, 0.59651914884508, 0.033107197657737
1916, 0.37652844484668, 0.65216639696935, 0.06956607737076
1917, 0.36157065217391, 0.62625874009103, 0.087351679833394
1918, 0.50166565592986, 0.86891040448288, 0.068280371873731
1919, 0.47424309638165, 0.82141313807179, 0.02904327507505
1920, 0.53562790588447, 0.92773474694362, 0.085781638388193
1921, 0.32480088544583, 0.56257163593554, 0.014708990935158
1922, 0.46421076063544, 0.80403662284077, 0.070030573964334
1923, 0.53561686000553, 0.92771561492008, 0.01438042864891
1924, 0.32463313999447, 0.56228109229105, 0.085619571351089
1925, 0.36739101132933, 0.63633989786652, 0.029120183358265
1926, 0.38389028438269, 0.66491747708288, 0.047262324063331
1927, 0.49029268717247, 0.8492118447622, 0.054793626418348
1928, 0.39105114485177, 0.50030390974898, 0.015884235977567
1929, 0.53467609824405, 0.34255871024762, 0.016936848387767
1930, 0.46262722525553, 0.43497247091324, 0.083063190566059
1931, 0.60801080475677, 0.18316075261644, 0.083063187505774
1932, 0.42230165210417, 0.47422179898238, 0.018109151776525
1933, 0.48852707157413, 0.405667721589, 0.016936848387767
1934, 0.57271993340032, 0.27425695594813, 0.083063217370826
1935, 0.61813316451904, 0.14538359921834, 0.016936848387767
1936, 0.62627129292075, 0.10492505736654, 0.018709382638713
1937, 0.63131384771681, 0.068321487696012, 0.017659623100202
1938, 0.51257376884661, 0.37482413408209, 0.016936848387767
1939, 0.55478089726837, 0.30893875772732, 0.01650867749896
1940, 0.59558208817849, 0.22024299362512, 0.016936848387767
1941, 0.33224508380515, 0.54114527096456, 0.049758116747832
1942, 0.43497253505719, 0.46262716494595, 0.08306301820393
1943, 0.54497162745199, 0.32593085965022, 0.083063128938057
1944, 0.63323645520144, 0.047292618915731, 0.08188527630613
1945, 0.37483934132634, 0.51256264806757, 0.082372771716718
1946, 0.52387339758244, 0.35886162138828, 0.083063190565853
1947, 0.58089410648989, 0.25648983809365, 0.016936848387767
1948, 0.44864940843835, 0.44937590979926, 0.015701643569707
1949, 0.40402266212798, 0.48988844494132, 0.081365188749394
1950, 0.58851721673007, 0.23847952870696, 0.083063305747576
1951, 0.62880629050196, 0.088474001973229, 0.084168807470914
1952, 0.62226241915503, 0.12654833743406, 0.083168283838933
1953, 0.50078793405511, 0.39043110161054, 0.083063174286459
1954, 0.60801082300432, 0.18316069204283, 0.016936848387767
1955, 0.63476851312662, 0.017144525161667, 0.050247290650164
1956, 0.35759944297646, 0.52473577959095, 0.018111508180578
1957, 0.63423787125111, 0.031101811375869, 0.018280346515443
1958, 0.34406111891354, 0.53371054556938, 0.081742595417462
1959, 0.63478331179892, 0.016587557433203, 0.069793973005913
1960, 0.6339965689932, 0.035684037115398, 0.063522820682952
1961, 0.63407294204219, 0.034300206558627, 0.040396507165802
1962, 0.63290710981667, 0.051513011400071, 0.05012489349324
1963, 0.63298739450714, 0.050516911970791, 0.030318356401181
1964, 0.63129823472509, 0.068465603283617, 0.040332567455614
1965, 0.63130534733815, 0.068399988466813, 0.05978859540002
1966, 0.62928605225401, 0.084994496519246, 0.048717027436637
1967, 0.62915005608861, 0.085995388967645, 0.029851317775743
1968, 0.62672698956842, 0.10216790370023, 0.039316986251857
1969, 0.62692395937614, 0.1009522122598, 0.056606703554059
1970, 0.62394490418793, 0.1179735416859, 0.046827963683718
1971, 0.33177102366098, 0.54143604226071, 0.030199123903362
1972, 0.34793873542321, 0.53119077212627, 0.036493290393237
1973, 0.34682225662773, 0.5319204097491, 0.059712430182084
1974, 0.36114326496764, 0.5223031133054, 0.049919292653436
1975, 0.36028909632148, 0.52289269173689, 0.069730794260997
1976, 0.37503246324051, 0.51242136129923, 0.059755495650978
1977, 0.37496840870059, 0.51246823557812, 0.040261068100826
1978, 0.38834483811825, 0.50240749069546, 0.05139397703413
1979, 0.38909772951657, 0.5018246276191, 0.070239518590498
1980, 0.40192076554382, 0.49161437959509, 0.060843848578948
1981, 0.40090197393254, 0.49244553739169, 0.042895530202315
1982, 0.41559013390752, 0.4801144036568, 0.051144034431487
1983, 0.53467610032561, 0.34255870699867, 0.083063190503589
1984, 0.5398878807926, 0.33428442406621, 0.066126329700008
1985, 0.54992612980992, 0.31750000275951, 0.066126265155111
1986, 0.54497162745192, 0.32593085965033, 0.049189454836698
1987, 0.55480248277753, 0.30889999207493, 0.049496946356112
1988, 0.53467609824374, 0.34255871024811, 0.049189454836869
1989, 0.55945324284842, 0.30039485525953, 0.066186832829423
1990, 0.56405982313145, 0.29165307460905, 0.049288042471137
1991, 0.56843898719235, 0.28302317544635, 0.066148243248014
1992, 0.57272079166053, 0.27425516367015, 0.049387029803774
1993, 0.56851866173599, 0.28286309631679, 0.032978484338076
1994, 0.5640059898983, 0.29175716505141, 0.083081247744892
1995, 0.55475164285352, 0.3089912858825, 0.083080300133916
1996, 0.52933752107433, 0.35075174808243, 0.066126303716068
1997, 0.51828505017732, 0.36688636764357, 0.0661263153381
1998, 0.51257377047394, 0.3748241318567, 0.083063163814815
1999, 0.57687858802659, 0.26539799297742, 0.066172655009002
2000, 0.58089413592406, 0.2564897714316, 0.049292437032424
2001, 0.5808949359631, 0.25648795950771, 0.083072984356521
2002, 0.58477628545846, 0.24751100170578, 0.066157401759073
2003, 0.59212000412097, 0.22938810064992, 0.066130614496945
2004, 0.59558213413863, 0.22024286933945, 0.0830641094619
2005, 0.59890306677506, 0.21104529515588, 0.066127182204805
2006, 0.59558205360908, 0.22024308710784, 0.049189528045798
2007, 0.60208198026593, 0.20179764378965, 0.049189521498685
2008, 0.60511814434966, 0.1925020295447, 0.066126363670807
2009, 0.6080107949494, 0.18316078517249, 0.049189508331879
2010, 0.60208201591984, 0.20179753741287, 0.083063453677781
2011, 0.61075917113811, 0.17377639330673, 0.066126763871609
2012, 0.61336286912699, 0.16435020771605, 0.04919030176681
2013, 0.6158209558727, 0.15488560394056, 0.066127074165034
2014, 0.61795441861811, 0.1461414948273, 0.050023080676657
2015, 0.61812459621551, 0.14542002459568, 0.083077809691518
2016, 0.61336152532109, 0.16435522278219, 0.083065350363752
2017, 0.62000648416546, 0.13717492333799, 0.066875424299554
2018, 0.50674094054015, 0.382672992489, 0.066126306795638
2019, 0.49471616306128, 0.39809661893305, 0.066126345364487
2020, 0.50078793405477, 0.39043110161096, 0.049189454836805
2021, 0.48852707157324, 0.40566772159006, 0.049189454837383
2022, 0.48222212414883, 0.41314261820997, 0.066126368293738
2023, 0.47580281157299, 0.42051954116217, 0.049189454838458
2024, 0.47580281351723, 0.42051953896232, 0.083063230715682
2025, 0.48852707200343, 0.40566772107201, 0.083063208137253
2026, 0.46927068599748, 0.42779670786888, 0.066126286286053
2027, 0.4558740996514, 0.4420450262892, 0.066126230112685
2028, 0.44901281979763, 0.44901279230928, 0.083063125409937
2029, 0.51257379023635, 0.37482410483151, 0.049189465297375
2030, 0.44204505568612, 0.45587407114625, 0.066126303224375
2031, 0.4483762613427, 0.44964844964077, 0.049204429974831
2032, 0.43449135808443, 0.46307910744272, 0.049289665871257
2033, 0.42714463214509, 0.4698643029957, 0.067184164086945
2034, 0.42411370304308, 0.47260191164561, 0.036074941831035
2035, 0.43823929385162, 0.45953380868488, 0.030690915233784
2036, 0.4202768435869, 0.47601720005125, 0.08354215292763
2037, 0.46257727583765, 0.43502558991238, 0.016412972461523
2038, 0.47579927399304, 0.42052354377335, 0.016719022994874
2039, 0.52387339636992, 0.35886162315835, 0.016936848387767
2040, 0.54497397383348, 0.32592693635867, 0.016725674598021
2041, 0.60208201122026, 0.20179755143451, 0.016936848387767
2042, 0.61336289969356, 0.1643500936401, 0.016936848387767
2043, 0.63132074697396, 0.06825770608689, 0.07956577264058
2044, 0.58851721944972, 0.23847952199543, 0.016936848387768
2045, 0.40586451396659, 0.48836359027129, 0.015773925140241
2046, 0.62581964548315, 0.10758611121953, 0.084925064642945
2047, 0.50078793405527, 0.39043110161032, 0.016936848387767
2048, 0.6223567549065, 0.12608358189013, 0.016489199385853
2049, 0.37481998162674, 0.51257680534075, 0.020460009316064
2050, 0.52387341812887, 0.3588615913942, 0.049189474445248
2051, 0.58851717598592, 0.23847962925491, 0.049287830770789
2052, 0.46256743428576, 0.43503605452685, 0.049444843745063
2053, 0.57277756051174, 0.27413658306439, 0.016523897402316
2054, 0.55952615994767, 0.30025901540872, 0.032924351842192
2055, 0.62060175983148, 0.13445614784782, 0.035701000952534
2056, 0.61584784438879, 0.15477865667361, 0.033656676630476
2057, 0.61076360053366, 0.17376082488054, 0.033144313215028
2058, 0.59211986567177, 0.22938845802884, 0.033062982210272
2059, 0.59890304201132, 0.21104536543025, 0.033063223296288
2060, 0.57687572158349, 0.26540422349227, 0.033063724890064
2061, 0.50674095543948, 0.38267297275909, 0.033063343617957
2062, 0.5398878811883, 0.33428442342712, 0.033062975825275
2063, 0.48222212207426, 0.41314262063142, 0.033063327400494
2064, 0.49471616482281, 0.39809661674399, 0.033063327399962
2065, 0.54995671526343, 0.31744702130696, 0.032968272170961
2066, 0.52933751904255, 0.3507517511487, 0.033063126939648
2067, 0.60511881053371, 0.19249993542407, 0.033074227573535
2068, 0.58477474657106, 0.2475146374919, 0.033063724906533
2069, 0.51828506192571, 0.36688635104712, 0.033063297383989
2070, 0.46924605122599, 0.42782372936622, 0.032955173356797
2071, 0.56404071332459, 0.29169003019007, 0.016537690393449
2072, 0.45519815349343, 0.44274105417972, 0.032375482101886
2073, 0.63479354040372, 0.01619138850453, 0.030637996390345
2074, 0.3314305938899, 0.54164449728008, 0.069385490527043
2075, 0.63430945888895, 0.029605917719413, 0.083380674268373
2076, 0.34280755861972, 0.53451658323497, 0.016615755710714
2077, 0.62396383187997, 0.11787339184761, 0.066529904520454
2078, 0.62410848267376, 0.1171050889358, 0.031416403345845
2079, 0.4134810931653, 0.48193193045785, 0.068698641894573
2080, 0.63306455411962, 0.049540592621934, 0.013597353585922
2081, 0.35886162315835, 0.52387339636992, 0.086268353700644
2082, 0.43597133363786, 0.46168603644254, 0.013183720226588
2083, 0.63270453257133, 0.053944179145667, 0.06674068994693
2084, 0.3872485119902, 0.50325300790097, 0.033221956475056
2085, 0.36312820713145, 0.52092504756971, 0.033291552515597
2086, 0.62947614884357, 0.083574984517314, 0.066845538698289
2087, 0.62894888259983, 0.087454577218269, 0.013053492837211
2088, 0.41150320906584, 0.48362186564352, 0.032665273929778
2089, 0.39021834224022, 0.50095373576738, 0.087005705122015
2090, 0.63482870410769, 0.014748438593757, 0.085249854131673
2091, 0.32910468945854, 0.5430608652595, 0.013480838232965
2092, 0.63484035274739, 0.014238206473144, 0.014362019687972
2093, 0.32975082488377, 0.54266876959014, 0.085637980312033
2094, 0.39855826984056, 0.494344318812, 0.027956148847679
2095, 0.62714020137151, 0.099600039275588, 0.07152621700571
2096, 0.62121052031758, 0.1316149286622, 0.052818042396483
2097, 0.49010530071153, 0.4303722136375, 0.1
2098, 0.92299090816313, 0.60463959566353, 0.1
2099, 0.72970857519646, 0.8443094773519, 0.1
2100, 0.44454728597475, 0.73691196404579, 0.1
2101, 0.92056528951285, 0.50523629685956, 0.1
2102, 0.53781717726652, 0.36821209045345, 0.1
2103, 0.92230904877108, 0.40694707002069, 0.1
2104, 0.57905960372086, 0.29935420177969, 0.1
2105, 0.92208352769214, 0.327406086332, 0.1
2106, 0.61831933738185, 0.20668500372103, 0.1
2107, 0.40722760146771, 0.67038512080802, 0.1
2108, 0.777734375, 0.016481545965773, 0.1
2109, 0.9223084566416, 0.24811924144711, 0.1
2110, 0.92230812280721, 0.684875709834, 0.1
2111, 0.48557652960763, 0.80376812013285, 0.1
2112, 0.9223320369444, 0.1680945750138, 0.1
2113, 0.63977105120272, 0.12880326912159, 0.1
2114, 0.43160266311671, 0.48800192214794, 0.1
2115, 0.65301122730137, 0.87003493306484, 0.1
2116, 0.80858554372455, 0.82430699412955, 0.1
2117, 0.92060428504426, 0.11245867822071, 0.1
2118, 0.72030327944567, 0.016507708498079, 0.1
2119, 0.37556325955749, 0.61679407441458, 0.1
2120, 0.8362141265947, 0.017453635767373, 0.1
2121, 0.51162780543908, 0.85622099282025, 0.1
2122, 0.92284507293249, 0.74442970658781, 0.1
2123, 0.64813676878989, 0.069736513950306, 0.1
2124, 0.38443915404929, 0.52623527696785, 0.1
2125, 0.59927685587102, 0.89271428239434, 0.1
2126, 0.86905416730206, 0.82250119448792, 0.1
2127, 0.46023299104651, 0.461110737078, 0.1
2128, 0.5135814157889, 0.40018738159897, 0.1
2129, 0.55959649118361, 0.33445928792331, 0.1
2130, 0.5965984295758, 0.26300583521281, 0.1
2131, 0.62893913649945, 0.16929273347993, 0.1
2132, 0.69032930853858, 0.85459188856934, 0.1
2133, 0.76868040019758, 0.83537404626557, 0.1
2134, 0.92177159852883, 0.069688021746149, 0.1
2135, 0.92232426835704, 0.20841391957794, 0.1
2136, 0.92231082216338, 0.28783994326436, 0.1
2137, 0.92352764753454, 0.367249826964, 0.1
2138, 0.92261655653855, 0.44609301375486, 0.1
2139, 0.92230812280721, 0.54591542088218, 0.1
2140, 0.92158976450031, 0.64453300924827, 0.1
2141, 0.42514557699265, 0.70206198849899, 0.1
2142, 0.4643715981406, 0.77016670719822, 0.1
2143, 0.87240024066051, 0.01731187553427, 0.1
2144, 0.68483576760285, 0.016410711645138, 0.1
2145, 0.35738533190224, 0.58463112503701, 0.1
2146, 0.53268627591827, 0.88906876909692, 0.1
2147, 0.92270749844714, 0.78410590997729, 0.1
2148, 0.92080259226209, 0.029683563203451, 0.1
2149, 0.35275212515914, 0.55066516535015, 0.1
2150, 0.90869550376239, 0.81572781119956, 0.1
2151, 0.55989794171843, 0.90944645471585, 0.1
2152, 0.65314812892216, 0.02953869772195, 0.1
2153, 0.65023297262544, 0.049583596882867, 0.1
2154, 0.66588834556637, 0.061031274908335, 0.1
2155, 0.66410528295818, 0.080928690643418, 0.1
2156, 0.68178043562672, 0.07246863645208, 0.1
2157, 0.67999629271064, 0.092277828600127, 0.1
2158, 0.69773857835288, 0.083834088557008, 0.1
2159, 0.69592447392025, 0.10344358410973, 0.1
2160, 0.71367069187623, 0.094982439262052, 0.1
2161, 0.71165053577912, 0.11459304439481, 0.1
2162, 0.72960364369793, 0.10602450101749, 0.1
2163, 0.72746150754939, 0.12558315367606, 0.1
2164, 0.7455844942814, 0.11708102907333, 0.1
2165, 0.74358137718553, 0.13650242938623, 0.1
