2166, 0.76160783368828, 0.12816489818903, 0.1
2167, 0.75997146788985, 0.14762637652036, 0.1
2168, 0.74195301438191, 0.15592143241776, 0.1
2169, 0.75834659944371, 0.16709920339928, 0.1
2170, 0.7406425540514, 0.17542715759645, 0.1
2171, 0.75672212098636, 0.18659906976764, 0.1
2172, 0.73875986802775, 0.19492562933782, 0.1
2173, 0.75505183513314, 0.20612050131011, 0.1
2174, 0.7370640222127, 0.21445508019426, 0.1
2175, 0.75340007019707, 0.22566151716081, 0.1
2176, 0.73569722701357, 0.2340196326511, 0.1
2177, 0.75185893583946, 0.24522249579831, 0.1
2178, 0.73411132445954, 0.25358668030855, 0.1
2179, 0.75019331771537, 0.26479178730793, 0.1
2180, 0.73246719794929, 0.27316206365881, 0.1
2181, 0.74855206119166, 0.28437229913429, 0.1
2182, 0.73081978032661, 0.29274539287864, 0.1
2183, 0.74694428084437, 0.30396268899401, 0.1
2184, 0.72906107839563, 0.31252729136037, 0.1
2185, 0.7452544430925, 0.32359057477816, 0.1
2186, 0.72723084751865, 0.33225307375881, 0.1
2187, 0.74357718172185, 0.34322151694555, 0.1
2188, 0.72566059840941, 0.35169614982174, 0.1
2189, 0.74196497763429, 0.36279210503111, 0.1
2190, 0.72408877675715, 0.37134915608896, 0.1
2191, 0.74031278273662, 0.38242612342907, 0.1
2192, 0.72232782442028, 0.39105363020886, 0.1
2193, 0.73865229403891, 0.40206542614948, 0.1
2194, 0.72075005838632, 0.41053207288196, 0.1
2195, 0.73703580876014, 0.42165518019515, 0.1
2196, 0.71927859697377, 0.4300289747383, 0.1
2197, 0.73540261833969, 0.4412726270282, 0.1
2198, 0.71761759564348, 0.44966439181749, 0.1
2199, 0.73375984972301, 0.46090532284634, 0.1
2200, 0.71596656208852, 0.46929801750567, 0.1
2201, 0.73213529969514, 0.48054284433602, 0.1
2202, 0.71431975716543, 0.48893708396737, 0.1
2203, 0.73046987946081, 0.50018158486053, 0.1
2204, 0.71266615785301, 0.50857749010915, 0.1
2205, 0.72882407873171, 0.51982368592883, 0.1
2206, 0.7110143414348, 0.52821761270452, 0.1
2207, 0.7271910660791, 0.53946783139899, 0.1
2208, 0.70936577825296, 0.54786025607873, 0.1
2209, 0.72552930760258, 0.55911197779787, 0.1
2210, 0.70771236812437, 0.56750552143095, 0.1
2211, 0.72388894750971, 0.57873648112888, 0.1
2212, 0.70606103624811, 0.58714766480671, 0.1
2213, 0.68987945786314, 0.57589868443263, 0.1
2214, 0.68822689385877, 0.59553828346926, 0.1
2215, 0.67204774013788, 0.58428762472318, 0.1
2216, 0.67039684696313, 0.60392097791419, 0.1
2217, 0.65422458868602, 0.5926750179051, 0.1
2218, 0.65257452311549, 0.61230013994801, 0.1
2219, 0.63640888483788, 0.60103765443577, 0.1
2220, 0.72223719706217, 0.59830315114437, 0.1
2221, 0.63476024308421, 0.62067498863417, 0.1
2222, 0.61859989141094, 0.60939089535055, 0.1
2223, 0.65092243375711, 0.63191810216137, 0.1
2224, 0.63310541344984, 0.6402959484182, 0.1
2225, 0.63806557541311, 0.5813721606502, 0.1
2226, 0.64926648720079, 0.65153670009108, 0.1
2227, 0.63145195781408, 0.65991492151337, 0.1
2228, 0.69814540113302, 0.47768499431017, 0.1
2229, 0.64761383417353, 0.67115672452268, 0.1
2230, 0.62979726265516, 0.67953219414985, 0.1
2231, 0.61363886540619, 0.66829266707498, 0.1
2232, 0.74173336336248, 0.57019043624108, 0.1
2233, 0.61198336404989, 0.68790303121224, 0.1
2234, 0.5958284968317, 0.67666754518251, 0.1
2235, 0.70286123456905, 0.41902157796127, 0.1
2236, 0.74665904913978, 0.51122870284494, 0.1
2237, 0.64596283367254, 0.69077840402661, 0.1
2238, 0.75162723768739, 0.45219658731935, 0.1
2239, 0.7565585386995, 0.39324774385563, 0.1
2240, 0.66378878503187, 0.68238485750248, 0.1
2241, 0.76150037139558, 0.33431835958912, 0.1
2242, 0.66213531014671, 0.70203216705794, 0.1
2243, 0.67997347285555, 0.69363891095481, 0.1
2244, 0.59417594981364, 0.69626941589357, 0.1
2245, 0.76645384086331, 0.27542011258226, 0.1
2246, 0.5780289223432, 0.68504137536868, 0.1
2247, 0.77128808742036, 0.21731202549841, 0.1
2248, 0.70757462661702, 0.36057919016232, 0.1
2249, 0.77769810215921, 0.13929167779983, 0.1
2250, 0.67831640437963, 0.71329602215755, 0.1
2251, 0.69616257733099, 0.70490342428733, 0.1
2252, 0.66047529646438, 0.7216704817994, 0.1
2253, 0.57637639218361, 0.70463351441251, 0.1
2254, 0.56023668859117, 0.693405918278, 0.1
2255, 0.56188740448777, 0.67382079211826, 0.1
2256, 0.69450577642254, 0.7245635906025, 0.1
2257, 0.71236239863056, 0.71616636336713, 0.1
2258, 0.71279060804409, 0.30153101346088, 0.1
2259, 0.54410542582869, 0.6821840058623, 0.1
2260, 0.54575411513144, 0.66260695593855, 0.1
2261, 0.77934050608983, 0.11982307691726, 0.1
2262, 0.79539009663932, 0.13095968195459, 0.1
2263, 0.55858518641505, 0.71299613803462, 0.1
2264, 0.57471884938696, 0.72422046525374, 0.1
2265, 0.52798095591773, 0.67096540853289, 0.1
2266, 0.52962802438459, 0.65139759320376, 0.1
2267, 0.71070481979646, 0.73582966036422, 0.1
2268, 0.72856690249538, 0.72743177039081, 0.1
2269, 0.73022341426864, 0.70776278475175, 0.1
2270, 0.74642041280993, 0.71903032904857, 0.1
2271, 0.74809040886781, 0.69935403513721, 0.1
2272, 0.76427449211336, 0.71065363338438, 0.1
2273, 0.76596067788508, 0.69094514870891, 0.1
2274, 0.78216730315982, 0.70225480706477, 0.1
2275, 0.78384336715157, 0.68253230903924, 0.1
2276, 0.80007524278073, 0.69381788792387, 0.1
2277, 0.80173518298016, 0.67411143472641, 0.1
2278, 0.79839861061072, 0.71354837218903, 0.1
2279, 0.81631181302008, 0.70510987765162, 0.1
2280, 0.81465243598601, 0.72482045873824, 0.1
2281, 0.71763267905009, 0.24270392098442, 0.1
2282, 0.51186021338805, 0.65974995779745, 0.1
2283, 0.5135116122125, 0.64017325454711, 0.1
2284, 0.53127226522598, 0.63183281090284, 0.1
2285, 0.51516288310931, 0.62060427789978, 0.1
2286, 0.53291393309449, 0.6122762462183, 0.1
2287, 0.51680505362788, 0.60106627992069, 0.1
2288, 0.53455079095603, 0.59271926300007, 0.1
2289, 0.5184449681047, 0.58152023680456, 0.1
2290, 0.53618830909707, 0.57316694759758, 0.1
2291, 0.50070124532826, 0.58984536994241, 0.1
2292, 0.52008888445314, 0.56196924474129, 0.1
2293, 0.53782980375693, 0.5536166001441, 0.1
2294, 0.79699045468302, 0.11149581657687, 0.1
2295, 0.81305851021796, 0.12261555613404, 0.1
2296, 0.81146143109015, 0.14212165790768, 0.1
2297, 0.5569296632739, 0.73258382826079, 0.1
2298, 0.5730652854438, 0.74380951516643, 0.1
2299, 0.52173382197321, 0.54241934537265, 0.1
2300, 0.53948483163589, 0.53406903197182, 0.1
2301, 0.82916541058011, 0.13375449669477, 0.1
2302, 0.82756272336338, 0.15329714475953, 0.1
2303, 0.83076723988293, 0.11422349894527, 0.1
2304, 0.74474991583868, 0.73875946791565, 0.1
2305, 0.49575782769301, 0.64847215401732, 0.1
2306, 0.72213160390148, 0.18418218270139, 0.1
2307, 0.83256003923975, 0.71639797569508, 0.1
2308, 0.55556554647996, 0.54522600225864, 0.1
2309, 0.55723322946023, 0.52570682484472, 0.1
2310, 0.54112498255727, 0.51451595455258, 0.1
2311, 0.55887756798971, 0.5061608250895, 0.1
2312, 0.57499293645006, 0.51735643856432, 0.1
2313, 0.57663377893919, 0.49779558786695, 0.1
2314, 0.5927469279109, 0.50899744059044, 0.1
2315, 0.59438183979234, 0.48943312902049, 0.1
2316, 0.5782698481789, 0.47823296197334, 0.1
2317, 0.59601678173114, 0.46986983954608, 0.1
2318, 0.61054391932992, 0.50057216959507, 0.1
2319, 0.78550001790079, 0.66281755900255, 0.1
2320, 0.80339094056463, 0.65440063357166, 0.1
2321, 0.57990634402108, 0.45867328884429, 0.1
2322, 0.59766300497936, 0.45030737393345, 0.1
2323, 0.55527261752839, 0.75216681280027, 0.1
2324, 0.57140973243696, 0.76340192943302, 0.1
2325, 0.83089742197518, 0.7361298027874, 0.1
2326, 0.81298340453428, 0.74458856646626, 0.1
2327, 0.51020393476448, 0.67933464637603, 0.1
2328, 0.78099928850035, 0.10039163486713, 0.1
2329, 0.53914225978976, 0.74094312210012, 0.1
2330, 0.69318632154922, 0.53660967020639, 0.1
2331, 0.503986263949, 0.55077003249343, 0.1
2332, 0.73187803262815, 0.6880452978656, 0.1
2333, 0.6928430154639, 0.74422674793496, 0.1
2334, 0.61374190373053, 0.46145108324246, 0.1
2335, 0.61540484904143, 0.44193058984543, 0.1
2336, 0.59929535471349, 0.43074165260562, 0.1
2337, 0.61705406687445, 0.42237617039331, 0.1
2338, 0.8196326257631, 0.66569134670603, 0.1
2339, 0.82128147744611, 0.64597905602634, 0.1
2340, 0.8050426645896, 0.63469129867746, 0.1
2341, 0.82293273072253, 0.62626718455558, 0.1
2342, 0.83752769612075, 0.65724620436205, 0.1
2343, 0.70902924831411, 0.75549731430483, 0.1
2344, 0.69119069337674, 0.76387566609175, 0.1
2345, 0.66707832924501, 0.64314100928201, 0.1
2346, 0.80669402616399, 0.61498323743963, 0.1
2347, 0.82458120165494, 0.60655630307717, 0.1
2348, 0.80834520269317, 0.59527249341766, 0.1
2349, 0.82623185936595, 0.58684583874789, 0.1
2350, 0.80999683430117, 0.57556288362093, 0.1
2351, 0.82788010394045, 0.56713574400196, 0.1
2352, 0.7985622366833, 0.092082503769141, 0.1
2353, 0.58921395534168, 0.75503490435038, 0.1
2354, 0.58756104628532, 0.77464263813154, 0.1
2355, 0.56974100942762, 0.78301624974501, 0.1
2356, 0.5858906548176, 0.79426605397825, 0.1
2357, 0.60372285647436, 0.78589015408773, 0.1
2358, 0.81164834139449, 0.55585128937865, 0.1
2359, 0.82953638675887, 0.54742627773035, 0.1
2360, 0.81329731902025, 0.53614547879417, 0.1
2361, 0.83118090894715, 0.52771738742948, 0.1
2362, 0.81494118034694, 0.51644420449457, 0.1
2363, 0.83282657726288, 0.50801002549192, 0.1
2364, 0.81659405117632, 0.49673425349303, 0.1
2365, 0.83447698431877, 0.48830217045349, 0.1
2366, 0.81825314736626, 0.47701924474532, 0.1
2367, 0.83612596448997, 0.468593717783, 0.1
2368, 0.81990675494274, 0.45730839429898, 0.1
2369, 0.83778737328002, 0.44888797475208, 0.1
2370, 0.82156068896319, 0.43760253084706, 0.1
2371, 0.83942868919082, 0.42918226738983, 0.1
2372, 0.8232106946405, 0.41790248794181, 0.1
2373, 0.84109701239529, 0.40948120172125, 0.1
2374, 0.8248626149309, 0.39820003543309, 0.1
2375, 0.84275058921998, 0.38978004190517, 0.1
2376, 0.82651907070516, 0.3784960001178, 0.1
2377, 0.8439301549356, 0.37004021100188, 0.1
2378, 0.82809126872222, 0.3587962458985, 0.1
2379, 0.8454886935832, 0.35033558509267, 0.1
2380, 0.82971720584503, 0.33909345948163, 0.1
2381, 0.8465043634198, 0.33058654268235, 0.1
2382, 0.8312600824626, 0.31938726636688, 0.1
2383, 0.84803036534875, 0.31088286996615, 0.1
2384, 0.83287081461978, 0.29969976277624, 0.1
2385, 0.85073640510215, 0.29128280101952, 0.1
2386, 0.83469592698275, 0.28002139619916, 0.1
2387, 0.73143591786075, 0.086619797168299, 0.1
2388, 0.54277087562765, 0.49494579209143, 0.1
2389, 0.50563391906087, 0.53122804459275, 0.1
2390, 0.48789356308516, 0.53957727189001, 0.1
2391, 0.60093013701991, 0.41118531069806, 0.1
2392, 0.61868272518065, 0.4028175801141, 0.1
2393, 0.84413286032769, 0.57834806943939, 0.1
2394, 0.85258997419087, 0.27161366162685, 0.1
2395, 0.83641305757182, 0.26034031642956, 0.1
2396, 0.85398010225865, 0.25191136185835, 0.1
2397, 0.83798967821695, 0.24072661665693, 0.1
2398, 0.8408309995991, 0.6177930838753, 0.1
2399, 0.60205384455753, 0.80551661103525, 0.1
2400, 0.5842192783653, 0.81388213069811, 0.1
2401, 0.61989081754575, 0.7971433769131, 0.1
2402, 0.84532181700401, 0.14490494751962, 0.1
2403, 0.84369855964765, 0.16448523369085, 0.1
2404, 0.85484969692807, 0.23110350236065, 0.1
2405, 0.85238567917826, 0.47974050876537, 0.1
2406, 0.84908483116158, 0.51918281241835, 0.1
2407, 0.84881299804306, 0.72769455132669, 0.1
2408, 0.84714433189373, 0.74745642653793, 0.1
2409, 0.63314034474165, 0.43351581988001, 0.1
2410, 0.5490422822719, 0.62343192522252, 0.1
2411, 0.60279280638676, 0.39212022900887, 0.1
2412, 0.62035112379421, 0.38334019867052, 0.1
2413, 0.70737004932323, 0.77516765836557, 0.1
2414, 0.68952779753006, 0.78354821156621, 0.1
2415, 0.55233204057589, 0.58425821845948, 0.1
2416, 0.63644344017946, 0.39446453248005, 0.1
2417, 0.63807139433648, 0.37490623353699, 0.1
2418, 0.62194869240122, 0.36371739762513, 0.1
2419, 0.63968892645464, 0.35533636571127, 0.1
2420, 0.58317597795241, 0.41955681453374, 0.1
2421, 0.59111397198487, 0.52856409226027, 0.1
2422, 0.78880504715436, 0.62340599764655, 0.1
2423, 0.82585272862902, 0.17248340740149, 0.1
2424, 0.60038489439679, 0.82514271137327, 0.1
2425, 0.58255149281648, 0.83350245377328, 0.1
2426, 0.53748490539611, 0.76051852176115, 0.1
2427, 0.56639939331298, 0.82225565772247, 0.1
2428, 0.69417470260637, 0.12281439386332, 0.1
2429, 0.78263233814922, 0.081022062037532, 0.1
2430, 0.62155766366403, 0.77750862114246, 0.1
2431, 0.85677840341756, 0.4206422414035, 0.1
2432, 0.80012789115158, 0.072742402962588, 0.1
2433, 0.4895369647392, 0.52004392658264, 0.1
2434, 0.6246962833085, 0.3442462452626, 0.1
2435, 0.64149771608936, 0.33579778559833, 0.1
2436, 0.47180232213369, 0.52838800748195, 0.1
2437, 0.47015972512212, 0.54791529414104, 0.1
2438, 0.45407467814488, 0.53672964325058, 0.1
2439, 0.45243110817357, 0.55624811603047, 0.1
2440, 0.85900056541548, 0.38122597699573, 0.1
2441, 0.52135771551326, 0.74930601262036, 0.1
2442, 0.59748111709055, 0.65706278607626, 0.1
2443, 0.61032075292953, 0.70750265193513, 0.1
2444, 0.85047459304144, 0.70796785074639, 0.1
2445, 0.65419891255989, 0.38608564126756, 0.1
2446, 0.79540830044554, 0.54457695687263, 0.1
2447, 0.80035996929646, 0.48545060077362, 0.1
2448, 0.8053312414918, 0.42632149346744, 0.1
2449, 0.81028850999837, 0.36722010244787, 0.1
2450, 0.86673432495392, 0.71926831344159, 0.1
2451, 0.86839856802666, 0.69953372317372, 0.1
2452, 0.81523504601133, 0.30813118573849, 0.1
2453, 0.86147761598822, 0.15609227920216, 0.1
2454, 0.8630762137708, 0.13649293753205, 0.1
2455, 0.82021778540624, 0.24908140096486, 0.1
2456, 0.86351832686162, 0.34037482624413, 0.1
2457, 0.8218255415284, 0.22949414594881, 0.1
2458, 0.85929549446353, 0.1748802371922, 0.1
2459, 0.62647325148772, 0.3249517992957, 0.1
2460, 0.64317766799062, 0.31629079932687, 0.1
2461, 0.65910423059645, 0.327421314891, 0.1
2462, 0.6608502225215, 0.30768956298209, 0.1
2463, 0.64462478448787, 0.29666269260454, 0.1
2464, 0.66241220626446, 0.2879999144184, 0.1
2465, 0.64663895279204, 0.27711866355088, 0.1
2466, 0.66394167142684, 0.26865861679472, 0.1
2467, 0.64831003736413, 0.25761280090214, 0.1
2468, 0.66561021261566, 0.24921477000965, 0.1
2469, 0.86801958475582, 0.30343189571344, 0.1
2470, 0.56473048834206, 0.84185696576744, 0.1
2471, 0.43681780678569, 0.54510450840176, 0.1
2472, 0.43524988084526, 0.56462885375844, 0.1
2473, 0.45087798225824, 0.57577525229178, 0.1
2474, 0.4331639124984, 0.58411331914654, 0.1
2475, 0.44917577893933, 0.59529303489828, 0.1
2476, 0.43143414843325, 0.60363034449242, 0.1
2477, 0.44750724578413, 0.61481643272888, 0.1
2478, 0.41803487265644, 0.57402961151628, 0.1
2479, 0.87043175055151, 0.26095184155199, 0.1
2480, 0.70572634703257, 0.79484736624796, 0.1
2481, 0.72356506419699, 0.78648586002721, 0.1
2482, 0.68785132772596, 0.80324983405971, 0.1
2483, 0.69947421766972, 0.06438557084755, 0.1
2484, 0.52301753512632, 0.72973004087398, 0.1
2485, 0.50524079511202, 0.73809022284784, 0.1
2486, 0.79210755344022, 0.58399416701179, 0.1
2487, 0.63771181822905, 0.78876500811242, 0.1
2488, 0.63598456077682, 0.8084616822546, 0.1
2489, 0.7743332492086, 0.17807667090725, 0.1
2490, 0.63937692474814, 0.76912757985865, 0.1
2491, 0.42976987728833, 0.62315403865952, 0.1
2492, 0.44585414591137, 0.63434508990452, 0.1
2493, 0.60889180632972, 0.3503830199277, 0.1
2494, 0.51969064301303, 0.76891033437436, 0.1
2495, 0.88466800151352, 0.7108385405203, 0.1
2496, 0.59871210473967, 0.84476850641156, 0.1
2497, 0.4734451178184, 0.50886732563253, 0.1
2498, 0.49118488990901, 0.50049336366498, 0.1
2499, 0.87926892944359, 0.14768655489363, 0.1
2500, 0.88086045569562, 0.12806346748381, 0.1
2501, 0.5485940770209, 0.83061378089046, 0.1
2502, 0.78422883933645, 0.061721137494049, 0.1
2503, 0.80170117154368, 0.053477025144292, 0.1
2504, 0.81758809582809, 0.064462158241883, 0.1
2505, 0.88299993890692, 0.73058363995803, 0.1
2506, 0.64913419304868, 0.23721735846387, 0.1
2507, 0.6670993176437, 0.22955593529941, 0.1
2508, 0.68168836822039, 0.25995741641458, 0.1
2509, 0.67696792700782, 0.31883142637357, 0.1
2510, 0.89707559754049, 0.13926430368908, 0.1
2511, 0.76675360573204, 0.069966873556494, 0.1
2512, 0.6752144592253, 0.33855908036849, 0.1
2513, 0.50689855506984, 0.71850694774435, 0.1
2514, 0.48913476296523, 0.72686702838571, 0.1
2515, 0.49078410027151, 0.70729810927876, 0.1
2516, 0.55025970476957, 0.81101658611574, 0.1
2517, 0.53246970984032, 0.81937710421584, 0.1
2518, 0.46359053128086, 0.62600424894564, 0.1
2519, 0.6326977292297, 0.24707170283588, 0.1
2520, 0.67370472531076, 0.56463702158871, 0.1
2521, 0.86467504442367, 0.11686791584181, 0.1
2522, 0.88244837376202, 0.10845275841107, 0.1
2523, 0.86630046904359, 0.097285039558727, 0.1
2524, 0.88439340291565, 0.088716084743442, 0.1
2525, 0.86797042314746, 0.077722731344839, 0.1
2526, 0.88597982674998, 0.069081882243152, 0.1
2527, 0.86949402134302, 0.05797332051651, 0.1
2528, 0.88715966602189, 0.049742931285248, 0.1
2529, 0.85004836891742, 0.086265472996488, 0.1
2530, 0.56215679765137, 0.46703352626362, 0.1
2531, 0.5637894688266, 0.44748519149446, 0.1
2532, 0.54605047783369, 0.45584086597943, 0.1
2533, 0.54768095806109, 0.43630676410794, 0.1
2534, 0.52995080756625, 0.44465914237282, 0.1
2535, 0.52831565085286, 0.46418741427044, 0.1
2536, 0.62321566606024, 0.75786541214776, 0.1
2537, 0.5635349279128, 0.65423725666466, 0.1
2538, 0.69782085532442, 0.68518119335045, 0.1
2539, 0.6865527535238, 0.61513462044656, 0.1
2540, 0.61652855593191, 0.83640490937083, 0.1
2541, 0.61394794882465, 0.85571315646408, 0.1
2542, 0.65256443684435, 0.40565161430125, 0.1
2543, 0.4619351412936, 0.64553563094522, 0.1
2544, 0.44420271071347, 0.65387522422723, 0.1
2545, 0.46027954900846, 0.66512144365471, 0.1
2546, 0.62891193489568, 0.28634824833446, 0.1
2547, 0.67501160417616, 0.7525387716571, 0.1
2548, 0.67032880783626, 0.39727847462528, 0.1
2549, 0.66867819965442, 0.41680876872846, 0.1
2550, 0.67195843743037, 0.37770618721002, 0.1
2551, 0.88618408383687, 0.69107971683368, 0.1
2552, 0.87005267537865, 0.67978223803333, 0.1
2553, 0.88781633901247, 0.67133006043851, 0.1
2554, 0.87168439090624, 0.6600429110194, 0.1
2555, 0.8041035889169, 0.23784032001853, 0.1
2556, 0.8057647597348, 0.21821508417343, 0.1
2557, 0.80240561218607, 0.25745958273094, 0.1
2558, 0.76824187723366, 0.050896952744241, 0.1
2559, 0.75086641414161, 0.058981962319521, 0.1
2560, 0.75238099129432, 0.039957635753953, 0.1
2561, 0.73493970674374, 0.048095856269967, 0.1
2562, 0.70406576524119, 0.81453590386531, 0.1
2563, 0.65164974184895, 0.21657566256298, 0.1
2564, 0.66931310339829, 0.20986359022599, 0.1
2565, 0.68493498904894, 0.22125863577455, 0.1
2566, 0.68645751643614, 0.2018088533221, 0.1
2567, 0.67104421833396, 0.19068457621264, 0.1
2568, 0.68804588806648, 0.18229172264485, 0.1
2569, 0.67286500266158, 0.17122302587737, 0.1
2570, 0.6898098125757, 0.16281256301225, 0.1
2571, 0.67376175572225, 0.15168155407141, 0.1
2572, 0.82284135020645, 0.21002707801579, 0.1
2573, 0.41368473547621, 0.61196543729225, 0.1
2574, 0.41210264538476, 0.63138896701776, 0.1
2575, 0.47320222784817, 0.71541355002371, 0.1
2576, 0.43808253723511, 0.52557899120718, 0.1
2577, 0.66155209156913, 0.10109867422367, 0.1
2578, 0.806706600596, 0.19915853245148, 0.1
2579, 0.5471918634932, 0.84987074086653, 0.1
2580, 0.56309823437611, 0.86139245732362, 0.1
2581, 0.4199254636791, 0.53457907929394, 0.1
2582, 0.8891668636019, 0.65155715510541, 0.1
2583, 0.87329181203857, 0.64028927497528, 0.1
2584, 0.89076603895043, 0.63180306464676, 0.1
2585, 0.87493233378921, 0.62053825351737, 0.1
2586, 0.68598766769679, 0.82251746929483, 0.1
2587, 0.70249872123589, 0.21248976035199, 0.1
2588, 0.69292264605278, 0.33008302970923, 0.1
2589, 0.68805738912934, 0.38881655749946, 0.1
2590, 0.78622349237904, 0.24620673076825, 0.1
2591, 0.47470767460847, 0.6960705286263, 0.1
2592, 0.53413807138965, 0.79976932946408, 0.1
2593, 0.52467369968348, 0.71013271033356, 0.1
2594, 0.44258132425994, 0.67336116085463, 0.1
2595, 0.5250215913215, 0.50331395218571, 0.1
2596, 0.46689024554324, 0.586958728353, 0.1
2597, 0.8358773974427, 0.67697010552141, 0.1
2598, 0.51249061255716, 0.45357485239522, 0.1
2599, 0.51062369985285, 0.47264105049759, 0.1
2600, 0.65550487071984, 0.78046969278706, 0.1
2601, 0.66994036261609, 0.81152544070378, 0.1
2602, 0.66659884828606, 0.83239326542479, 0.1
2603, 0.6410283599785, 0.74951266524545, 0.1
2604, 0.62483282007358, 0.73827613366452, 0.1
2605, 0.49446822275402, 0.46140507628313, 0.1
2606, 0.81940003567205, 0.046035114754719, 0.1
2607, 0.8350242566751, 0.05617366637484, 0.1
2608, 0.48785583500293, 0.74642464535657, 0.1
2609, 0.80394181470389, 0.033557257381768, 0.1
2610, 0.90234664630203, 0.72174970639319, 0.1
2611, 0.51706713770118, 0.80691489451232, 0.1
2612, 0.8921071145379, 0.61202687044378, 0.1
2613, 0.87653660534137, 0.60078661260297, 0.1
2614, 0.89370429373382, 0.59227245117327, 0.1
2615, 0.87817625099333, 0.58103566842157, 0.1
2616, 0.89611718759954, 0.57257678487046, 0.1
2617, 0.87995239977768, 0.56128154504133, 0.1
2618, 0.47595784233719, 0.48925812465542, 0.1
2619, 0.45773326418074, 0.70302487992101, 0.1
2620, 0.63336493618319, 0.84748699161354, 0.1
2621, 0.89496438486399, 0.15806052892053, 0.1
2622, 0.53209718553097, 0.42509642604431, 0.1
2623, 0.54930770729813, 0.41677832992334, 0.1
2624, 0.42191814056434, 0.51437545123076, 0.1
2625, 0.59671757039046, 0.8634188983211, 0.1
2626, 0.51388729770477, 0.82605460537316, 0.1
2627, 0.65701300830492, 0.16004624393893, 0.1
2628, 0.459011498147, 0.49806743345229, 0.1
2629, 0.89899316400183, 0.55308592696708, 0.1
2630, 0.88184127886003, 0.54159071143479, 0.1
2631, 0.86373348531392, 0.55006641033834, 0.1
2632, 0.90104516397273, 0.53363054706071, 0.1
2633, 0.88360427877408, 0.52189878004144, 0.1
2634, 0.69910399439373, 0.83476265930727, 0.1
2635, 0.61320504068197, 0.87571360885804, 0.1
2636, 0.9051620210642, 0.65966001175985, 0.1
2637, 0.91287615637426, 0.58403803103396, 0.1
2638, 0.89822966422915, 0.74211593086738, 0.1
2639, 0.88115835455843, 0.75037182875496, 0.1
2640, 0.89677092570145, 0.7618814515518, 0.1
2641, 0.87949697625563, 0.7701352375731, 0.1
2642, 0.89498367393155, 0.78173859328477, 0.1
2643, 0.87818287157013, 0.78936416351746, 0.1
2644, 0.86173908781286, 0.77845132809645, 0.1
2645, 0.86024892382124, 0.79664334302267, 0.1
2646, 0.8438465219825, 0.78666815341628, 0.1
2647, 0.84087880517547, 0.80694313998413, 0.1
2648, 0.82530903362964, 0.79454806614278, 0.1
2649, 0.82747022878652, 0.77546374073425, 0.1
2650, 0.80954074633812, 0.78390539377571, 0.1
2651, 0.90205108285983, 0.099677298223108, 0.1
2652, 0.80786492880909, 0.80293765589833, 0.1
2653, 0.79170923429325, 0.79232354619661, 0.1
2654, 0.79339172346512, 0.77273957882124, 0.1
2655, 0.77550068068974, 0.7811628752548, 0.1
2656, 0.77716907793288, 0.76148861816273, 0.1
2657, 0.75928674069868, 0.76988188515417, 0.1
2658, 0.75726005592855, 0.78878186872725, 0.1
2659, 0.79059427365686, 0.8118365292342, 0.1
2660, 0.66874348929125, 0.042378573106499, 0.1
2661, 0.87101015116977, 0.037931064571752, 0.1
2662, 0.88850517919911, 0.030930252463062, 0.1
2663, 0.85375495327484, 0.027910641624104, 0.1
2664, 0.54387970784526, 0.87162118561833, 0.1
2665, 0.56369806098558, 0.87999934368425, 0.1
2666, 0.90924128217605, 0.6235052779877, 0.1
2667, 0.9019437155649, 0.51374225410526, 0.1
2668, 0.88498469818781, 0.50203127253063, 0.1
2669, 0.90339774389253, 0.49385358219814, 0.1
2670, 0.88664421331029, 0.48227934527549, 0.1
2671, 0.90457991046436, 0.47384052078498, 0.1
2672, 0.88810120926357, 0.46251347899998, 0.1
2673, 0.65663726261975, 0.14043051222928, 0.1
2674, 0.42628921136225, 0.66207666072243, 0.1
2675, 0.67542891814433, 0.13203215196632, 0.1
2676, 0.89310010979175, 0.80108633322603, 0.1
2677, 0.90470572162948, 0.041557599444151, 0.1
2678, 0.85287215161904, 0.047372593053533, 0.1
2679, 0.65891747354696, 0.12085605666016, 0.1
2680, 0.78932923381607, 0.20744272062108, 0.1
2681, 0.42555379681622, 0.6814014648651, 0.1
2682, 0.72006160755996, 0.82720290556671, 0.1
2683, 0.68383770425928, 0.053038788479478, 0.1
2684, 0.7016378193688, 0.045185040340375, 0.1
2685, 0.69481083522276, 0.31025493246315, 0.1
2686, 0.73679267705867, 0.029183420856464, 0.1
2687, 0.75557851177418, 0.019269908635487, 0.1
2688, 0.78457022757222, 0.26582865958367, 0.1
2689, 0.80073381588174, 0.2770796539784, 0.1
2690, 0.63750236007484, 0.15106610487156, 0.1
2691, 0.62447981549176, 0.1876306615512, 0.1
2692, 0.64257927498378, 0.18342823641874, 0.1
2693, 0.63725514076775, 0.20256431225606, 0.1
2694, 0.40079856561284, 0.51408580109967, 0.1
2695, 0.44515562131488, 0.47352586731116, 0.1
2696, 0.36861258960087, 0.53793461034252, 0.1
2697, 0.38626528117272, 0.54588205209153, 0.1
2698, 0.3716749023345, 0.55718692636457, 0.1
2699, 0.38858290788581, 0.56575026318085, 0.1
2700, 0.4037602869537, 0.55140183548259, 0.1
2701, 0.47789978068681, 0.44824727362325, 0.1
2702, 0.54917755946768, 0.35133264671168, 0.1
2703, 0.55785305960895, 0.36905627927261, 0.1
2704, 0.54575118940644, 0.38546873191172, 0.1
2705, 0.56757057157691, 0.38823369784843, 0.1
2706, 0.57943351771772, 0.36998791178374, 0.1
2707, 0.50206030480428, 0.41622736264232, 0.1
2708, 0.56968584955921, 0.31684728036847, 0.1
2709, 0.58943555442146, 0.31591675070729, 0.1
2710, 0.59853179935965, 0.2985974420518, 0.1
2711, 0.57966354172658, 0.33447879440413, 0.1
2712, 0.59817842925026, 0.33424104828936, 0.1
2713, 0.5709697365323, 0.35090421023578, 0.1
2714, 0.61073520310196, 0.22531872501035, 0.1
2715, 0.60321280499415, 0.24413889691258, 0.1
2716, 0.6154040849393, 0.25634358728207, 0.1
2717, 0.60918641889239, 0.27855759932802, 0.1
2718, 0.52610730916404, 0.3846414456433, 0.1
2719, 0.53394852340303, 0.40420565442242, 0.1
2720, 0.71734958028156, 0.056273463035132, 0.1
2721, 0.57904565651725, 0.90227787558973, 0.1
2722, 0.68971577870343, 0.36925460210631, 0.1
2723, 0.67079506372204, 0.86305030755505, 0.1
2724, 0.65452973463828, 0.85111002956985, 0.1
2725, 0.63277583637808, 0.87820155613093, 0.1
2726, 0.7494774046759, 0.84059459730382, 0.1
2727, 0.75319727949643, 0.82464609290308, 0.1
2728, 0.8304002316085, 0.82459192478667, 0.1
2729, 0.92169273990671, 0.48553840139699, 0.1
2730, 0.91214060663588, 0.15107437158735, 0.1
2731, 0.91430592734833, 0.13339024287639, 0.1
2732, 0.92016252017422, 0.5253816551724, 0.1
2733, 0.63124729295775, 0.22488720054759, 0.1
2734, 0.74913729446305, 0.078271051504346, 0.1
2735, 0.58842023594998, 0.28119779059191, 0.1
2736, 0.64297859686078, 0.10906422264938, 0.1
2737, 0.64574080643188, 0.089377644481138, 0.1
2738, 0.7190800221815, 0.036823352512728, 0.1
2739, 0.70235664555467, 0.026739025383621, 0.1
2740, 0.83377972936119, 0.075353763847649, 0.1
2741, 0.70585358009336, 0.17366623799089, 0.1
2742, 0.70734950115583, 0.15399325951526, 0.1
2743, 0.87037282305972, 0.47096638255235, 0.1
2744, 0.87200970801046, 0.45127424949432, 0.1
2745, 0.88946132812579, 0.44326905131488, 0.1
2746, 0.39423703058836, 0.61995732445236, 0.1
2747, 0.39655351328607, 0.59985574545721, 0.1
2748, 0.37636073113798, 0.59601273311209, 0.1
2749, 0.39485018906509, 0.64010214218526, 0.1
2750, 0.85153149184387, 0.06681025802231, 0.1
2751, 0.86707132522786, 0.51055837381778, 0.1
2752, 0.73318891921774, 0.067338814612181, 0.1
2753, 0.74737233954129, 0.097660158990091, 0.1
2754, 0.51816982555353, 0.78827829079252, 0.1
2755, 0.78577022593682, 0.043329505791251, 0.1
2756, 0.53583569063573, 0.78010393681877, 0.1
2757, 0.50288434938179, 0.77712419828039, 0.1
2758, 0.84848669352623, 0.10579664611874, 0.1
2759, 0.45879505691363, 0.68440872729387, 0.1
2760, 0.47637920807229, 0.67636616812295, 0.1
2761, 0.92122319818326, 0.089989749169059, 0.1
2762, 0.90391222266666, 0.079451268172042, 0.1
2763, 0.4929310307954, 0.48089050615282, 0.1
2764, 0.701102858586, 0.23208032152697, 0.1
2765, 0.81459234990101, 0.1031375667104, 0.1
2766, 0.85875969231085, 0.60922290582159, 0.1
2767, 0.91182069845491, 0.56427661089722, 0.1
2768, 0.92233515875922, 0.18847275466172, 0.1
2769, 0.90517473950768, 0.19846113277831, 0.1
2770, 0.90514941703097, 0.21828318912326, 0.1
2771, 0.8880266324344, 0.20834914860104, 0.1
2772, 0.88789705068582, 0.22903432923965, 0.1
2773, 0.88829543898444, 0.18899007339641, 0.1
2774, 0.87134873743981, 0.19916371282168, 0.1
2775, 0.9050836584425, 0.238069171068, 0.1
2776, 0.88796503347595, 0.24958679241617, 0.1
2777, 0.79507339412747, 0.75303095237501, 0.1
2778, 0.77881853148508, 0.74172094641022, 0.1
2779, 0.55193868728652, 0.79138409933689, 0.1
2780, 0.65146984208034, 0.819331338756, 0.1
2781, 0.81686204851358, 0.28842010708781, 0.1
2782, 0.79905192462558, 0.29686791276264, 0.1
2783, 0.79740075486908, 0.31652464270829, 0.1
2784, 0.78121044667185, 0.30526693887271, 0.1
2785, 0.77956016093643, 0.32491123094909, 0.1
2786, 0.79574400840495, 0.33616951872326, 0.1
2787, 0.47966764512661, 0.63721348503297, 0.1
2788, 0.4813186838975, 0.61768427107884, 0.1
2789, 0.69139801445773, 0.14316507765132, 0.1
2790, 0.85544154396673, 0.64872211199918, 0.1
2791, 0.90518531045831, 0.17866319871747, 0.1
2792, 0.87087460509625, 0.21820805903314, 0.1
2793, 0.85448525675034, 0.20943531663696, 0.1
2794, 0.60702107711303, 0.74665715837101, 0.1
2795, 0.50895216470405, 0.49212196679405, 0.1
2796, 0.52668301985793, 0.48376455467306, 0.1
2797, 0.76334362120946, 0.10871899203951, 0.1
2798, 0.81192662254519, 0.34751305302082, 0.1
2799, 0.79414284493005, 0.35592154103113, 0.1
2800, 0.79244011946315, 0.37561331518891, 0.1
2801, 0.77622279039685, 0.36435423883372, 0.1
2802, 0.77457276799698, 0.3840125005558, 0.1
2803, 0.79076866122053, 0.39527628867019, 0.1
2804, 0.53163785546595, 0.83734827634132, 0.1
2805, 0.86337811725559, 0.75877952433083, 0.1
2806, 0.79375764860312, 0.56428530881987, 0.1
2807, 0.77752962024431, 0.55300420549523, 0.1
2808, 0.77918829446903, 0.53333813554561, 0.1
2809, 0.76128896677104, 0.54181139699439, 0.1
2810, 0.75966233690797, 0.56140652572605, 0.1
2811, 0.79705373771925, 0.52488543656274, 0.1
2812, 0.78081000951963, 0.51361770404272, 0.1
2813, 0.79869734576781, 0.50517203146056, 0.1
2814, 0.7824761762084, 0.49386860276897, 0.1
2815, 0.78418776846107, 0.47414858136774, 0.1
2816, 0.76626684910985, 0.48256926815734, 0.1
2817, 0.76459929576238, 0.50230277448758, 0.1
2818, 0.69153439640946, 0.55625158658588, 0.1
2819, 0.67536167927428, 0.54499836494828, 0.1
2820, 0.67701024331236, 0.52537152355215, 0.1
2821, 0.65919557983323, 0.5337531849115, 0.1
2822, 0.66084051591867, 0.51413994475741, 0.1
2823, 0.64304145731815, 0.52253294512557, 0.1
2824, 0.64468943478715, 0.50292884975931, 0.1
2825, 0.64138803328218, 0.54212749561438, 0.1
2826, 0.66248394868162, 0.49453748250783, 0.1
2827, 0.64626086237052, 0.48336412416144, 0.1
2828, 0.66411292688425, 0.47494164053528, 0.1
2829, 0.6251454463054, 0.53103947921601, 0.1
2830, 0.62351644449311, 0.55055987989455, 0.1
2831, 0.64775686950448, 0.46393337148647, 0.1
2832, 0.66557617211793, 0.4554579636186, 0.1
2833, 0.62837802070959, 0.49194858233703, 0.1
2834, 0.63971823263089, 0.56175721482785, 0.1
2835, 0.62190965818973, 0.57011372123295, 0.1
2836, 0.60567110722862, 0.55895781452382, 0.1
2837, 0.60410613304083, 0.57847115787946, 0.1
2838, 0.58788081969478, 0.56732397798902, 0.1
2839, 0.58632354759697, 0.58684719156147, 0.1
2840, 0.57009135914758, 0.57580361152604, 0.1
2841, 0.60247763578867, 0.59803893926594, 0.1
2842, 0.58466533667392, 0.60649386459573, 0.1
2843, 0.68028088954644, 0.48615403072815, 0.1
2844, 0.65588445211588, 0.57301586602992, 0.1
2845, 0.80698764755596, 0.40660744053212, 0.1
2846, 0.7891690223913, 0.41502508791546, 0.1
2847, 0.78747116488077, 0.43472230436307, 0.1
2848, 0.77124677097399, 0.42345926159499, 0.1
2849, 0.76959671891961, 0.44312642763614, 0.1
2850, 0.78586032528119, 0.45443561645452, 0.1
2851, 0.79045632086044, 0.60370132034677, 0.1
2852, 0.77257464157896, 0.61212446351856, 0.1
2853, 0.77092247614444, 0.63181794508742, 0.1
2854, 0.75470879461327, 0.62056327555246, 0.1
2855, 0.75304630890726, 0.6402265483057, 0.1
2856, 0.7368246730124, 0.62900958285287, 0.1
2857, 0.73518069851889, 0.64863738094373, 0.1
2858, 0.71893872396292, 0.63743358712732, 0.1
2859, 0.71731845664608, 0.65704178777204, 0.1
2860, 0.75139640691928, 0.65992763321799, 0.1
2861, 0.70108853501772, 0.6458752606351, 0.1
2862, 0.75635003889091, 0.6009216789428, 0.1
2863, 0.69946426457883, 0.66550631953378, 0.1
2864, 0.71566981338408, 0.67676264286117, 0.1
2865, 0.68162341543532, 0.6739551508786, 0.1
2866, 0.77423338153976, 0.59246215065224, 0.1
2867, 0.5072849901434, 0.511679714747, 0.1
2868, 0.5815393924514, 0.43911894840718, 0.1
2869, 0.58489448559167, 0.40047549360009, 0.1
2870, 0.56717044688882, 0.40898527917857, 0.1
2871, 0.50379793130747, 0.75763749702627, 0.1
2872, 0.48493299979898, 0.76848055912078, 0.1
2873, 0.7758888852961, 0.57274339178883, 0.1
2874, 0.60134718046345, 0.37131726323764, 0.1
2875, 0.6277130339829, 0.30555222903121, 0.1
2876, 0.92231402341225, 0.26799328263864, 0.1
2877, 0.90529498539958, 0.27791842937172, 0.1
2878, 0.90513712958567, 0.2977108318402, 0.1
2879, 0.88796584993776, 0.28783418248349, 0.1
2880, 0.88807565301391, 0.30801821132947, 0.1
2881, 0.87547919977335, 0.32277572864686, 0.1
2882, 0.88421681902624, 0.33921355345836, 0.1
2883, 0.87714506992678, 0.3571662639854, 0.1
2884, 0.89519274615412, 0.35686200381123, 0.1
2885, 0.88834817443702, 0.37337444040947, 0.1
2886, 0.90425165336046, 0.3384917352788, 0.1
2887, 0.92225401179632, 0.3076169617558, 0.1
2888, 0.90531373398004, 0.25828146317284, 0.1
2889, 0.50234062689011, 0.57031778838724, 0.1
2890, 0.51179543675532, 0.43307386199084, 0.1
2891, 0.80202127998703, 0.46573465897339, 0.1
2892, 0.86207759507198, 0.56972334431853, 0.1
2893, 0.92330685776226, 0.34754522941058, 0.1
2894, 0.69483797373445, 0.51696540192415, 0.1
2895, 0.56805882951268, 0.80264695532769, 0.1
2896, 0.47280990570707, 0.73433142491402, 0.1
2897, 0.92275509915023, 0.38710109371399, 0.1
2898, 0.90600774683221, 0.39734235641584, 0.1
2899, 0.90587684759466, 0.41656591452395, 0.1
2900, 0.89013942752544, 0.40549089096432, 0.1
2901, 0.92275255795752, 0.42653279418034, 0.1
2902, 0.61529275045479, 0.64867916081022, 0.1
2903, 0.59913295258854, 0.63745541228187, 0.1
2904, 0.58133210761416, 0.64583472350049, 0.1
2905, 0.5829798057648, 0.62622851913885, 0.1
2906, 0.60079048586551, 0.61780135965093, 0.1
2907, 0.5668594422983, 0.61491408995259, 0.1
2908, 0.54245461401035, 0.70177218132861, 0.1
2909, 0.52632761763986, 0.69054407939309, 0.1
2910, 0.50854948731772, 0.69893071400782, 0.1
2911, 0.69978768531073, 0.45807334579177, 0.1
2912, 0.70130225002955, 0.43853631145099, 0.1
2913, 0.68335216811619, 0.44705130130955, 0.1
2914, 0.61694695614231, 0.62904962752432, 0.1
2915, 0.494099110441, 0.66808569599123, 0.1
2916, 0.71465449903901, 0.28159701426556, 0.1
2917, 0.6966268385319, 0.2902387365157, 0.1
2918, 0.67856846807941, 0.29906102592226, 0.1
2919, 0.71607806321623, 0.26211818779426, 0.1
2920, 0.56051786947824, 0.48658995002208, 0.1
2921, 0.92301221542738, 0.76427781602901, 0.1
2922, 0.92232128037705, 0.22826911369854, 0.1
2923, 0.78715383458493, 0.64310500679109, 0.1
2924, 0.71892999242559, 0.22315453456751, 0.1
2925, 0.72021246514661, 0.2035969755865, 0.1
2926, 0.45601885776552, 0.5172997897089, 0.1
2927, 0.76093802039835, 0.7501273404862, 0.1
2928, 0.74307211093887, 0.75851461541978, 0.1
2929, 0.67166518548326, 0.79183020484324, 0.1
2930, 0.69796833692579, 0.27076950415196, 0.1
2931, 0.48624773908596, 0.5591139395557, 0.1
2932, 0.79672540393279, 0.73329764612525, 0.1
2933, 0.42816850973517, 0.64254202980328, 0.1
2934, 0.72398389337114, 0.16452622142022, 0.1
2935, 0.72510661483049, 0.14510850780402, 0.1
2936, 0.92207961217714, 0.70536444269179, 0.1
2937, 0.9223100406487, 0.72457532773563, 0.1
2938, 0.56544399191307, 0.42803855460754, 0.1
2939, 0.77377522357855, 0.79950825482805, 0.1
2940, 0.52338041112574, 0.52287703466188, 0.1
2941, 0.84546597486204, 0.76712375097079, 0.1
2942, 0.82921434482775, 0.75587321039035, 0.1
2943, 0.41535098062788, 0.59248132346769, 0.1
2944, 0.76761808272101, 0.6712307177952, 0.1
2945, 0.74974483680184, 0.67963240181137, 0.1
2946, 0.78049020792284, 0.72196199433387, 0.1
2947, 0.81129759246993, 0.76431087812414, 0.1
2948, 0.84693567005238, 0.12532405088771, 0.1
2949, 0.57968216271336, 0.66544407981848, 0.1
2950, 0.69649398728233, 0.49733851247793, 0.1
2951, 0.54079966030434, 0.72136565030658, 0.1
2952, 0.55361377378522, 0.77176525831585, 0.1
2953, 0.64429838827856, 0.71037476989619, 0.1
2954, 0.65581651189579, 0.36652392936505, 0.1
2955, 0.70437660339506, 0.60671271193, 0.1
2956, 0.59251170435023, 0.71585402210667, 0.1
2957, 0.62813349688467, 0.69912819033575, 0.1
2958, 0.80368295939095, 0.44600746220902, 0.1
2959, 0.65754318377227, 0.55337713374802, 0.1
2960, 0.76927285452962, 0.65152090169999, 0.1
2961, 0.73353137414972, 0.66834119074532, 0.1
2962, 0.80972929234209, 0.16137904701463, 0.1
2963, 0.80864514223609, 0.38689521959477, 0.1
2964, 0.9028454321617, 0.70162052080087, 0.1
2965, 0.45318749209773, 0.75429142330834, 0.1
2966, 0.43485376734592, 0.72074892555822, 0.1
2967, 0.67665790902825, 0.73294280264349, 0.1
2968, 0.54441578188362, 0.47539368388334, 0.1
2969, 0.58083008064108, 0.8529379364718, 0.1
2970, 0.8135472866897, 0.32780318767323, 0.1
2971, 0.71401951526114, 0.6964702844139, 0.1
2972, 0.46523795149359, 0.60648320481358, 0.1
2973, 0.4738751113326, 0.78668094303524, 0.1
2974, 0.68191835549969, 0.46655323513467, 0.1
2975, 0.5474010472108, 0.64302901615047, 0.1
2976, 0.72687976009738, 0.7471325965616, 0.1
2977, 0.5733419763388, 0.53689064003139, 0.1
2978, 0.60538573941504, 0.76626841491829, 0.1
2979, 0.63480463084474, 0.41400612851768, 0.1
2980, 0.49358945651282, 0.82315975665194, 0.1
2981, 0.56519160217879, 0.63461258843826, 0.1
2982, 0.65747923548641, 0.34696451997706, 0.1
2983, 0.52264361548178, 0.8724765013846, 0.1
2984, 0.67864467900507, 0.50576215255377, 0.1
2985, 0.81856942867292, 0.26872736975892, 0.1
2986, 0.72167286029636, 0.80636003878213, 0.1
2987, 0.46853498191114, 0.56744089882202, 0.1
2988, 0.86506399264611, 0.73899206582625, 0.1
2989, 0.81796973811965, 0.68539719601799, 0.1
2990, 0.66873287564451, 0.62352583780884, 0.1
2991, 0.68324253662231, 0.24057019436103, 0.1
2992, 0.85787610044881, 0.40095560050677, 0.1
2993, 0.59085989649286, 0.73543796987026, 0.1
2994, 0.61817790384193, 0.81678027067889, 0.1
2995, 0.67764245313181, 0.11231193602394, 0.1
2996, 0.71086707094989, 0.32141918569419, 0.1
2997, 0.83421362621987, 0.69668854338671, 0.1
2998, 0.85213579520724, 0.68824873911633, 0.1
2999, 0.4846100103792, 0.5786365396562, 0.1
3000, 0.84124472120861, 0.18277532606405, 0.1
3001, 0.77610280900388, 0.15876467562149, 0.1
3002, 0.87658962335386, 0.16562862403679, 0.1
3003, 0.49245391924591, 0.68768097706718, 0.1
3004, 0.65090608222625, 0.42514493246376, 0.1
3005, 0.76503974793257, 0.089338462165851, 0.1
3006, 0.66543745866292, 0.66275128184928, 0.1
3007, 0.48297189262745, 0.59816520918498, 0.1
3008, 0.85378658317038, 0.66850205167528, 0.1
3009, 0.67357246707789, 0.35813450940684, 0.1
3010, 0.89909977391089, 0.11992672260575, 0.1
3011, 0.86885618924035, 0.28288775611888, 0.1
3012, 0.62026129644686, 0.58973742146914, 0.1
3013, 0.81519388164851, 0.016280119945739, 0.1
3014, 0.49907005947063, 0.60938107272856, 0.1
3015, 0.83220155108204, 0.094810510961022, 0.1
3016, 0.58028703133644, 0.87057566801809, 0.1
3017, 0.8391708622826, 0.63752865141641, 0.1
3018, 0.49741478525159, 0.62892141921743, 0.1
3019, 0.8571251112315, 0.62903332350245, 0.1
3020, 0.69130100015659, 0.34957569839194, 0.1
3021, 0.79375125104067, 0.15039913392803, 0.1
3022, 0.70593420553325, 0.38022603964186, 0.1
3023, 0.55068184607361, 0.60385117458349, 0.1
3024, 0.47801974693916, 0.65679909629407, 0.1
3025, 0.84246771175802, 0.59808928862919, 0.1
3026, 0.86045083112579, 0.5895500005947, 0.1
3027, 0.68643230445476, 0.40819301616487, 0.1
3028, 0.60890044473187, 0.52006330354374, 0.1
3029, 0.68325390089098, 0.65433324881882, 0.1
3030, 0.81614197566787, 0.083764817748781, 0.1
3031, 0.62678312053035, 0.51151422159612, 0.1
3032, 0.60866410511359, 0.72706767112368, 0.1
3033, 0.55393430624443, 0.56471784226398, 0.1
3034, 0.56849226206105, 0.59536135844647, 0.1
3035, 0.63149295912689, 0.45294311145893, 0.1
3036, 0.61213836448327, 0.48094445145418, 0.1
3037, 0.84574478578654, 0.55867324614768, 0.1
3038, 0.68489679547283, 0.6347140037084, 0.1
3039, 0.8474273436602, 0.53892640858609, 0.1
3040, 0.86546042383295, 0.5303705827728, 0.1
3041, 0.62648186630241, 0.71871572152082, 0.1
3042, 0.76261526342804, 0.73037561859648, 0.1
3043, 0.85076867842891, 0.49943914067238, 0.1
3044, 0.72522865483081, 0.76683504342573, 0.1
3045, 0.73849932481092, 0.60940448290667, 0.1
3046, 0.796765625, 0.016431467037307, 0.1
3047, 0.65885504296611, 0.74122992291439, 0.1
3048, 0.86876667342409, 0.49084095308735, 0.1
3049, 0.74135912939017, 0.77804892881935, 0.1
3050, 0.79199338638252, 0.16961414841338, 0.1
3051, 0.64265200586584, 0.72995428479063, 0.1
3052, 0.73907699706121, 0.7969495783162, 0.1
3053, 0.8540089882325, 0.460036705668, 0.1
3054, 0.65719528011837, 0.76084140601122, 0.1
3055, 0.39998989530533, 0.58113220059478, 0.1
3056, 0.75804277104124, 0.58130799302782, 0.1
3057, 0.92153651141727, 0.05011038055075, 0.1
3058, 0.85559089779451, 0.44039007450399, 0.1
3059, 0.43815529071894, 0.50449786681995, 0.1
3060, 0.67334923856741, 0.77218399215943, 0.1
3061, 0.87261015125014, 0.43217147730127, 0.1
3062, 0.74334454094551, 0.55056581366332, 0.1
3063, 0.65371277331757, 0.80006389457619, 0.1
3064, 0.74500836603012, 0.53091359960345, 0.1
3065, 0.74012527377957, 0.5898107038986, 0.1
3066, 0.70272679542248, 0.62629144838357, 0.1
3067, 0.76303248141775, 0.52222488372125, 0.1
3068, 0.71547631754315, 0.075572362247037, 0.1
3069, 0.63397074226472, 0.82734037622706, 0.1
3070, 0.72060055294433, 0.61785916072413, 0.1
3071, 0.74831680401716, 0.49149352141326, 0.1
3072, 0.75005135004671, 0.47176363470835, 0.1
3073, 0.76806412545754, 0.46295883310437, 0.1
3074, 0.90529808642382, 0.31718950216373, 0.1
3075, 0.75319702046776, 0.43259781279668, 0.1
3076, 0.57169412178971, 0.55630680442055, 0.1
3077, 0.75498558859493, 0.4127973147257, 0.1
3078, 0.77304986377398, 0.40386623712487, 0.1
3079, 0.5894701734781, 0.54792627950086, 0.1
3080, 0.60725039207361, 0.53951729566803, 0.1
3081, 0.75811879107046, 0.37366399289586, 0.1
3082, 0.75993901705733, 0.35383403858609, 0.1
3083, 0.77804669525858, 0.34478878168933, 0.1
3084, 0.76305196752198, 0.31476168944586, 0.1
3085, 0.78274293295768, 0.28600471303756, 0.1
3086, 0.76463559700064, 0.29525874529199, 0.1
3087, 0.77265875605683, 0.19759176253867, 0.1
3088, 0.92215199803898, 0.46541279903349, 0.1
3089, 0.78784062341371, 0.22710954472966, 0.1
3090, 0.62996149665421, 0.47243078735675, 0.1
3091, 0.7693147761411, 0.23683531054247, 0.1
3092, 0.76798260476828, 0.25591266768519, 0.1
3093, 0.83837565852602, 0.22033424202793, 0.1
3094, 0.64929398568128, 0.4445109505433, 0.1
3095, 0.66707394452747, 0.43609839402882, 0.1
3096, 0.60951630855355, 0.31516319643473, 0.1
3097, 0.34550033616158, 0.56816724680389, 0.1
3098, 0.68495001689191, 0.42761822827399, 0.1
3099, 0.66450766053729, 0.014588529253401, 0.1
3100, 0.70429020753604, 0.39963356475661, 0.1
3101, 0.78844491264483, 0.83121314394644, 0.1
3102, 0.92404209626543, 0.80349565452295, 0.1
3103, 0.54097695994279, 0.9065330635938, 0.1
3104, 0.70925946495072, 0.34093438792304, 0.1
3105, 0.6802009815748, 0.27944753570294, 0.1
3106, 0.90382375257308, 0.060092128883829, 0.1
3107, 0.41079246775088, 0.65041219828822, 0.1
3108, 0.44113740227791, 0.69230120852997, 0.1
3109, 0.69961880710347, 0.2513665908722, 0.1
3110, 0.70397078118157, 0.19311254750993, 0.1
3111, 0.83665224957137, 0.037530668510426, 0.1
3112, 0.47750388047658, 0.46978725000544, 0.1
3113, 0.90387701404609, 0.6812521132607, 0.1
3114, 0.88800315883396, 0.26912677787429, 0.1
3115, 0.40119701482217, 0.53318685307963, 0.1
3116, 0.7091315584798, 0.13451582772007, 0.1
3117, 0.50142614395272, 0.7957533823263, 0.1
3118, 0.88907253113414, 0.81931105499349, 0.1
3119, 0.68601650631862, 0.034948601882934, 0.1
3120, 0.87594742601051, 0.39066124423249, 0.1
3121, 0.77061102855569, 0.03283636951472, 0.1
3122, 0.79028606160374, 0.18851743130517, 0.1
3123, 0.91052286105064, 0.014150409097313, 0.1
3124, 0.90560398287868, 0.45451773785158, 0.1
3125, 0.71156722388703, 0.84888350614517, 0.1
3126, 0.80799535385763, 0.1803108058957, 0.1
3127, 0.73738332269511, 0.81525913329262, 0.1
3128, 0.82381719700393, 0.19099565706282, 0.1
3129, 0.3730311154047, 0.57547192985433, 0.1
3130, 0.90544972579521, 0.37546897077721, 0.1
3131, 0.45526028495827, 0.72249820689754, 0.1
3132, 0.92198948706964, 0.66672822067839, 0.1
3133, 0.84954604297754, 0.82384871256892, 0.1
3134, 0.58930094013728, 0.35314022791616, 0.1
3135, 0.87099970649938, 0.24013264774333, 0.1
3136, 0.90623878699077, 0.4355627150228, 0.1
3137, 0.50156090876751, 0.83945722789402, 0.1
3138, 0.47076436774771, 0.75298030641116, 0.1
3139, 0.63266054550687, 0.26617946778341, 0.1
3140, 0.52899046349128, 0.85486076684372, 0.1
3141, 0.90318519405858, 0.6422117037496, 0.1
3142, 0.891921875, 0.013958511503488, 0.1
3143, 0.68251379003436, 0.83833253488113, 0.1
3144, 0.42048921543791, 0.55498808399694, 0.1
3145, 0.65513088346415, 0.19716828151668, 0.1
3146, 0.85945113832501, 0.36142285880363, 0.1
3147, 0.88936058693834, 0.42418519223057, 0.1
3148, 0.7721048833053, 0.81797949317926, 0.1
3149, 0.41590880905273, 0.49939661671191, 0.1
3150, 0.83869896573972, 0.20112924203063, 0.1
3151, 0.5872077123473, 0.38442691909575, 0.1
3152, 0.87283104602175, 0.41220416727505, 0.1
3153, 0.9265643909679, 0.62466409669319, 0.1
3154, 0.73876599546836, 0.012984772829953, 0.1
3155, 0.46064009522324, 0.48012968334595, 0.1
3156, 0.61441258244936, 0.29419751280959, 0.1
3157, 0.49763654366162, 0.44526296876749, 0.1
3158, 0.87445164590904, 0.80682484485234, 0.1
3159, 0.90910783739184, 0.7940024157835, 0.1
3160, 0.55266773469835, 0.40091797013433, 0.1
3161, 0.88998654309441, 0.32389318644613, 0.1
3162, 0.51827535478581, 0.41619541232913, 0.1
3163, 0.39521912602027, 0.65612776759828, 0.1
3164, 0.85630729930601, 0.19189824147827, 0.1
3165, 0.55031985969067, 0.8918425854509, 0.1
3166, 0.90618395099703, 0.60329644526045, 0.1
3167, 0.64798682069052, 0.83553240031825, 0.1
3168, 0.65763498630608, 0.17886328173898, 0.1
3169, 0.36239464657076, 0.60316593746334, 0.1
3170, 0.82264797359248, 0.030238359487987, 0.1
3171, 0.90978451464559, 0.77379088958304, 0.1
3172, 0.33742914820572, 0.55509118326192, 0.1
3173, 0.92474173799121, 0.81916873230622, 0.1
3174, 0.54824074083539, 0.92021659701698, 0.1
3175, 0.75496982249961, 0.80648439587723, 0.1
3176, 0.87380898036881, 0.18241691684757, 0.1
3177, 0.64870662363604, 0.013833098900193, 0.1
3178, 0.63936009412262, 0.86204693379383, 0.1
3179, 0.85391704231269, 0.011879309992773, 0.1
3180, 0.41128479741056, 0.68829227229235, 0.1
3181, 0.48973902681474, 0.78636144057911, 0.1
3182, 0.82227108390011, 0.81041949479679, 0.1
3183, 0.92873518520582, 0.58513624771906, 0.1
3184, 0.78727979149922, 0.027778024090452, 0.1
3185, 0.38134475403565, 0.63202105581367, 0.1
3186, 0.87197847482296, 0.37277015688535, 0.1
3187, 0.89181735504424, 0.38888418269871, 0.1
3188, 0.92592675590692, 0.013503705600606, 0.1
3189, 0.70174825294685, 0.011354730761673, 0.1
3190, 0.56493810911948, 0.89544135414117, 0.1
3191, 0.91053118656537, 0.75374408814753, 0.1
3192, 0.91081364913355, 0.35727055211091, 0.1
3193, 0.61893970532533, 0.23877763898296, 0.1
3194, 0.58297608587322, 0.88718452172379, 0.1
3195, 0.92769654563422, 0.14828079202896, 0.1
3196, 0.89123304495581, 0.17308377684679, 0.1
3197, 0.61777391237234, 0.88985770783708, 0.1
3198, 0.67311056364951, 0.027362729377111, 0.1
3199, 0.38562482031107, 0.58392744626788, 0.1
3200, 0.44246920115305, 0.70691272927021, 0.1
3201, 0.67177577298482, 0.84765158231483, 0.1
3202, 0.90312625252196, 0.026416362304705, 0.1
3203, 0.64403632573745, 0.16815725522624, 0.1
3204, 0.92770870320039, 0.56675685353629, 0.1
3205, 0.85969709645125, 0.32166538948605, 0.1
3206, 0.4459787380173, 0.48902868757342, 0.1
3207, 0.91161162572226, 0.73523609685207, 0.1
3208, 0.73707387764024, 0.83120762154201, 0.1
3209, 0.59449251683062, 0.87792139586307, 0.1
3210, 0.90855453170544, 0.16474331916194, 0.1
3211, 0.36055180614052, 0.56754326720154, 0.1
3212, 0.92915329610107, 0.1290345540267, 0.1
3213, 0.61421682163212, 0.3335280417904, 0.1
3214, 0.40498274362167, 0.56669114763119, 0.1
3215, 0.50232255897313, 0.81033402758182, 0.1
3216, 0.51696193322239, 0.84162690403129, 0.1
3217, 0.38506251183424, 0.60693519120705, 0.1
3218, 0.85705127183491, 0.81204297986646, 0.1
3219, 0.6265307712381, 0.86383244937208, 0.1
3220, 0.41095979616961, 0.524056796176, 0.1
3221, 0.45830215024631, 0.74003880294629, 0.1
3222, 0.83526934217005, 0, 0.082334942096126
3223, 0.77881022425454, 0, 0.015702614638775
3224, 0.70188538317662, 0, 0.082406548728514
3225, 0.87261461682338, 0, 0.017593451271486
3226, 0.73907255419789, 0, 0.018175548160309
3227, 0.815796875, 0, 0.016481545965772
3228, 0.79668010426624, 0, 0.083595129824201
3229, 0.89232536769978, 0, 0.084064923389097
3230, 0.75821297073808, 0, 0.083782700298456
3231, 0.68242466971277, 0, 0.016039679027361
3232, 0.65210280134577, 0, 0.04975809328482
3233, 0.92239719865423, 0, 0.05024190671518
3234, 0.91067812499166, 0, 0.014390144194509
3235, 0.66382187500834, 0, 0.085609855805491
3236, 0.92051814751705, 0, 0.070441184768798
3237, 0.9041572332211, 0, 0.058655328143929
3238, 0.90463008019235, 0, 0.041374074385731
3239, 0.88798981454108, 0, 0.049809806175159
3240, 0.88843413405502, 0, 0.03178026516324
3241, 0.8717906669673, 0, 0.040737620185094
3242, 0.87187132958727, 0, 0.059851784040526
3243, 0.85480329617031, 0, 0.049603204640809
3244, 0.8551140946778, 0, 0.029747302589778
3245, 0.83910222009346, 0, 0.038720322177872
3246, 0.83759437621358, 0, 0.057943551311827
3247, 0.82209405533472, 0, 0.047451052425278
3248, 0.82016326142294, 0, 0.066274653836279
3249, 0.80509697967431, 0, 0.054715443960311
3250, 0.85411446898843, 0, 0.069595078802592
3251, 0.80593075983945, 0, 0.034170059448678
3252, 0.78871452804455, 0, 0.044682511012341
3253, 0.78768793477022, 0, 0.065561862320473
3254, 0.77184413201769, 0, 0.052481874916896
3255, 0.87216084643055, 0, 0.081227899619701
3256, 0.83734072348155, 0, 0.018613161384859
3257, 0.65398185248295, 0, 0.029558815231202
3258, 0.6703427667789, 0, 0.041344671856071
3259, 0.66986991980765, 0, 0.058625925614269
3260, 0.68651018545892, 0, 0.050190193824841
3261, 0.68606586594498, 0, 0.06821973483676
3262, 0.7027093330327, 0, 0.059262379814906
3263, 0.70366472119185, 0, 0.040535395262346
3264, 0.71981259278388, 0, 0.050991301081708
3265, 0.71940558660981, 0, 0.070352033384071
3266, 0.73539910340344, 0, 0.061279709362645
3267, 0.73718558369743, 0, 0.040853541180186
3268, 0.72155644516038, 0, 0.03067794796499
3269, 0.75411202337265, 0, 0.033084889429876
3270, 0.70326757555585, 0, 0.019567797657309
3271, 0.73711185237263, 0, 0.081424246268608
3272, 0.75335977625775, 0, 0.052841623570311
3273, 0.79703513319221, 0, 0.015908172217173
3274, 0.77771141829576, 0, 0.083697805448331
3275, 0.81555617157122, 0, 0.083984628823121
3276, 0.9205868875139, 0, 0.02956333033598
3277, 0.6539131124861, 0, 0.07043666966402
3278, 0.77175712818478, 0, 0.033165821420023
3279, 0.66429535317449, 0, 0.014439399076615
3280, 0.9102463197276, 0, 0.085578034659461
3281, 0.75946328061308, 0, 0.015529411055736
3282, 0.76776042097241, 0, 0.068911483907132
3283, 0.89240632454729, 0, 0.014695953424193
3284, 0.68209367545271, 0, 0.085304046575807
3285, 0.68732586626164, 0, 0.032786037400254
3286, 0.88775123061042, 0, 0.067524265666601
3287, 0.72103556498282, 0, 0.013684258756521
3288, 0.82456997491349, 0, 0.030618610642664
3289, 0.74993196716624, 0, 0.069380230558546
3290, 0.85455763699655, 0, 0.013190783049225
3291, 0.71993681443181, 0, 0.086836565676239
3292, 0.80552667438878, 0, 0.07069248224848
3293, 0.85385459394129, 0, 0.086985288218615
3294, 0.78822182975205, 0, 0.028998765378503
3295, 0.92556927560742, 0, 0.086046268845121
3296, 0.64893289395224, 0, 0.013954638783788
3297, 0.64860855190555, 0, 0.086419115332183
3298, 0.92589144809445, 0, 0.013580884667817
3299, 0.76276826495822, 0, 0.042893552334277
3300, 0.90334711026004, 0, 0.026360753500731
3301, 0.67115288973996, 0, 0.073639246499269
3302, 0.67167410168215, 0, 0.026833720518301
3303, 0.90299965975519, 0, 0.073252747325577
3304, 0.39105114485177, 0.50030390974898, 0.015884235977567
3305, 0.53467609824405, 0.34255871024762, 0.016936848387767
3306, 0.46262722525553, 0.43497247091324, 0.083063190566058
3307, 0.60801082300432, 0.18316069204283, 0.016936848387767
3308, 0.42230165210417, 0.47422179898238, 0.018109151776522
3309, 0.48852707157413, 0.405667721589, 0.016936848387767
3310, 0.57274721267175, 0.27419998245212, 0.01650862171448
3311, 0.61813316451904, 0.14538359921834, 0.016936848387767
3312, 0.62627129292075, 0.10492505736654, 0.018709382638713
3313, 0.51257376884661, 0.37482413408209, 0.016936848387767
3314, 0.63131384771681, 0.068321487696012, 0.017659623100202
3315, 0.55475021806044, 0.30899384388995, 0.016936848387768
3316, 0.58851721944961, 0.23847952199571, 0.083063128938143
3317, 0.33224508380515, 0.54114527096456, 0.049758116747832
3318, 0.43497253505719, 0.46262716494595, 0.083063018203928
3319, 0.54497162745177, 0.32593085965059, 0.083063151612226
3320, 0.63323645520144, 0.047292618915731, 0.08188527630613
3321, 0.37483934132634, 0.51256264806757, 0.082372771716718
3322, 0.52387339758232, 0.35886162138846, 0.083063190565939
3323, 0.60208201190202, 0.20179754940042, 0.083063190565825
3324, 0.44864940843835, 0.44937590979926, 0.015701643569705
3325, 0.40402266212798, 0.48988844494132, 0.081365188749394
3326, 0.59558208817849, 0.22024299362512, 0.016936848387767
3327, 0.61336289969353, 0.16435009364019, 0.083063151612205
3328, 0.56400259546981, 0.29176372684643, 0.083063190565987
3329, 0.62880629050196, 0.088474001973229, 0.084168807470914
3330, 0.6222624359996, 0.12654825460605, 0.083168020507231
3331, 0.50078793405511, 0.39043110161054, 0.083063174286459
3332, 0.63476851312662, 0.017144525161667, 0.050247290650164
3333, 0.35759944297646, 0.52473577959095, 0.018111508180578
3334, 0.63423787125111, 0.031101811375869, 0.018280346515443
3335, 0.34406111891354, 0.53371054556938, 0.081742595417462
3336, 0.63478331179892, 0.016587557433203, 0.069793973005913
3337, 0.6339965689932, 0.035684037115398, 0.063522820682952
3338, 0.63407294204219, 0.034300206558627, 0.040396507165802
3339, 0.63290710981667, 0.051513011400071, 0.05012489349324
3340, 0.63298739450714, 0.050516911970791, 0.030318356401181
3341, 0.63129823472509, 0.068465603283617, 0.040332567455614
3342, 0.63130534733815, 0.068399988466813, 0.05978859540002
3343, 0.62928605225401, 0.084994496519246, 0.048717027436637
3344, 0.62915005608861, 0.085995388967645, 0.029851317775743
3345, 0.62672698956842, 0.10216790370023, 0.039316986251857
3346, 0.62692396350277, 0.10095218663298, 0.056606753276277
3347, 0.62394491043578, 0.11797350864195, 0.046827697044399
3348, 0.33177102366098, 0.54143604226071, 0.030199123903362
3349, 0.34793873542321, 0.53119077212627, 0.036493290393237
3350, 0.34682225662773, 0.5319204097491, 0.059712430182084
3351, 0.36114326496764, 0.5223031133054, 0.049919292653436
3352, 0.36028909632148, 0.52289269173689, 0.069730794260997
3353, 0.37503246324051, 0.51242136129923, 0.059755495650978
3354, 0.37496840870059, 0.51246823557812, 0.040261068100826
3355, 0.38834483811825, 0.50240749069546, 0.05139397703413
3356, 0.38909772951657, 0.5018246276191, 0.070239518590498
3357, 0.40192076554382, 0.49161437959509, 0.060843848578948
3358, 0.40090197393254, 0.49244553739169, 0.042895530202312
3359, 0.41559013390752, 0.4801144036568, 0.051144034431485
3360, 0.61812465251067, 0.14541978530643, 0.0830773949699
3361, 0.61581980943646, 0.15489016206864, 0.066131827997626
3362, 0.61075909421222, 0.17377666367228, 0.066127074337999
3363, 0.61336289969356, 0.1643500936401, 0.049189454836697
3364, 0.60801082300414, 0.18316069204341, 0.049189454836871
3365, 0.61795425416704, 0.1461421902014, 0.050023252389008
3366, 0.60801079039114, 0.18316080030385, 0.083063318382695
3367, 0.60511814112842, 0.19250203967047, 0.066126440097988
3368, 0.5989030672649, 0.2110452937658, 0.066126333813842
3369, 0.59558208826171, 0.22024299340008, 0.083063160787053
3370, 0.62000636063802, 0.13717548165905, 0.066875917398269
3371, 0.59211986795412, 0.22938845213741, 0.066126309004323
3372, 0.58477500543082, 0.24751402591245, 0.066126262351982
3373, 0.58851049843587, 0.23849610737025, 0.049367069241979
3374, 0.58093690538447, 0.25639288594327, 0.049255823216015
3375, 0.57688127336631, 0.265392155949, 0.066147577075211
3376, 0.57277367671963, 0.27414469766363, 0.049509748391929
3377, 0.58485155444737, 0.24733309374302, 0.032967097628665
3378, 0.57271998028311, 0.27425685804462, 0.08306315161204
3379, 0.58089510856278, 0.25648756860291, 0.083066936124228
3380, 0.56843444452441, 0.28303229900177, 0.06620722752236
3381, 0.55944358530509, 0.3004128407059, 0.066137278110696
3382, 0.55475023014354, 0.30899382219663, 0.083065676163097
3383, 0.59558187453182, 0.22024357136853, 0.049288376928318
3384, 0.54992628330157, 0.31749973690402, 0.066128346348486
3385, 0.53988790285798, 0.3342843884294, 0.066126602680183
3386, 0.5449716274515, 0.32593085965104, 0.049189454836806
3387, 0.53467609824329, 0.34255871024881, 0.049189454837393
3388, 0.53467609872934, 0.34255870949017, 0.083063180306256
3389, 0.52933751461514, 0.35075175783033, 0.066126470599207
3390, 0.51828506028565, 0.36688635336396, 0.066126324143757
3391, 0.51257377186411, 0.37482412995564, 0.083063166863611
3392, 0.55475023569358, 0.30899381223241, 0.049189465297563
3393, 0.5067409425629, 0.38267298981045, 0.066126311096808
3394, 0.49471616334635, 0.39809661857879, 0.066126345947164
3395, 0.50078793405477, 0.39043110161096, 0.049189454836804
3396, 0.48852707157324, 0.40566772159006, 0.049189454837383
3397, 0.48222212418891, 0.41314261816319, 0.066126368372672
3398, 0.47580281157299, 0.42051954116217, 0.049189454838458
3399, 0.47580281352205, 0.42051953895687, 0.08306323073692
3400, 0.48852707203322, 0.40566772103613, 0.083063208260844
3401, 0.46927068600412, 0.4277967078616, 0.066126286300937
3402, 0.45587409965233, 0.44204502628824, 0.066126230114701
3403, 0.44901281979774, 0.44901279230918, 0.083063125410464
3404, 0.51257379023641, 0.37482410483143, 0.049189465297547
3405, 0.44204505568612, 0.45587407114625, 0.066126303224375
3406, 0.44837626134287, 0.4496484496406, 0.049204429975191
3407, 0.43449135808444, 0.46307910744271, 0.049289665871269
3408, 0.4271446321451, 0.4698643029957, 0.067184164086948
3409, 0.42411370304308, 0.47260191164561, 0.036074941831031
3410, 0.43823929385164, 0.45953380868487, 0.030690915233823
3411, 0.4202768435869, 0.47601720005125, 0.08354215292763
3412, 0.46257727583765, 0.43502558991238, 0.016412972461523
3413, 0.47579927127535, 0.42052354684826, 0.016718983571413
3414, 0.60208201122026, 0.20179755143451, 0.016936848387767
3415, 0.52387339636992, 0.35886162315835, 0.016936848387767
3416, 0.54497162745192, 0.32593085965033, 0.016936848387767
3417, 0.61336289969356, 0.1643500936401, 0.016936848387767
3418, 0.63132074697396, 0.06825770608689, 0.07956577264058
3419, 0.56400469272042, 0.29175967265772, 0.01672567438705
3420, 0.40586451396659, 0.48836359027129, 0.01577392514024
3421, 0.6258196554589, 0.10758605319139, 0.084925072980925
3422, 0.50078793405527, 0.39043110161032, 0.016936848387767
3423, 0.62235675902168, 0.12608356157733, 0.016489004017583
3424, 0.37481998162674, 0.51257680534075, 0.020460009316064
3425, 0.60208201245983, 0.20179754773614, 0.049285568571427
3426, 0.52387341812891, 0.35886159139413, 0.049189474445891
3427, 0.56400608484735, 0.29175698150202, 0.049342043848854
3428, 0.46256743428671, 0.43503605452584, 0.049444843747361
3429, 0.58856705247033, 0.23835650766528, 0.016521104149803
3430, 0.57694830801842, 0.26524639464973, 0.032920665129476
3431, 0.54992614080625, 0.3174999837133, 0.033063187838425
3432, 0.5067409554396, 0.38267297275894, 0.033063343618074
3433, 0.61075928341474, 0.17377599869577, 0.033062975825291
3434, 0.61582105438223, 0.15488521226882, 0.033062975825291
3435, 0.48222212207574, 0.4131426206297, 0.0330629758252
3436, 0.49471616645746, 0.3980966147126, 0.033063184418863
3437, 0.53988788187755, 0.33428442231395, 0.033063069236296
3438, 0.60511817027124, 0.19250194806178, 0.033062973956054
3439, 0.56845598483591, 0.28298903389396, 0.033003583507422
3440, 0.52933752091209, 0.35075174832729, 0.033063200881033
3441, 0.59890308081627, 0.21104525530979, 0.033063348877712
3442, 0.51828506199539, 0.36688635094868, 0.033063300010924
3443, 0.55945144961528, 0.30039819494025, 0.033041947637644
3444, 0.46924605142666, 0.42782372914612, 0.032955116557705
3445, 0.59211987533259, 0.22938843309137, 0.033063621754719
3446, 0.58092707445415, 0.25641515978221, 0.016534215176139
3447, 0.45519815354063, 0.4427410541312, 0.032375474354273
3448, 0.62060173606831, 0.13445625753008, 0.035700785586334
3449, 0.63479354040372, 0.01619138850453, 0.030637996390345
3450, 0.3314305938899, 0.54164449728008, 0.069385490527043
3451, 0.63430945888895, 0.029605917719413, 0.083380674268373
3452, 0.34280755861972, 0.53451658323497, 0.016615755710714
3453, 0.62396385126418, 0.11787328923711, 0.066529916968252
3454, 0.62410848267376, 0.1171050889358, 0.031416403345845
3455, 0.4134810931653, 0.48193193045785, 0.068698641894573
3456, 0.63306455411962, 0.049540592621934, 0.013597353585922
3457, 0.35886162315835, 0.52387339636992, 0.086268353700644
3458, 0.43597133363787, 0.46168603644254, 0.013183720226596
3459, 0.63270453257133, 0.053944179145667, 0.06674068994693
3460, 0.3872485119902, 0.50325300790097, 0.033221956475056
3461, 0.36312820713145, 0.52092504756971, 0.033291552515597
3462, 0.62947614884357, 0.083574984517314, 0.066845538698289
3463, 0.62894888259983, 0.087454577218269, 0.013053492837211
3464, 0.41150320906584, 0.48362186564352, 0.032665273929777
3465, 0.39021834224022, 0.50095373576738, 0.087005705122015
3466, 0.63482870410769, 0.014748438593757, 0.085249854131673
3467, 0.32910468945854, 0.5430608652595, 0.013480838232965
3468, 0.63484035274739, 0.014238206473144, 0.014362019687972
3469, 0.32975082488377, 0.54266876959014, 0.085637980312033
3470, 0.39855826984056, 0.494344318812, 0.027956148847678
3471, 0.62714020657695, 0.099600006499083, 0.071526236001583
3472, 0.62121047733594, 0.13161513153149, 0.052817552374295
3473, 0.36226101564112, 0.62745448469193, 0.016238295329927
3474, 0.38117109483017, 0.6602077026225, 0.08369297015037
3475, 0.44977439489811, 0.77903210390707, 0.016469629518019
3476, 0.42037608685529, 0.72811274072035, 0.016591172872935
3477, 0.48982696600821, 0.84840519204354, 0.018873780404659
3478, 0.40068217417776, 0.69400188336305, 0.016742691331607
3479, 0.46929891304348, 0.81284956132815, 0.016962801930647
3480, 0.50845284795595, 0.8806661659128, 0.018393870029988
3481, 0.32609689805508, 0.56481639562201, 0.049803196777033
3482, 0.35179877498194, 0.60933335230921, 0.082363995663707
3483, 0.41053804347826, 0.71107274974427, 0.083037198069353
3484, 0.43991847826087, 0.76196115553621, 0.083037198069353
3485, 0.47909239130435, 0.8298123632588, 0.083037198069353
3486, 0.45950543478261, 0.79588675939751, 0.0841209585993
3487, 0.51903709756385, 0.89899862399367, 0.082231434533054
3488, 0.49836094265498, 0.86318647318634, 0.083404860691857
3489, 0.38130034052688, 0.66043156273588, 0.016797989408281
3490, 0.53415926463247, 0.92519098567706, 0.05020596490112
3491, 0.34122513123341, 0.59101926411562, 0.017769479402212
3492, 0.52707914068244, 0.91292785127173, 0.01808771782582
3493, 0.33317598393778, 0.57707773204198, 0.081930067670941
3494, 0.53451138583065, 0.92580087748273, 0.069882803483855
3495, 0.52483782457052, 0.90904577789005, 0.063279142434344
3496, 0.52560547497627, 0.91037538739526, 0.04035430988103
3497, 0.51694843896336, 0.89538096117795, 0.050103966015741
3498, 0.51746321433049, 0.89627257826831, 0.030161672205834
3499, 0.50852854102229, 0.88079727014947, 0.039876461439058
3500, 0.50852840820127, 0.88079704009673, 0.059818136606114
3501, 0.49915936469729, 0.8645693807295, 0.051289323790524
3502, 0.49951252094999, 0.86518106530219, 0.030459558571029
3503, 0.49144477123443, 0.8512073128921, 0.040365764595596
3504, 0.4820335833354, 0.83490665729141, 0.03333936990745
3505, 0.48325002930049, 0.8370136035076, 0.051688225003086
3506, 0.47447494639855, 0.82181471408081, 0.045392264645278
3507, 0.47443627562143, 0.82174773433006, 0.065767545006601
3508, 0.46717776782562, 0.80917563004059, 0.053908799705696
3509, 0.46525063551482, 0.80583773896538, 0.034874621390104
3510, 0.45830020003152, 0.79379923157358, 0.050640050062559
3511, 0.32572493014166, 0.56417212829717, 0.030115730435696
3512, 0.33542869677377, 0.58097954512878, 0.036735901678484
3513, 0.33466124139141, 0.57965027341399, 0.059686157593403
3514, 0.34334421556383, 0.59468962584143, 0.049932279560569
3515, 0.34280643596486, 0.59375816425274, 0.069998959915949
3516, 0.35186747509433, 0.60945234439435, 0.060088820119649
3517, 0.36110917690285, 0.62545944147512, 0.071219317573065
3518, 0.36095114617747, 0.62518572422961, 0.051738068645117
3519, 0.36927438641358, 0.63960199920215, 0.062545743714444
3520, 0.36950752291714, 0.6400058034714, 0.043420780200667
3521, 0.37705894551404, 0.65308525107867, 0.053727508970787
3522, 0.35186746296404, 0.60945232338407, 0.04011372780156
3523, 0.45965725144563, 0.7961497135713, 0.016765662186619
3524, 0.50866298519728, 0.88103013429134, 0.080078022968768
3525, 0.4693390169514, 0.81291902333425, 0.084053977159786
3526, 0.40074456521739, 0.69410994781362, 0.083037198069353
3527, 0.40564130434783, 0.70259134877894, 0.066074396138705
3528, 0.4154347826087, 0.71955415070959, 0.066074396138705
3529, 0.41053804347826, 0.71107274974427, 0.049111594208058
3530, 0.40070000018908, 0.69403275892035, 0.049483223055708
3531, 0.42039391290175, 0.72814361633852, 0.049331704657229
3532, 0.42523865939667, 0.73653496341751, 0.066111081213567
3533, 0.43019952277758, 0.74512743084265, 0.049226424825727
3534, 0.43503589268121, 0.75350426923994, 0.066099648754127
3535, 0.43976060311737, 0.76168770776641, 0.049482468648823
3536, 0.43513267660844, 0.75367190391925, 0.03282201264503
3537, 0.37031362250891, 0.64140200892032, 0.082116962842297
3538, 0.41053507249102, 0.71106760384341, 0.016568043390541
3539, 0.44971195652174, 0.77892395746686, 0.083414291163499
3540, 0.44461856426881, 0.77010194330191, 0.066599148735914
3541, 0.4888328020367, 0.84668324953382, 0.083588703654704
3542, 0.49370853995049, 0.85512827532489, 0.068276884261266
3543, 0.43012909201298, 0.74500544117995, 0.083047521017733
3544, 0.39090208604883, 0.67706227382123, 0.01682660511003
3545, 0.38663377048943, 0.66966933440961, 0.032905560446365
3546, 0.42033152173913, 0.72803555167492, 0.083037198069353
3547, 0.39095333464561, 0.67715103899467, 0.083146493416189
3548, 0.38519749191545, 0.66718162694566, 0.064861298667807
3549, 0.37175869974285, 0.64390495611036, 0.015867791732975
3550, 0.39584782608696, 0.6856285468483, 0.066074396138706
3551, 0.35189218916196, 0.60949515041515, 0.020226580036342
3552, 0.42527699695862, 0.73660136602265, 0.032847098564813
3553, 0.43994741922874, 0.76201128276298, 0.016400541248946
3554, 0.39591840370157, 0.68575079086269, 0.033165932494642
3555, 0.40563474610773, 0.70257998957389, 0.033018113758318
3556, 0.41545914313211, 0.71959634437385, 0.032911287908649
3557, 0.44464992481406, 0.77015626135963, 0.032961610657968
3558, 0.43016386327518, 0.74506566677273, 0.016443470888621
3559, 0.39139264356417, 0.67791194436184, 0.048978131203704
3560, 0.53466012338278, 0.92605849848002, 0.030504736876147
3561, 0.32559454389646, 0.56394629269588, 0.069506498898744
3562, 0.52797013661535, 0.91447110149687, 0.083490953450994
3563, 0.33212640029681, 0.57525979984903, 0.016527854467371
3564, 0.45450292006319, 0.78722214973786, 0.067381679544703
3565, 0.45449440927212, 0.78720740861532, 0.032992544748261
3566, 0.47897727148903, 0.82961296988972, 0.016018444177227
3567, 0.3767804241514, 0.65260283792758, 0.03419024915866
3568, 0.44903903023751, 0.77775841495282, 0.050155791670839
3569, 0.36013816428417, 0.62377759828477, 0.034270431185723
3570, 0.48433100358554, 0.83888590589098, 0.068550888041043
3571, 0.49903020611327, 0.86434567149974, 0.013545441801135
3572, 0.51790556233291, 0.89703874748312, 0.013328652012328
3573, 0.34234971723778, 0.59296710421268, 0.086858604650119
3574, 0.51610313985707, 0.89391686017827, 0.066811357076624
3575, 0.34440049116248, 0.59651914884508, 0.033107197657737
3576, 0.37652844484668, 0.65216639696935, 0.06956607737076
3577, 0.36157065217391, 0.62625874009103, 0.087351679833394
3578, 0.50166565592986, 0.86891040448288, 0.068280371873731
3579, 0.47424309638165, 0.82141313807179, 0.02904327507505
3580, 0.53562790588447, 0.92773474694362, 0.085781638388193
3581, 0.32480088544583, 0.56257163593554, 0.014708990935158
3582, 0.46421076063544, 0.80403662284077, 0.070030573964334
3583, 0.53561686000553, 0.92771561492008, 0.01438042864891
3584, 0.32463313999447, 0.56228109229105, 0.085619571351089
3585, 0.36739101132933, 0.63633989786652, 0.029120183358265
3586, 0.38389028438269, 0.66491747708288, 0.047262324063331
3587, 0.49029268717247, 0.8492118447622, 0.054793626418348
3588, 0.69621320441263, 0.87197782345414, 0.016036885411442
3589, 0.62340612261804, 0.89943832746351, 0.08384240986815
3590, 0.83298345422874, 0.84094342953831, 0.018900352611492
3591, 0.75329935272887, 0.85591773201275, 0.017133371368507
3592, 0.79137665571093, 0.8477094744771, 0.081990766992622
3593, 0.87040570031793, 0.83677566314966, 0.082379904027204
3594, 0.65883113117426, 0.88505742486327, 0.016965616446584
3595, 0.55772933264855, 0.93163726062938, 0.050202017050748
3596, 0.71508248788114, 0.86615791013997, 0.08286662758876
3597, 0.67736928855522, 0.87830930523673, 0.084304256297328
3598, 0.60409965843752, 0.90813110518804, 0.017610768913513
3599, 0.89173513080221, 0.83520064561831, 0.017989466302108
3600, 0.83377412591328, 0.84083672803744, 0.081491118205508
3601, 0.75552505145661, 0.85538384938698, 0.082177490761868
3602, 0.79197913971623, 0.84759523720035, 0.017133371368508
3603, 0.92231394113497, 0.83394786809364, 0.049796265680422
3604, 0.58504562730806, 0.91732909769571, 0.082061241876684
3605, 0.90804033064681, 0.83438561526358, 0.081827517409999
3606, 0.57030911343726, 0.92487982955979, 0.018166483267144
3607, 0.92272077982582, 0.83393915885862, 0.030122935819847
3608, 0.90351401498753, 0.83457815315521, 0.036635377571823
3609, 0.90503558008151, 0.83451054086438, 0.059784690769994
3610, 0.88776456988756, 0.83545007979882, 0.049939505613493
3611, 0.88861542381273, 0.83539494573066, 0.069939872556542
3612, 0.87064521653173, 0.8367547642328, 0.059838798097557
3613, 0.87027085932135, 0.83678746083366, 0.039967296739793
3614, 0.85358885330341, 0.83842618375566, 0.049919670347983
3615, 0.85246683421964, 0.83854918908253, 0.03001898556518
3616, 0.83585831959711, 0.84055934266129, 0.040741600694828
3617, 0.81757250779746, 0.84318524723454, 0.033830605820614
3618, 0.8209422075622, 0.84266865455956, 0.052352063001934
3619, 0.80303991281985, 0.84558347854021, 0.046435574219358
3620, 0.80601481469771, 0.84506996994403, 0.065325032348941
3621, 0.78779542311681, 0.84839847783565, 0.059829162339629
3622, 0.78457596943459, 0.84903246495183, 0.035938842998003
3623, 0.77037845373274, 0.85199393959839, 0.052041558370108
3624, 0.77299319451397, 0.85142816023864, 0.0720444920097
3625, 0.85299840852765, 0.83849071201154, 0.070344476438521
3626, 0.76245293604736, 0.85376539425889, 0.032974802272672
3627, 0.75168319324465, 0.8563096618542, 0.049906942298676
3628, 0.55737153656898, 0.9318337450336, 0.069878389660628
3629, 0.57450934982314, 0.92268805035096, 0.063376193659767
3630, 0.57307752734209, 0.9234316252819, 0.040081015348405
3631, 0.58841984916359, 0.91565441384369, 0.050052112934698
3632, 0.58766271447396, 0.9160284565693, 0.030029736619495
3633, 0.60422537750955, 0.90807248357308, 0.0391471740325
3634, 0.62103956817202, 0.90047070228587, 0.029096561492984
3635, 0.62039446537097, 0.9007537105143, 0.048330431268144
3636, 0.63622283512105, 0.89400515429078, 0.038327658922382
3637, 0.63550903770449, 0.8943007901112, 0.056224742155916
3638, 0.65168139220317, 0.88780064683357, 0.047706295579759
3639, 0.65070122214058, 0.88818290441945, 0.067264470608605
3640, 0.66796638109655, 0.88166684115523, 0.055766706309818
3641, 0.60487225705498, 0.90777127258481, 0.059205976230443
3642, 0.66799046165008, 0.88165807184696, 0.034849879178663
3643, 0.68196442830672, 0.8767168121289, 0.047370558958602
3644, 0.64095782778246, 0.8920646027266, 0.084681363879
3645, 0.73445731826118, 0.8607111817802, 0.082763858657068
3646, 0.72450856162099, 0.8634417736263, 0.06577076320262
3647, 0.70612527478004, 0.86885650718064, 0.066007042455953
3648, 0.71508248988787, 0.86615790954827, 0.048599824480812
3649, 0.69624447384201, 0.87196775187766, 0.083149607070762
3650, 0.71508438267569, 0.8661573514473, 0.016773776132691
3651, 0.63847203608111, 0.89307891251528, 0.018385089786636
3652, 0.87029665172702, 0.83678520237824, 0.019380623292391
3653, 0.67735690043028, 0.87831364115182, 0.016228811980919
3654, 0.73364692074681, 0.86092841213217, 0.016541940672311
3655, 0.74320547699368, 0.8584244881006, 0.065721480170005
3656, 0.68521030666081, 0.87561088267608, 0.065589289237612
3657, 0.6046158591152, 0.907890576252, 0.079537588230088
3658, 0.8122587872359, 0.84403001590689, 0.083091431554332
3659, 0.73333214408386, 0.86101303701586, 0.049075035367515
3660, 0.83691641681183, 0.84042067068725, 0.060574293576443
3661, 0.92320744134581, 0.83392901502825, 0.06946652167647
3662, 0.55695701265366, 0.93206168132882, 0.030509306587317
3663, 0.90990871156428, 0.83431368645394, 0.016626401618375
3664, 0.56869861947215, 0.92572870797472, 0.083384832607084
3665, 0.70610017789799, 0.86886423039047, 0.032618416376421
3666, 0.72402589076809, 0.86357779499631, 0.032677525315813
3667, 0.65889953207099, 0.8850315622695, 0.084665056881217
3668, 0.81128619658038, 0.84418863966885, 0.01628609163914
3669, 0.77258736677185, 0.85151536867349, 0.015329968043238
3670, 0.61993173373104, 0.90095713287612, 0.065935154736967
3671, 0.59126899286239, 0.91425583214497, 0.066768167114267
3672, 0.85065618821203, 0.83875109516067, 0.013583051157525
3673, 0.88944356107761, 0.83534216524305, 0.086735456051594
3674, 0.64970338202535, 0.88857359233433, 0.030772026317755
3675, 0.58689813905182, 0.91640719327679, 0.013255187144052
3676, 0.7428785512927, 0.85850803069013, 0.033144520201448
3677, 0.88482467299099, 0.83564764931348, 0.032813842565904
3678, 0.82198352634113, 0.84251201028394, 0.068679516244255
3679, 0.69871405841203, 0.87117683085045, 0.049913204314709
3680, 0.75901543498259, 0.8545602572076, 0.06456515746615
3681, 0.85102530138529, 0.83870959358005, 0.086981830438686
3682, 0.62218567870229, 0.89996958367813, 0.012854072049598
3683, 0.68709707297452, 0.87497521088274, 0.030768430160285
3684, 0.80179618213507, 0.84580162049633, 0.029737174049728
3685, 0.92614812751448, 0.83387407468094, 0.013350388868402
3686, 0.55469489079236, 0.93331124705669, 0.086268820451051
3687, 0.66724077302355, 0.88193149594639, 0.071899780504083
3688, 0.92505495658945, 0.83389322493281, 0.085495365382844
3689, 0.55532552016389, 0.93296192884086, 0.014504634617336
3690, 0.77278395119288, 0.85147309685802, 0.087857552671038
3691, 0.63260292593031, 0.89551284513821, 0.071578139332099
3692, 0.9395, 0.66470077114365, 0.017628731332044
3693, 0.9395, 0.54591542029925, 0.017191876584057
3694, 0.9395, 0.60546982939131, 0.017191879397915
3695, 0.9395, 0.72690100680851, 0.018872535115036
3696, 0.9395, 0.76446620810048, 0.081775693164094
3697, 0.9395, 0.36725219222983, 0.017191877192788
3698, 0.9395, 0.42680660178061, 0.017191877192787
3699, 0.9395, 0.48636101133139, 0.082808122807213
3700, 0.9395, 0.14772681393723, 0.082858845362506
3701, 0.9395, 0.10664518848454, 0.080656308158798
3702, 0.9395, 0.24814337312826, 0.082808122807213
3703, 0.9395, 0.18858896357748, 0.017191877192796
3704, 0.9395, 0.28784631282878, 0.017191877192792
3705, 0.9395, 0.32754925252931, 0.017191877192789
3706, 0.9395, 0.069439563657422, 0.017390068886759
3707, 0.9395, 0.64759262745505, 0.082128624773234
3708, 0.9395, 0.68372609577609, 0.081722763068592
3709, 0.9395, 0.78579769278039, 0.017869194505516
3710, 0.9395, 0.52606395103192, 0.082808122807213
3711, 0.9395, 0.56576689073244, 0.082808122807213
3712, 0.9395, 0.44650342827465, 0.08346935142054
3713, 0.9395, 0.50621248118166, 0.017191877192787
3714, 0.9395, 0.38710366208009, 0.082808122807213
3715, 0.9395, 0.34740072237957, 0.082808122807213
3716, 0.9395, 0.46650954148113, 0.017191877192787
3717, 0.9395, 0.228291903278, 0.017191877192792
3718, 0.9395, 0.12904955980099, 0.016637307355343
3719, 0.9395, 0.30754313932282, 0.083469351420542
3720, 0.9395, 0.20828579007152, 0.083469351420544
3721, 0.9395, 0.048209979123703, 0.081652790797073
3722, 0.9395, 0.60546983043296, 0.082808122807213
3723, 0.9395, 0.72767082106013, 0.081439518893232
3724, 0.9395, 0.81655164881077, 0.049821111143272
3725, 0.9395, 0.017210084900187, 0.050178888856728
3726, 0.9395, 0.8021032931958, 0.081895054976526
3727, 0.9395, 0.031658440515157, 0.018104945023474
3728, 0.9395, 0.016744985376385, 0.069903517828784
3729, 0.9395, 0.036150203981335, 0.063116067522062
3730, 0.9395, 0.03450924123578, 0.040159615585677
3731, 0.9395, 0.05183380803292, 0.050037033440435
3732, 0.9395, 0.051255441500873, 0.029961127359676
3733, 0.9395, 0.069173482260439, 0.039225662417294
3734, 0.9395, 0.08801152375637, 0.029046414754117
3735, 0.9395, 0.087064053539283, 0.04900109309567
3736, 0.9395, 0.10442451763202, 0.038643191244257
3737, 0.9395, 0.10433483074285, 0.058664194058341
3738, 0.9395, 0.12142065509002, 0.047909459672808
3739, 0.9395, 0.08768857787138, 0.068871218044718
3740, 0.9395, 0.070074040363349, 0.058949884232734
3741, 0.9395, 0.069713254600446, 0.080296121211213
3742, 0.9395, 0.81701674833457, 0.030096482171216
3743, 0.9395, 0.79764662586084, 0.036815642114013
3744, 0.9395, 0.79915744570791, 0.059936450578217
3745, 0.9395, 0.78192792567804, 0.049962966559565
3746, 0.9395, 0.78275023740214, 0.069990938913858
3747, 0.9395, 0.76481470176536, 0.060255526220838
3748, 0.9395, 0.76434934739865, 0.040139829328743
3749, 0.9395, 0.74770782496247, 0.050035237054978
3750, 0.9395, 0.74667214500205, 0.030007374664568
3751, 0.9395, 0.7297303411076, 0.040689292399248
3752, 0.9395, 0.71084671374286, 0.033348971766432
3753, 0.9395, 0.71401218945593, 0.052783352040355
3754, 0.9395, 0.69574978523619, 0.046521220720191
3755, 0.9395, 0.69411576835923, 0.029977487127188
3756, 0.9395, 0.67620830791832, 0.036395658407429
3757, 0.9395, 0.68057933979165, 0.059553932710641
3758, 0.9395, 0.66206679067185, 0.052583912133392
3759, 0.9395, 0.6652940901833, 0.07163979558537
3760, 0.9395, 0.69915626346522, 0.065762433330177
3761, 0.9395, 0.74700444101255, 0.069920874006967
3762, 0.9395, 0.62532130028322, 0.017191877192787
3763, 0.9395, 0.61539556657335, 0.034383765111283
3764, 0.9395, 0.59554409025741, 0.034383758614825
3765, 0.9395, 0.63500669630189, 0.034211384379706
3766, 0.9395, 0.62521911965805, 0.051323218777714
3767, 0.9395, 0.60546982209973, 0.051575643117756
3768, 0.9395, 0.58561834999211, 0.051575635287244
3769, 0.9395, 0.5756926200567, 0.034383754984021
3770, 0.9395, 0.56576687981206, 0.051575630465472
3771, 0.9395, 0.52606395093476, 0.017191877091332
3772, 0.9395, 0.51613821609059, 0.034383754368665
3773, 0.9395, 0.49628674625383, 0.034383754382755
3774, 0.9395, 0.50621248118165, 0.051575631578361
3775, 0.9395, 0.48636101133139, 0.05157563157836
3776, 0.9395, 0.52606395103192, 0.051575631578361
3777, 0.9395, 0.53598968513612, 0.03438375388397
3778, 0.9395, 0.44665807163087, 0.017191877192787
3779, 0.9395, 0.43673233670574, 0.034383754385574
3780, 0.9395, 0.41688086685548, 0.034383754385574
3781, 0.9395, 0.4265901010819, 0.051450634841678
3782, 0.9395, 0.40691904848057, 0.051291897782753
3783, 0.9395, 0.44640548748237, 0.05116719678917
3784, 0.9395, 0.39702338309692, 0.03433646541964
3785, 0.9395, 0.3871018356988, 0.051424476661276
3786, 0.9395, 0.41640576809997, 0.067648965963525
3787, 0.9395, 0.37717662044003, 0.034350680405072
3788, 0.9395, 0.36725205630139, 0.051430922253503
3789, 0.9395, 0.35732621686414, 0.034354123834682
3790, 0.9395, 0.34740070605091, 0.051431351285758
3791, 0.9395, 0.33747494465957, 0.034354769244994
3792, 0.9395, 0.32754924996425, 0.051431397900129
3793, 0.9395, 0.31762351004419, 0.034354884582442
3794, 0.9395, 0.30748128029282, 0.051159178998396
3795, 0.9395, 0.29773596276288, 0.034309533988395
3796, 0.9395, 0.28758771423386, 0.051368856012161
3797, 0.9395, 0.27787146397266, 0.034336921725017
3798, 0.9395, 0.26794355755754, 0.051270462534414
3799, 0.9395, 0.25805237482806, 0.03432508743483
3800, 0.9395, 0.24814042215964, 0.051423053068983
3801, 0.9395, 0.27743592917024, 0.067631763617219
3802, 0.9395, 0.23821435750414, 0.034348546808893
3803, 0.9395, 0.22829163291897, 0.051430767925956
3804, 0.9395, 0.21836557650987, 0.034353742514066
3805, 0.9395, 0.20822378902869, 0.051158883657975
3806, 0.9395, 0.19847849246227, 0.034309294420266
3807, 0.9395, 0.18833032113887, 0.051368766860741
3808, 0.9395, 0.17861408723919, 0.034336866938431
3809, 0.9395, 0.16868619641859, 0.051270438544751
3810, 0.9395, 0.15879501901512, 0.034325074305461
3811, 0.9395, 0.17817857063038, 0.067631744760375
3812, 0.9395, 0.14888602387696, 0.051575631578383
3813, 0.9395, 0.26798386845247, 0.017174293924238
3814, 0.9395, 0.1687265135272, 0.017174282604916
3815, 0.9395, 0.4069541296123, 0.017183995698465
3816, 0.9395, 0.62560937853579, 0.083102385152986
3817, 0.9395, 0.50621248118165, 0.082808122807213
3818, 0.9395, 0.54591542088218, 0.082808122807212
3819, 0.9395, 0.34740072237957, 0.017191877192787
3820, 0.9395, 0.12721574930543, 0.082612674808304
3821, 0.9395, 0.22827875333274, 0.083132314284259
3822, 0.9395, 0.32753610258405, 0.083132314284259
3823, 0.9395, 0.10691174823082, 0.018330186082764
3824, 0.9395, 0.30769778267905, 0.017191877192787
3825, 0.9395, 0.38710227492321, 0.017177169785994
3826, 0.9395, 0.46649639153588, 0.083132314284258
3827, 0.9395, 0.20844043342774, 0.017191877192787
3828, 0.9395, 0.36725219222983, 0.082808122807213
3829, 0.9395, 0.5856183605827, 0.082808122807213
3830, 0.9395, 0.48636101133094, 0.017191877192317
3831, 0.9395, 0.76426366712937, 0.019280342046312
3832, 0.9395, 0.47643527640574, 0.034383754385025
3833, 0.9395, 0.58561835916687, 0.017191877835616
3834, 0.9395, 0.45654170919783, 0.034315681920617
3835, 0.9395, 0.14888390484151, 0.017086736441884
3836, 0.9395, 0.24813820838653, 0.017173300893459
3837, 0.9395, 0.46648448352984, 0.051267147699838
3838, 0.9395, 0.56576688941134, 0.017191876561107
3839, 0.9395, 0.55584115186677, 0.034383753164708
3840, 0.9395, 0.54591541542199, 0.05157562842592
3841, 0.9395, 0.64517277013348, 0.017191877192786
3842, 0.9395, 0.13770566939533, 0.033098424119126
3843, 0.9395, 0.13330403350577, 0.063596743406316
3844, 0.9395, 0.6546574375543, 0.034618040140687
3845, 0.9395, 0.016314089587886, 0.030498410719859
3846, 0.9395, 0.81743180299519, 0.069517600307457
3847, 0.9395, 0.80415064354637, 0.016595406314662
3848, 0.9395, 0.029951819270237, 0.083343239944409
3849, 0.9395, 0.73076475631428, 0.060403550857331
3850, 0.9395, 0.40687594880443, 0.083672120058183
3851, 0.9395, 0.43654919887925, 0.067552259175313
3852, 0.9395, 0.26791406818962, 0.083669253000467
3853, 0.9395, 0.29758631557545, 0.067534426014215
3854, 0.9395, 0.16817065110541, 0.083643532077001
3855, 0.9395, 0.19832893379997, 0.067534358789436
3856, 0.9395, 0.47642890842351, 0.067194495125874
3857, 0.9395, 0.49628568492606, 0.067192313514968
3858, 0.9395, 0.45647798302092, 0.067297127415832
3859, 0.9395, 0.37717792715496, 0.067191877192788
3860, 0.9395, 0.3573264573047, 0.067191877192788
3861, 0.9395, 0.33747498745444, 0.067191877192789
3862, 0.9395, 0.31752851253231, 0.067319757635055
3863, 0.9395, 0.23821490965765, 0.067196039668899
3864, 0.9395, 0.21827063480159, 0.067320285957845
3865, 0.9395, 0.51613803921838, 0.067191949939656
3866, 0.9395, 0.53598965556561, 0.067191889277536
3867, 0.9395, 0.55584114801197, 0.067191879366048
3868, 0.9395, 0.57569262438612, 0.067191881626212
3869, 0.9395, 0.59554409463166, 0.067191884995437
3870, 0.9395, 0.61542654676109, 0.067198858997181
3871, 0.9395, 0.63524703520835, 0.06719189913198
3872, 0.9395, 0.42665792460325, 0.083723782769594
3873, 0.9395, 0.39702939700522, 0.067190102734182
3874, 0.9395, 0.28769534631928, 0.083717465675407
3875, 0.9395, 0.2580691080534, 0.067190102734188
3876, 0.9395, 0.1883569787937, 0.083713164507893
3877, 0.9395, 0.15813843708966, 0.066972102676724
3878, 0.9395, 0.64373072714622, 0.050743075824731
3879, 0.9395, 0.70602508841953, 0.082955690451105
3880, 0.9395, 0.70609747111475, 0.015618773146374
3881, 0.9395, 0.089331614326175, 0.085974709478487
3882, 0.9395, 0.11970140823484, 0.030961605599435
3883, 0.9395, 0.74473473787806, 0.086447777693626
3884, 0.9395, 0.74443011938479, 0.0135702596009
3885, 0.9395, 0.050322158984951, 0.013091228253982
3886, 0.9395, 0.78351717137381, 0.086732337410896
3887, 0.9395, 0.77915023322664, 0.032974206714724
3888, 0.9395, 0.055196257220351, 0.066810379440703
3889, 0.9395, 0.11781870305273, 0.068075741910413
3890, 0.9395, 0.71591807572178, 0.068758218121556
3891, 0.9395, 0.088605212859393, 0.012953333944728
3892, 0.9395, 0.65078625413295, 0.064857461489741
3893, 0.9395, 0.68305230383834, 0.015759403667379
3894, 0.9395, 0.66502423998374, 0.087779376192449
3895, 0.9395, 0.81913512211567, 0.014665965574376
3896, 0.9395, 0.014626611595293, 0.085334034425624
3897, 0.9395, 0.014506770876193, 0.014547014853274
3898, 0.9395, 0.81925496283477, 0.085452985146728
3899, 0.76486335225453, 0.049580799717428, 0.05
3900, 0.66803096364493, 0.18058671237151, 0.05
3901, 0.62399236260118, 0.33445236594823, 0.05
3902, 0.81771711951036, 0.20022360118629, 0.05
3903, 0.80495958102641, 0.082866969807471, 0.05
3904, 0.70618363730239, 0.055419450861792, 0.05
3905, 0.86183145339815, 0.3713837021725, 0.05
3906, 0.78710784211884, 0.15918267508825, 0.05
3907, 0.40836865349539, 0.57594543173725, 0.05
3908, 0.64403474014362, 0.82620782011271, 0.05
3909, 0.4653471757089, 0.53767774258672, 0.05
3910, 0.45877812429283, 0.61576808361177, 0.05
3911, 0.55250914113234, 0.44654486254709, 0.05
3912, 0.49588268633302, 0.57960823623201, 0.05
3913, 0.53301840787256, 0.54336538823251, 0.05
3914, 0.62351308323374, 0.41306691254029, 0.05
3915, 0.83849739836179, 0.15344999227548, 0.05
3916, 0.57016986465525, 0.50710261441978, 0.05
3917, 0.52023003767768, 0.49306143837946, 0.05
3918, 0.50870244190403, 0.62991328960946, 0.05
3919, 0.66066119909798, 0.37677228410436, 0.05
3920, 0.5004330570865, 0.72782143530071, 0.05
3921, 0.60245745300421, 0.46056133637801, 0.05
3922, 0.53928181665198, 0.67191983614828, 0.05
3923, 0.55044849755005, 0.74189701306068, 0.05
3924, 0.67928185141903, 0.23049314047956, 0.05
3925, 0.58768655478289, 0.70558097970639, 0.05
3926, 0.47123995759601, 0.66541604486906, 0.05
3927, 0.5829583276606, 0.55715669151937, 0.05
3928, 0.75693987959828, 0.099918213371666, 0.05
3929, 0.55990957778966, 0.83157479982419, 0.05
3930, 0.62496390181033, 0.66924608336309, 0.05
3931, 0.65740743928155, 0.6225856796743, 0.05
3932, 0.66568431445342, 0.52442178699508, 0.05
3933, 0.85968906110442, 0.10678749920662, 0.05
3934, 0.60053776852009, 0.75599034194259, 0.05
3935, 0.54558952640053, 0.59300308777299, 0.05
3936, 0.52943974939412, 0.7894577758124, 0.05
3937, 0.63323161967399, 0.57108778049354, 0.05
3938, 0.69578820222124, 0.58802908668717, 0.053251629661602
3939, 0.63779732510871, 0.71968709219791, 0.05
3940, 0.70948022856419, 0.47864269401298, 0.05
3941, 0.65427975767864, 0.45467756633678, 0.05
3942, 0.71585383382293, 0.53851428229029, 0.05
3943, 0.81373849384146, 0.25842990410747, 0.05
3944, 0.68800558108702, 0.73391580149146, 0.05
3945, 0.57600996436965, 0.63627112147904, 0.05
3946, 0.65069694239558, 0.77016869543663, 0.05
3947, 0.67514164810481, 0.68332286395793, 0.05
3948, 0.78684261205145, 0.78204119077024, 0.05
3949, 0.8087439185923, 0.31748268110866, 0.05
3950, 0.73653252393268, 0.7677834162887, 0.05
3951, 0.70760433946978, 0.63655990298428, 0.05
3952, 0.76702633515381, 0.20609494873531, 0.05
3953, 0.7774347471641, 0.62244824152643, 0.05
3954, 0.83458277674311, 0.41885073522789, 0.05
3955, 0.80379416539271, 0.37658385099562, 0.05
3956, 0.80678541503175, 0.54552246251329, 0.05
3957, 0.75624854313453, 0.67025591679057, 0.05
3958, 0.80825283225901, 0.66473398938602, 0.05
3959, 0.81339764545284, 0.46668711235085, 0.05
3960, 0.8729859442319, 0.77934963960845, 0.05
3961, 0.74539984352186, 0.25452826681424, 0.05
3962, 0.83908854685582, 0.70702162340727, 0.05
3963, 0.5587870909565, 0.39555714274955, 0.05
3964, 0.76911592110717, 0.72099173606218, 0.05
3965, 0.82944709611217, 0.61688762379113, 0.05
3966, 0.69059790357535, 0.41828004304618, 0.05
3967, 0.78371612037118, 0.42447684358871, 0.05
3968, 0.87790494086372, 0.65060687980179, 0.05
3969, 0.65933853960649, 0.29766286035271, 0.05
3970, 0.77783695641091, 0.50339946965435, 0.05
3971, 0.8668154111375, 0.58009214455951, 0.05
3972, 0.74556185424683, 0.58038025563238, 0.05
3973, 0.69754452476395, 0.80065621435643, 0.05
3974, 0.88290746821689, 0.17847182177872, 0.05
3975, 0.84423431711211, 0.50882549462688, 0.05
3976, 0.70361540608531, 0.14383137511637, 0.05
3977, 0.69637099914415, 0.34018369600266, 0.05
3978, 0.84890105771731, 0.056900140034779, 0.05
3979, 0.73444461037572, 0.39181982165627, 0.05
3980, 0.74041761785492, 0.31328746938508, 0.05
3981, 0.86511221921326, 0.45997540711942, 0.05
3982, 0.71639512493162, 0.19590492485757, 0.05
3983, 0.88948156578764, 0.41545082023013, 0.05
3984, 0.82913620540011, 0.75579312851215, 0.050223037082312
3985, 0.88895477659608, 0.53361156266321, 0.05
3986, 0.61953752371412, 0.50688072949168, 0.048632470715689
3987, 0.88963242316215, 0.23821547292561, 0.05
3988, 0.68064586847198, 0.098920881447011, 0.05
3989, 0.8585967068829, 0.32147595570623, 0.05
3990, 0.88885361870757, 0.72113514928142, 0.05
3991, 0.60042506319972, 0.80464123086144, 0.051364975240761
3992, 0.60353135276998, 0.85333102073667, 0.052203494023188
3993, 0.63561353780076, 0.25407315071511, 0.050945837150569
3994, 0.70465926544012, 0.28066467453731, 0.05257867440964
3995, 0.73806173872057, 0.43986033242947, 0.048119087955799
3996, 0.71927860546427, 0.699032333051, 0.053393636988471
3997, 0.41244562814096, 0.62260131607451, 0.050266754321232
3998, 0.76258668230264, 0.35446692574954, 0.04679804367546
3999, 0.85853484044548, 0.2740383024978, 0.052908855487592
4000, 0.89371961885814, 0.045798126791652, 0.054266363429221
4001, 0.74890016110451, 0.81123186977179, 0.055186527385439
4002, 0.58179073700605, 0.35476161513107, 0.053655892423304
4003, 0.61372293521085, 0.61166983153781, 0.044985133845186
4004, 0.46028622346219, 0.70857110468244, 0.05554934731226
4005, 0.56040742018156, 0.87828159473544, 0.046679935595761
4006, 0.77793288931139, 0.28513913643599, 0.055284613353897
4007, 0.50837649107726, 0.45037798640576, 0.055647623083067
4008, 0.8955778133614, 0.13476556376951, 0.045482926169371
4009, 0.47286354582058, 0.49085961851148, 0.052637068919238
4010, 0.89617708749187, 0.29747588419503, 0.045702974234392
4011, 0.61316904688036, 0.29178523236212, 0.044302629739788
4012, 0.74706241027502, 0.14225681300226, 0.056551091032588
4013, 0.89678931387782, 0.61153095457038, 0.043613785536136
4014, 0.89706177234968, 0.34102438939168, 0.043714619760287
4015, 0.42083135715278, 0.53294890875351, 0.045005418721668
4016, 0.89629328442259, 0.49055738304918, 0.043461778061672
4017, 0.79994573529502, 0.58697500889191, 0.058052276929302
4018, 0.80920954742868, 0.12410690864133, 0.042017561225868
4019, 0.75777141555227, 0.54024300661652, 0.057547608691216
4020, 0.82634110883937, 0.79854453751085, 0.056845452604886
4021, 0.4495221797783, 0.5756679939813, 0.041918399925176
4022, 0.8471988357116, 0.23147791906124, 0.042873281107797
4023, 0.42953719909879, 0.6609531206895, 0.057527740080328
4024, 0.81034165842534, 0.041811962636065, 0.058854088411886
4025, 0.89702422001751, 0.086912054521087, 0.041858394790733
4026, 0.64187469129658, 0.21270478546651, 0.058948141003005
4027, 0.66194948415696, 0.13909587455189, 0.043805399719933
4028, 0.77096028782412, 0.463206917059, 0.058457194471195
4029, 0.56865415540181, 0.78051080546654, 0.041103594141999
4030, 0.5033733575191, 0.68841504151893, 0.060582637453031
4031, 0.73828761526666, 0.50585105943162, 0.039769007423377
4032, 0.58563739873456, 0.424690035381, 0.059627440876813
4033, 0.49243025624873, 0.76923122854058, 0.042220434385668
4034, 0.71888823617911, 0.092124523260897, 0.039732787200198
4035, 0.84554599878854, 0.54762065891969, 0.039276558339373
4036, 0.61586850566124, 0.37371157253367, 0.039944780466896
4037, 0.522253764415, 0.82673682966386, 0.061290969590166
4038, 0.83058047439836, 0.34906936094785, 0.061257103299242
4039, 0.68160010540946, 0.83607114547643, 0.059975068468471
4040, 0.50049954859464, 0.52485487994263, 0.061668638618551
4041, 0.53276334547025, 0.7088395838014, 0.03838443688134
4042, 0.67285654380986, 0.48744444051695, 0.038619789594655
4043, 0.69878407853287, 0.37825917128204, 0.060994281173799
4044, 0.80168677052572, 0.7019082575834, 0.038569882797951
4045, 0.8455623076551, 0.6699146601165, 0.038492021331894
4046, 0.74011674609029, 0.61761402582499, 0.038459901990698
4047, 0.9003251337418, 0.37793882148761, 0.058901783350299
4048, 0.58286566089128, 0.59446121888234, 0.061782940436077
4049, 0.52647253620718, 0.41876053097421, 0.041956979790802
4050, 0.66997626132093, 0.063410462822807, 0.061475412427249
4051, 0.78044538445131, 0.24113183542551, 0.061514867809741
4052, 0.87191900090465, 0.68765008699573, 0.061573555418569
4053, 0.66833944997303, 0.56088543747955, 0.062062130114968
4054, 0.65994162203181, 0.34034963645386, 0.037773070215024
4055, 0.73391895582308, 0.73122288940867, 0.038004858057786
4056, 0.901326877322, 0.45086528574881, 0.061371382649862
4057, 0.71588177857127, 0.2327699911871, 0.062570098970107
4058, 0.58906888592367, 0.66970959598521, 0.036945616127943
4059, 0.90203724718492, 0.56835586941983, 0.060892604288653
4060, 0.79431284825955, 0.74677374530606, 0.037598660682528
4061, 0.85370490284745, 0.19951540206709, 0.062691715072535
4062, 0.67686971825379, 0.036542767900412, 0.036294299124183
4063, 0.59054750872849, 0.32146933783138, 0.037869590900092
4064, 0.77057143220548, 0.39081110525852, 0.062560669497294
4065, 0.3808941688846, 0.55401775561184, 0.036406317659075
4066, 0.86496132657286, 0.61752916836723, 0.063457821203388
4067, 0.67328017012188, 0.26525672263899, 0.036457463812241
4068, 0.61443608944534, 0.54123897355715, 0.063103751893699
4069, 0.90160967059229, 0.75588189113536, 0.038106447518411
4070, 0.77751643541853, 0.56530982866524, 0.03690306246717
4071, 0.74678104423224, 0.175807047486, 0.037894033885584
4072, 0.70168681413907, 0.76601228508302, 0.063973732950033
4073, 0.83041992708039, 0.58180971005841, 0.036885039285754
4074, 0.7373013879038, 0.07036833820908, 0.063343067765047
4075, 0.72846903735833, 0.35520002202002, 0.062643903454535
4076, 0.77938154624524, 0.12580509042846, 0.063620273642953
4077, 0.82906035178911, 0.28946340316164, 0.035785347093696
4078, 0.38700084616611, 0.60123714042036, 0.064399712045779
4079, 0.86293746306513, 0.74534090732104, 0.037127359291709
4080, 0.54291147372839, 0.62721380413596, 0.063743443413308
4081, 0.72251554901493, 0.66699365221642, 0.035253929989377
4082, 0.65704179798288, 0.41584971640864, 0.064921293392591
4083, 0.71988887975198, 0.82805739665489, 0.040509823149545
4084, 0.77412306395278, 0.32283958331898, 0.063065537702511
4085, 0.69672188677109, 0.5102759219306, 0.063848618771163
4086, 0.68816887089043, 0.45217454015918, 0.063947110675984
4087, 0.55088180054873, 0.47987356421325, 0.035515718669791
4088, 0.9032237550329, 0.20643526710094, 0.036273126256628
4089, 0.57184180717254, 0.47365679316848, 0.064534522738689
4090, 0.46991857078719, 0.74460173780244, 0.06063819984267
4091, 0.66135619472975, 0.58930827683813, 0.03560783458935
4092, 0.65573442471255, 0.65603180452082, 0.06440597934493
4093, 0.81086415369544, 0.72700827747685, 0.063627311570081
4094, 0.90247107961599, 0.68710179398159, 0.038075090983985
4095, 0.64646555544102, 0.48751828779165, 0.063777242324328
4096, 0.76745158671973, 0.75457334456484, 0.064316990599112
4097, 0.51940858587817, 0.75629370573325, 0.063818860848672
4098, 0.67691205713195, 0.64966643321399, 0.035517991796139
4099, 0.81056113034732, 0.51191893782369, 0.063962099787334
4100, 0.50414522626805, 0.66262109082189, 0.035228040433992
4101, 0.6644822229339, 0.8002231360339, 0.034772969562542
4102, 0.60837352131571, 0.64105033880033, 0.065280708706696
4103, 0.55541213211267, 0.70035802429494, 0.065026905013588
4104, 0.80095907458896, 0.22831725275375, 0.034695085474935
4105, 0.59220928528203, 0.38872447465897, 0.063797562888706
4106, 0.73772684504951, 0.22205711224845, 0.035550205589264
4107, 0.73987364965682, 0.64193516940267, 0.064967415609081
4108, 0.43844982034865, 0.68806592929621, 0.035624721171901
4109, 0.49591186575928, 0.54750313216919, 0.034548700144685
4110, 0.43285750991933, 0.59676295248011, 0.065161137721394
4111, 0.63541518054385, 0.53572335865139, 0.034672580494634
4112, 0.82780551523346, 0.10516613167899, 0.065716183847306
4113, 0.63430212774529, 0.8568038556104, 0.034777682395601
4114, 0.84339751770241, 0.64619950860411, 0.065392475265725
4115, 0.73412742103171, 0.038469280238907, 0.034748325590961
4116, 0.90456291387533, 0.2678088638262, 0.06494019662251
4117, 0.6321164654478, 0.79637533820236, 0.065572028481674
4118, 0.71950103161894, 0.60668728208934, 0.065438754898106
4119, 0.78085418360463, 0.69101514223444, 0.06544510693322
4120, 0.68247957014458, 0.7684799370464, 0.034159043525429
4121, 0.44068363758989, 0.50682278219124, 0.062820939506738
4122, 0.72259612722895, 0.1172767929399, 0.065272539446427
4123, 0.79474037019037, 0.34606773389349, 0.034157500590141
4124, 0.78964582339385, 0.033586788000606, 0.033306394414788
4125, 0.74132705253086, 0.4815783780331, 0.065627222128008
4126, 0.6859709004862, 0.54854961323671, 0.034034246916522
4127, 0.69007720011166, 0.30827845747327, 0.035312423971279
4128, 0.70342571671849, 0.66830834348553, 0.064981200789216
4129, 0.83397429824931, 0.38694680233981, 0.065668193498324
4130, 0.70640783759266, 0.44718669674814, 0.033980231600542
4131, 0.59454916307635, 0.52753459545853, 0.034989556391733
4132, 0.86957849205781, 0.15020720724688, 0.066237082249312
4133, 0.62060820152669, 0.78080054836395, 0.03506630360561
4134, 0.56997635661288, 0.66679930795943, 0.0662766472303
4135, 0.83629797007453, 0.085735640393367, 0.033911899746801
4136, 0.62996174979302, 0.47630220763036, 0.034892734746312
4137, 0.80149185848799, 0.81045283654607, 0.034247280713636
4138, 0.53351534540374, 0.85471628786588, 0.041363687213173
4139, 0.5027435575606, 0.80299026634499, 0.033417068895126
4140, 0.55757122258749, 0.80118619034088, 0.066831882419832
4141, 0.44868113773728, 0.64469043208483, 0.033340346633932
4142, 0.71092621926393, 0.2518190563026, 0.033357622162419
4143, 0.53647452884989, 0.6418297893706, 0.032924648315255
4144, 0.48781576764907, 0.60844746355582, 0.032692454991958
4145, 0.48781576764907, 0.60844746355582, 0.067307545008042
4146, 0.85127841626014, 0.1811331067523, 0.033263373249991
4147, 0.57955113401584, 0.73448877142897, 0.032730564068907
4148, 0.90657706304565, 0.6430628524223, 0.066332262897709
4149, 0.48483825135033, 0.69868832774963, 0.033094177165584
4150, 0.7338762163428, 0.28314155303042, 0.033499385904995
4151, 0.6168099448521, 0.69818279294197, 0.032739356330643
4152, 0.56196546686124, 0.53585949959761, 0.067312002871641
4153, 0.62659134322998, 0.44284608491395, 0.067297009915867
4154, 0.57954856353681, 0.73449247013242, 0.067322924988686
4155, 0.66699143055238, 0.71231051121502, 0.032774834756475
4156, 0.62969728535938, 0.74864583191367, 0.067227927985661
4157, 0.60362864643827, 0.58023992597517, 0.034567412572799
4158, 0.61681424903881, 0.6981831580607, 0.067328771270136
