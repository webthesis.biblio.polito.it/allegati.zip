11593, 4306, 4719, 541, 5446
11594, 3903, 5311, 4530, 5762
11595, 3772, 3771, 3713, 4428
11596, 1098, 4297, 1385, 6035
11597, 4985, 5643, 4689, 5837
11598, 2782, 2781, 4208, 5378
11599, 595, 4629, 1291, 5367
11600, 3612, 4200, 4503, 4928
11601, 4304, 4988, 4191, 5087
11602, 3718, 4469, 3882, 4775
11603, 4132, 4935, 4419, 6012
11604, 896, 5556, 4065, 5562
11605, 4023, 5112, 4909, 5345
11606, 941, 942, 4535, 4791
11607, 3263, 4848, 5194, 6101
11608, 5045, 5284, 4487, 5656
11609, 3994, 4839, 4517, 5029
11610, 351, 350, 858, 4942
11611, 4325, 571, 4958, 5823
11612, 644, 1006, 4787, 5502
11613, 3936, 4139, 5315, 5596
11614, 782, 5564, 4513, 5591
11615, 2749, 3474, 4389, 4809
11616, 4140, 3929, 4605, 5224
11617, 829, 815, 1090, 4385
11618, 3927, 4152, 4729, 5068
11619, 3917, 4370, 5118, 5706
11620, 1392, 1214, 1407, 4291
11621, 2952, 2324, 5040, 5227
11622, 3932, 4860, 4566, 5701
11623, 1296, 4759, 4339, 5285
11624, 323, 4291, 3598, 5117
11625, 2314, 2421, 3028, 4453
11626, 866, 5360, 949, 5399
11627, 3199, 4612, 5078, 5695
11628, 1373, 4309, 1137, 5919
11629, 382, 4458, 5072, 5894
11630, 2805, 4852, 2644, 5986
11631, 4064, 4755, 4279, 4847
11632, 3189, 4417, 2739, 5669
11633, 2641, 2805, 2644, 5986
11634, 2310, 2388, 4970, 5387
11635, 4133, 4484, 5187, 5492
11636, 3058, 4996, 4203, 5688
11637, 4278, 5671, 5252, 5940
11638, 4083, 4920, 5243, 5682
11639, 3959, 4792, 4358, 5142
11640, 1014, 5103, 1271, 6218
11641, 3857, 5079, 4435, 5620
11642, 484, 1221, 4572, 4749
11643, 2257, 4217, 2267, 5822
11644, 3917, 4087, 4699, 4808
11645, 4226, 2796, 4970, 5706
11646, 4487, 5149, 4350, 5343
11647, 3959, 4358, 4748, 5142
11648, 4222, 3900, 4689, 4985
11649, 3922, 4813, 4516, 4971
11650, 701, 630, 4856, 4879
11651, 742, 4141, 690, 5500
11652, 4138, 5263, 4548, 5415
11653, 4150, 4794, 4878, 5894
11654, 347, 3452, 3333, 4582
11655, 4384, 4404, 3993, 4875
11656, 4006, 4208, 5030, 5099
11657, 3058, 4203, 2431, 5688
11658, 3950, 4096, 4918, 5544
11659, 2472, 4881, 4160, 4950
11660, 595, 4379, 4629, 5091
11661, 4295, 5122, 4431, 5543
11662, 494, 1160, 4523, 4679
11663, 4180, 4665, 4369, 4867
11664, 5157, 5462, 4091, 5525
11665, 543, 1204, 4549, 5366
11666, 3929, 4801, 5415, 5680
11667, 3129, 3199, 4612, 5078
11668, 5204, 5596, 4255, 5666
11669, 4057, 5322, 4434, 5434
11670, 3972, 5279, 5047, 6137
11671, 799, 5108, 4101, 5816
11672, 2641, 2644, 5361, 5986
11673, 3713, 4428, 299, 4790
11674, 4498, 5384, 5164, 5543
11675, 989, 971, 1394, 4768
11676, 4286, 4474, 4022, 5367
11677, 3947, 4441, 5269, 5366
11678, 3920, 4611, 4097, 4943
11679, 4461, 4855, 3970, 5144
11680, 523, 4697, 4259, 4954
11681, 2450, 4769, 4663, 6057
11682, 710, 4603, 5244, 5900
11683, 4239, 5020, 3950, 5544
11684, 380, 5072, 378, 5894
11685, 2323, 5040, 4838, 5886
11686, 2795, 2763, 4907, 5706
11687, 3992, 4701, 4595, 4939
11688, 4237, 4754, 3920, 6047
11689, 4189, 4509, 4974, 6075
11690, 2992, 4368, 4677, 5811
11691, 4124, 3899, 4445, 5531
11692, 3174, 2151, 3103, 4508
11693, 3733, 5284, 5045, 5656
11694, 1020, 1182, 4566, 5493
11695, 3963, 4784, 4449, 5989
11696, 4325, 4744, 3954, 5823
11697, 2525, 4172, 5013, 5879
11698, 3805, 5773, 3855, 6221
11699, 5053, 5189, 4617, 5226
11700, 3941, 5541, 5076, 6010
11701, 4428, 5094, 3985, 5352
11702, 3947, 5008, 4638, 5269
11703, 4222, 3976, 4558, 5592
11704, 306, 885, 4445, 5725
11705, 4329, 4765, 4372, 4957
11706, 3994, 4839, 4207, 4946
11707, 878, 1320, 776, 4305
11708, 5007, 5010, 4442, 5449
11709, 3930, 4158, 4901, 5184
11710, 4431, 5122, 4295, 5584
11711, 3998, 4295, 4598, 5033
11712, 3388, 5176, 3389, 5947
11713, 3995, 4670, 4244, 4797
11714, 3954, 4744, 4268, 5073
11715, 3208, 3127, 4365, 6077
11716, 4654, 5152, 4102, 5699
11717, 4264, 4872, 3973, 5243
11718, 4128, 4638, 5008, 5269
11719, 1252, 4712, 5276, 5633
11720, 4249, 5067, 4938, 5180
11721, 4736, 5238, 4156, 5848
11722, 1101, 4374, 5401, 5981
11723, 2255, 4134, 4813, 5517
11724, 3899, 5890, 4445, 5998
11725, 5002, 5793, 3908, 6079
11726, 3375, 5014, 4648, 5266
11727, 4544, 4757, 4248, 5303
11728, 2642, 3171, 2640, 4688
11729, 3945, 4807, 4102, 5559
11730, 2580, 3016, 2969, 5226
11731, 792, 5702, 1306, 5722
11732, 2329, 4635, 2951, 4838
11733, 563, 4829, 4179, 5399
11734, 4146, 5027, 4474, 5539
11735, 868, 1246, 4460, 5360
11736, 5054, 5683, 4911, 5714
11737, 2941, 4335, 4852, 5661
11738, 4452, 4622, 3952, 5342
11739, 3976, 4412, 4532, 5234
11740, 3057, 3721, 2148, 4448
11741, 5042, 5289, 4218, 5631
11742, 4123, 5095, 4234, 5109
11743, 2272, 4912, 2271, 5640
11744, 4020, 4294, 5216, 6018
11745, 3771, 930, 4428, 5286
11746, 4033, 4240, 4793, 5315
11747, 4518, 5099, 4208, 5121
11748, 4062, 4820, 4674, 4942
11749, 3912, 4896, 4382, 5200
11750, 3937, 4451, 4933, 5302
11751, 2779, 4140, 2895, 5227
11752, 1015, 1014, 1012, 4461
11753, 1061, 4687, 4441, 5366
11754, 1235, 4620, 4898, 5424
11755, 4105, 4934, 4821, 5679
11756, 3255, 4312, 2143, 5021
11757, 3943, 4629, 4379, 5581
11758, 4351, 4403, 4010, 5965
11759, 4011, 4308, 5153, 5172
11760, 4198, 5035, 4513, 6226
11761, 2354, 4302, 2356, 6105
11762, 4268, 5073, 4744, 5645
11763, 2310, 4265, 2940, 6113
11764, 4013, 4387, 5235, 5470
11765, 4086, 4802, 4363, 5857
11766, 3529, 3555, 3556, 4885
11767, 4813, 4971, 4438, 5148
11768, 3969, 4189, 5309, 5522
11769, 1227, 4687, 1061, 5366
11770, 3904, 4314, 4568, 4857
11771, 3918, 4711, 4232, 5262
11772, 4105, 4934, 5679, 5801
11773, 3576, 3474, 3537, 4809
11774, 4470, 5282, 4044, 5533
11775, 322, 3424, 4491, 5562
11776, 4008, 4902, 4281, 6232
11777, 4877, 5674, 4339, 5787
11778, 3441, 3414, 4436, 5797
11779, 4016, 4317, 4460, 5878
11780, 878, 4305, 776, 5305
11781, 5294, 5443, 4652, 6199
11782, 1392, 1407, 323, 4291
11783, 1408, 4334, 819, 5049
11784, 4391, 5284, 5046, 5628
11785, 4412, 5802, 3988, 6164
11786, 3988, 4593, 4506, 5889
11787, 1175, 506, 507, 4176
11788, 4318, 4814, 4469, 5166
11789, 4346, 5008, 4951, 5642
11790, 3547, 4389, 3548, 4890
11791, 761, 4715, 5203, 5733
11792, 4199, 5558, 4837, 6201
11793, 536, 4644, 4742, 6097
11794, 3914, 4632, 4187, 5806
11795, 4558, 5015, 987, 5100
11796, 3592, 5670, 3620, 6091
11797, 896, 1409, 4582, 5637
11798, 2457, 2556, 2555, 4191
11799, 3955, 4847, 4362, 5095
11800, 2757, 4837, 5558, 6201
11801, 5107, 5351, 4543, 5926
11802, 4080, 4711, 4438, 5403
11803, 614, 4447, 643, 5673
11804, 4009, 4218, 5007, 5010
11805, 3070, 4118, 4938, 4991
11806, 3877, 4281, 5331, 5888
11807, 3902, 5005, 4161, 5627
11808, 3969, 4127, 4555, 5522
11809, 4319, 4740, 748, 5244
11810, 4080, 4795, 4682, 5113
11811, 3634, 4291, 4939, 5430
11812, 837, 1186, 4811, 5860
11813, 1274, 4726, 1038, 5892
11814, 4979, 5081, 4289, 5616
11815, 3925, 4798, 4567, 5568
11816, 3170, 4831, 3111, 5375
11817, 4080, 4682, 4514, 5113
11818, 4076, 4645, 4955, 5190
11819, 4608, 4736, 4302, 5548
11820, 4474, 4761, 4146, 5676
11821, 2979, 4822, 2416, 5810
11822, 4414, 4795, 3945, 5559
11823, 5346, 5382, 4103, 5517
11824, 4229, 674, 5313, 5355
11825, 4289, 5300, 4711, 5691
11826, 2719, 2623, 4327, 6154
11827, 1242, 541, 1174, 5446
11828, 3925, 4678, 4211, 5003
11829, 3952, 5230, 4477, 6002
11830, 4163, 4628, 4020, 5133
11831, 4170, 3957, 4778, 5086
11832, 5077, 5666, 4139, 6151
11833, 3909, 4538, 4826, 5318
11834, 2257, 4862, 4217, 5822
11835, 3513, 4193, 3515, 5125
11836, 3960, 4812, 4383, 6230
11837, 3037, 4173, 2393, 5249
11838, 4139, 1315, 4793, 6151
11839, 3336, 5147, 3337, 5413
11840, 3980, 4800, 4560, 5884
11841, 3965, 5160, 4596, 5738
11842, 3955, 5095, 4234, 5944
11843, 4186, 4036, 5372, 5396
11844, 3958, 4844, 4644, 5349
11845, 578, 580, 579, 4261
11846, 3340, 3334, 4674, 4942
11847, 3954, 4744, 5073, 6138
11848, 3980, 5884, 4560, 5909
11849, 3946, 5162, 4117, 5201
11850, 3960, 4656, 4383, 4812
11851, 2858, 3070, 4938, 4991
11852, 601, 621, 4975, 5027
11853, 3982, 4477, 4235, 6002
11854, 4250, 4621, 4878, 5894
11855, 4045, 4114, 5455, 5786
11856, 3404, 4911, 4449, 5714
11857, 4469, 5045, 3736, 5166
11858, 4169, 3928, 4895, 5060
11859, 536, 4742, 1187, 6097
11860, 4883, 5007, 4218, 6118
11861, 2237, 5552, 2229, 6001
11862, 5063, 5229, 4354, 5376
11863, 3902, 5005, 4305, 5791
11864, 2781, 2689, 4208, 5436
11865, 3904, 4568, 4314, 5169
11866, 4114, 5334, 4743, 5423
11867, 3991, 5187, 4484, 5492
11868, 1264, 4601, 4687, 5412
11869, 3906, 4162, 4523, 5292
11870, 4075, 4498, 5351, 5543
11871, 990, 4286, 5196, 5625
11872, 3901, 4766, 4651, 5358
11873, 4411, 4713, 2223, 5374
11874, 701, 4328, 630, 4879
11875, 4329, 5050, 4028, 5953
11876, 626, 987, 5015, 5100
11877, 4853, 4904, 4392, 5380
11878, 4297, 3983, 5534, 5966
11879, 4708, 5224, 4140, 5227
11880, 541, 4719, 4306, 5658
11881, 4104, 4776, 4305, 5305
11882, 4295, 3998, 5122, 5543
11883, 4055, 4662, 4550, 5347
11884, 939, 5212, 4922, 5592
11885, 4496, 4607, 4251, 5729
11886, 5098, 5448, 4171, 6136
11887, 1293, 1030, 4977, 5333
11888, 3961, 5185, 5029, 6187
11889, 3982, 5150, 4225, 5175
11890, 4187, 4784, 4467, 5376
11891, 4547, 5240, 4028, 5497
11892, 4470, 4742, 795, 5912
11893, 3915, 4161, 4761, 4763
11894, 3934, 4147, 4610, 5454
11895, 3946, 4705, 4245, 5201
11896, 4006, 4233, 5391, 5417
11897, 2663, 2678, 2661, 4312
11898, 857, 5563, 4137, 5881
11899, 2353, 2993, 2298, 4736
11900, 1240, 1144, 976, 5398
11901, 3919, 5089, 4447, 5209
11902, 2431, 3058, 3061, 4203
11903, 742, 690, 4141, 5503
11904, 2719, 4327, 5651, 6154
11905, 4519, 5052, 2824, 5980
11906, 3497, 4707, 3499, 4796
11907, 3992, 4228, 4762, 5430
11908, 2954, 4753, 3009, 5432
11909, 2460, 2463, 2875, 5247
11910, 5688, 4528, 5808, 6138
11911, 3746, 3745, 5062, 5613
11912, 2353, 4736, 2298, 5548
11913, 2447, 4358, 2891, 5240
11914, 4115, 5772, 5208, 5890
11915, 4986, 5054, 3396, 5714
11916, 3950, 4872, 4264, 5020
11917, 415, 413, 5157, 5462
11918, 4021, 4783, 4227, 6156
11919, 978, 4585, 5002, 6193
11920, 1212, 489, 485, 5471
11921, 2895, 4140, 2779, 6155
11922, 1220, 388, 4773, 5496
11923, 3967, 4183, 4547, 5681
11924, 762, 5203, 4282, 6160
11925, 1038, 4692, 4284, 5892
11926, 3227, 1211, 5495, 6043
11927, 5201, 5906, 4245, 6079
11928, 2891, 4358, 4748, 5240
11929, 842, 5860, 4656, 5939
11930, 3089, 2556, 5074, 5296
11931, 3959, 4179, 4792, 5783
11932, 3369, 4384, 2714, 5016
11933, 1160, 4162, 621, 5791
11934, 4131, 5165, 4706, 5179
11935, 4781, 4793, 1315, 6151
11936, 4511, 4970, 2388, 5387
11937, 3377, 4641, 3373, 5654
11938, 3958, 4159, 4844, 5349
11939, 347, 4582, 3333, 5562
11940, 608, 4572, 1105, 4724
11941, 762, 4715, 4282, 5203
11942, 4071, 4947, 4622, 5205
11943, 741, 716, 985, 4780
11944, 370, 4622, 371, 5342
11945, 4375, 5455, 4114, 5786
11946, 3340, 4674, 3338, 4942
11947, 2528, 2662, 2661, 5021
11948, 3628, 4508, 3494, 6159
11949, 4132, 4987, 4731, 5464
11950, 4558, 5643, 4985, 5837
11951, 3940, 4363, 5303, 5767
11952, 4197, 4325, 4958, 5250
11953, 4062, 4857, 5420, 6101
11954, 2580, 2969, 5053, 5189
11955, 3940, 4802, 4363, 5767
11956, 4510, 4657, 2692, 5995
11957, 2835, 4301, 2837, 5863
11958, 2302, 2423, 2403, 5618
11959, 4373, 4933, 4805, 5574
11960, 3957, 4710, 4367, 5327
11961, 4006, 5391, 4621, 5417
11962, 2783, 2970, 4631, 5882
11963, 4358, 4792, 3959, 5050
11964, 3020, 4361, 3009, 5416
11965, 3910, 5379, 4756, 6147
11966, 3828, 3860, 3715, 4433
11967, 4016, 4435, 4348, 5297
11968, 4180, 5277, 4833, 5386
11969, 4334, 4281, 5344, 5408
11970, 670, 4873, 4398, 5156
11971, 404, 1092, 402, 4660
11972, 3910, 4275, 5481, 6180
11973, 1407, 4939, 4291, 5338
11974, 921, 5421, 1399, 5623
11975, 2620, 5411, 4182, 5527
11976, 4126, 4373, 5489, 5809
11977, 4493, 4229, 5355, 6037
11978, 953, 5257, 4856, 5725
11979, 4439, 4870, 3987, 5071
11980, 4277, 4464, 3933, 4849
11981, 3974, 4257, 4731, 5155
11982, 929, 315, 1410, 4469
11983, 2264, 2297, 2298, 5040
11984, 3957, 4119, 4693, 4844
11985, 4280, 5218, 4627, 5991
11986, 866, 1246, 5360, 5399
11987, 4229, 5313, 4557, 5355
11988, 4312, 5154, 4313, 5988
11989, 4318, 4483, 3010, 4902
11990, 3042, 2272, 2270, 4912
11991, 3929, 4399, 4841, 5299
11992, 4651, 1294, 5153, 5565
11993, 1214, 5338, 4291, 5845
11994, 441, 448, 4764, 5642
11995, 3404, 3393, 4405, 5054
11996, 4126, 4860, 4833, 5574
11997, 4352, 6095, 3440, 6127
11998, 2339, 4589, 2342, 5817
11999, 3745, 4846, 3743, 5062
12000, 4018, 4679, 4277, 5317
12001, 3919, 4740, 5064, 5796
12002, 1279, 1000, 4362, 5122
12003, 3955, 4639, 4234, 5649
12004, 4425, 5206, 3931, 5709
12005, 404, 4660, 402, 5993
12006, 3958, 5009, 5463, 5786
12007, 4140, 4841, 3929, 5224
12008, 4285, 4648, 5368, 6061
12009, 4064, 5095, 4543, 5164
12010, 1044, 646, 4702, 5645
12011, 4451, 4655, 4053, 5275
12012, 2874, 2411, 4821, 5679
12013, 4185, 4694, 4337, 5741
12014, 3888, 3729, 3721, 5321
12015, 4631, 5378, 3949, 5882
12016, 1159, 5271, 4710, 6134
12017, 4625, 4668, 3911, 5177
12018, 2655, 4815, 4356, 5457
12019, 4394, 4506, 3344, 5392
12020, 3924, 4785, 4282, 4866
12021, 4154, 3934, 4608, 4736
12022, 589, 5507, 5063, 6229
12023, 3923, 4838, 4298, 6063
12024, 1175, 506, 4176, 5892
12025, 4304, 5025, 2395, 5851
12026, 4061, 4286, 5676, 6049
12027, 3352, 4201, 5082, 5357
12028, 1245, 4343, 1252, 5633
12029, 4833, 4860, 4126, 6099
12030, 3907, 5264, 5556, 5835
12031, 3900, 4222, 4689, 5150
12032, 1064, 1060, 4288, 5425
12033, 2154, 2683, 5044, 5949
12034, 4589, 4965, 4271, 5456
12035, 3943, 5121, 4583, 5529
12036, 3957, 4778, 4364, 5327
12037, 578, 580, 4261, 5718
12038, 4352, 4488, 4002, 4906
12039, 1227, 4687, 5366, 5412
12040, 3147, 4804, 4462, 5811
12041, 2393, 4817, 2892, 5249
12042, 1172, 4544, 1041, 5333
12043, 3516, 4976, 3514, 5402
12044, 3929, 4231, 4444, 6053
12045, 2205, 2203, 4565, 5648
12046, 4265, 5017, 4270, 5042
12047, 1207, 4319, 748, 5244
12048, 4353, 5187, 4117, 5191
12049, 3986, 4272, 5069, 5774
12050, 4134, 5517, 5127, 5744
12051, 4006, 4250, 4621, 4878
12052, 434, 5232, 4992, 5993
12053, 5161, 5488, 4259, 5610
12054, 3949, 5378, 4631, 5918
12055, 3906, 4205, 4563, 4989
12056, 3582, 4199, 3507, 5486
12057, 3933, 4464, 4277, 4845
12058, 4721, 4783, 4227, 5854
12059, 3974, 5344, 4281, 5464
12060, 2238, 3073, 5497, 6024
12061, 3159, 2642, 2676, 5613
12062, 2302, 2403, 4935, 5618
12063, 4561, 5270, 5022, 5740
12064, 4000, 5021, 4931, 5452
12065, 1020, 4333, 1022, 5493
12066, 3933, 4419, 4483, 4845
12067, 528, 4660, 5277, 5701
12068, 3955, 4234, 4639, 5944
12069, 2662, 5021, 2528, 5321
12070, 955, 4793, 4781, 5459
12071, 1254, 4577, 4665, 5752
12072, 4792, 4829, 4179, 5545
12073, 657, 4651, 4308, 6042
12074, 4345, 4741, 663, 5826
12075, 551, 4610, 496, 5454
12076, 4271, 4589, 4945, 4965
12077, 4808, 5017, 4265, 5387
12078, 3823, 4469, 959, 5045
12079, 639, 4240, 692, 5459
12080, 4292, 5214, 4106, 5322
12081, 3223, 306, 3281, 5495
12082, 3859, 5370, 4962, 5550
12083, 3813, 3797, 3704, 4752
12084, 572, 1161, 4958, 5923
12085, 4533, 5003, 4695, 5554
12086, 1198, 4146, 656, 5539
12087, 424, 4673, 4549, 5969
12088, 1401, 1366, 890, 5646
12089, 842, 4656, 4812, 5939
12090, 4369, 4665, 4180, 5752
12091, 3404, 4405, 4911, 5054
12092, 4747, 5050, 4174, 5144
12093, 4396, 4949, 3905, 5195
12094, 2591, 4457, 2575, 5619
12095, 2286, 2287, 2285, 5691
12096, 4210, 4671, 1040, 5401
12097, 2716, 4386, 4875, 5266
12098, 3998, 4598, 4123, 5926
12099, 4270, 4808, 4265, 5042
12100, 3992, 4300, 5241, 5982
12101, 3909, 4826, 5219, 5318
12102, 4630, 5031, 4309, 5337
12103, 1411, 691, 4651, 5358
12104, 1106, 5381, 4851, 5964
12105, 3980, 4466, 4800, 5884
12106, 4192, 5039, 4276, 5994
12107, 3902, 4581, 5074, 5627
12108, 3953, 4778, 4170, 4965
12109, 4785, 5203, 4715, 5916
12110, 4105, 5245, 5806, 5810
12111, 4160, 5280, 4950, 5962
12112, 3007, 5691, 4721, 6066
12113, 4622, 4649, 370, 5864
12114, 2789, 4412, 2675, 5485
12115, 3926, 5168, 4232, 5473
12116, 3548, 4890, 4389, 5220
12117, 2418, 4489, 4821, 5788
12118, 4592, 5008, 4081, 6015
12119, 4571, 4042, 5333, 5493
12120, 3952, 4947, 4205, 6002
12121, 393, 4670, 394, 5946
12122, 2400, 4300, 2425, 5982
12123, 3744, 4846, 4224, 5310
12124, 3944, 4343, 5126, 5504
12125, 4255, 715, 5204, 5908
12126, 4295, 5543, 4431, 5584
12127, 3982, 4866, 4922, 5150
12128, 1043, 4268, 572, 5645
12129, 4434, 4866, 4057, 5434
12130, 883, 5072, 5635, 6070
12131, 4261, 4949, 4904, 5195
12132, 2823, 4347, 3031, 5626
12133, 1194, 4458, 384, 4714
12134, 3515, 4193, 3513, 4976
12135, 5107, 5490, 4234, 5944
12136, 2951, 4237, 4635, 5382
12137, 3979, 5164, 4498, 5384
12138, 3901, 4509, 4262, 4810
12139, 4059, 4320, 4395, 5557
12140, 2227, 5552, 2226, 5859
12141, 3202, 4448, 5021, 5321
12142, 4119, 3957, 4693, 5192
12143, 1274, 1036, 1038, 4726
12144, 2184, 2186, 2185, 4800
12145, 4106, 3952, 5205, 5342
12146, 3917, 5405, 4699, 5576
12147, 4118, 4867, 4369, 5466
12148, 3918, 4711, 4289, 5140
12149, 2144, 3284, 3099, 5326
12150, 2580, 2969, 5189, 5226
12151, 397, 1270, 399, 4171
12152, 4013, 4513, 4310, 5235
12153, 3992, 5411, 5189, 5982
12154, 4201, 4015, 5097, 6029
12155, 2418, 4489, 2874, 4821
12156, 4297, 5508, 1385, 6035
12157, 490, 4164, 488, 5743
12158, 4381, 4888, 4526, 6032
12159, 4033, 4943, 4240, 5315
12160, 4438, 4813, 2266, 5721
12161, 4109, 4896, 3912, 5200
12162, 2400, 4708, 4300, 5982
12163, 4772, 5220, 3545, 6103
12164, 3772, 4428, 3713, 4790
12165, 4229, 4871, 3997, 5313
12166, 4336, 5064, 4319, 5796
12167, 4317, 4680, 949, 5399
12168, 3870, 3767, 3869, 4492
12169, 3998, 4466, 5033, 5926
12170, 404, 4992, 4660, 5993
12171, 4536, 3949, 5378, 5882
12172, 4115, 5208, 4568, 5614
12173, 2593, 4237, 2484, 5382
12174, 1098, 1385, 4297, 6023
12175, 3510, 5111, 3582, 5486
12176, 4339, 4175, 5101, 5285
12177, 2667, 4348, 4843, 6123
12178, 4106, 3982, 4649, 5132
12179, 2450, 4220, 4769, 6057
12180, 4247, 5395, 4562, 6091
12181, 4143, 4080, 4795, 5403
12182, 3955, 4234, 5095, 5649
12183, 4232, 4030, 5168, 5242
12184, 3344, 4506, 4394, 5510
12185, 2985, 2557, 4518, 4988
12186, 3959, 4168, 4748, 5720
12187, 3938, 4118, 4832, 4867
12188, 3922, 4438, 4813, 4971
12189, 2813, 5142, 4888, 5846
12190, 3959, 4748, 4792, 5142
12191, 3202, 5021, 2677, 5321
12192, 488, 4164, 490, 6062
12193, 3524, 4640, 3500, 4707
12194, 2535, 5999, 4226, 6205
12195, 2929, 2482, 4666, 5028
12196, 3902, 4776, 4104, 4981
12197, 3962, 5092, 4324, 5283
12198, 4225, 5150, 3900, 5602
12199, 5293, 5529, 5121, 6130
12200, 4692, 5065, 3927, 5655
12201, 2194, 4653, 3100, 4863
12202, 4423, 5431, 4537, 5684
12203, 4135, 5268, 4700, 5311
12204, 3988, 4803, 4412, 6164
12205, 3956, 4241, 4903, 5320
12206, 2950, 5476, 4565, 5587
12207, 3718, 1410, 315, 4469
12208, 958, 789, 4554, 5516
12209, 4056, 4804, 4462, 6039
12210, 1073, 4651, 1294, 5153
12211, 4297, 3983, 4842, 4972
12212, 4312, 3978, 5154, 5988
12213, 3729, 4448, 3721, 5321
12214, 3936, 4793, 4240, 5315
12215, 501, 956, 1146, 4849
12216, 1175, 4176, 507, 5450
12217, 2135, 2922, 3821, 5136
12218, 4297, 4325, 4972, 6023
12219, 5730, 6021, 4476, 6172
12220, 2142, 3539, 4521, 5261
12221, 4441, 5642, 4592, 5784
12222, 3963, 5137, 4669, 5801
12223, 2679, 4827, 4338, 5958
12224, 3928, 5060, 4597, 5641
12225, 4136, 5519, 4894, 5573
12226, 2260, 2266, 4813, 5721
12227, 3963, 5561, 5137, 5801
12228, 4761, 4763, 4162, 5963
12229, 4011, 4648, 4285, 4886
12230, 3678, 4562, 3660, 5048
12231, 4006, 4355, 5121, 5417
12232, 3930, 5152, 4659, 5513
12233, 954, 952, 4793, 5204
12234, 334, 1075, 1074, 4752
12235, 2959, 2821, 2825, 4655
12236, 3999, 4392, 4893, 4924
12237, 3908, 4588, 4117, 6079
12238, 4134, 4682, 4795, 5559
12239, 4438, 2265, 4813, 5148
12240, 2227, 2229, 2226, 5552
12241, 3930, 4267, 5006, 6109
12242, 4164, 488, 5743, 6062
12243, 4285, 4886, 4648, 6061
12244, 2272, 2273, 2271, 4912
12245, 4379, 4923, 5295, 6223
12246, 1312, 4296, 1075, 4924
12247, 980, 650, 4739, 5896
12248, 4686, 4895, 4185, 5750
12249, 4470, 3962, 5092, 5533
12250, 2838, 4729, 5218, 5353
12251, 4006, 4208, 5121, 5350
12252, 4407, 4951, 3947, 5088
12253, 3945, 4795, 4682, 5559
12254, 3114, 5223, 4546, 6119
12255, 4123, 5122, 5095, 5536
12256, 4784, 5137, 4467, 5376
12257, 3912, 4727, 4164, 4896
12258, 3925, 4476, 5703, 5730
12259, 3937, 4933, 4373, 5302
12260, 3278, 3223, 4445, 5495
12261, 4281, 4424, 3974, 5155
12262, 3902, 4104, 4882, 4981
12263, 3522, 4976, 3575, 5637
12264, 4649, 4922, 3982, 6072
12265, 3930, 4901, 4377, 5184
12266, 485, 484, 4263, 5743
12267, 2114, 3206, 2695, 4522
12268, 2676, 4688, 2643, 4928
12269, 4282, 4785, 4269, 4866
12270, 4022, 4408, 4304, 6049
12271, 4011, 4285, 4648, 5549
12272, 2385, 5025, 5579, 6119
12273, 351, 3334, 350, 4942
12274, 382, 4794, 4458, 5894
12275, 4397, 4906, 4352, 5137
12276, 4432, 4740, 3919, 5244
12277, 4537, 5518, 3990, 5582
12278, 3288, 4195, 4944, 5869
12279, 3642, 4274, 3683, 5178
12280, 3994, 4517, 4278, 5258
12281, 3990, 4220, 5431, 5739
12282, 4263, 3918, 5217, 5471
12283, 2154, 2683, 2660, 5044
12284, 4033, 4781, 4139, 4793
12285, 2291, 4721, 3007, 5691
12286, 4322, 5576, 4699, 5710
12287, 4579, 4722, 4283, 5023
12288, 3721, 3741, 3888, 5321
12289, 3144, 4160, 2471, 5134
12290, 3377, 5014, 4422, 6116
12291, 593, 4379, 595, 5091
12292, 580, 4739, 4261, 5718
12293, 2472, 4950, 4160, 6237
12294, 4461, 3970, 5050, 5144
12295, 4923, 5091, 4379, 5295
12296, 4039, 4683, 5178, 5971
12297, 2539, 4249, 4938, 5950
12298, 3990, 4537, 4423, 5431
12299, 3988, 4593, 5889, 6164
12300, 2238, 5497, 4545, 6024
12301, 1413, 4139, 1315, 5204
12302, 3913, 4165, 4865, 4941
12303, 5096, 5311, 3903, 5762
12304, 761, 4323, 4715, 5733
12305, 2835, 4760, 4301, 5863
12306, 3017, 2339, 2342, 5817
12307, 3987, 4408, 4257, 5071
12308, 484, 486, 1221, 4749
12309, 2660, 3119, 3198, 4246
12310, 4179, 4824, 4168, 5783
12311, 2421, 3028, 4453, 5469
12312, 4495, 4948, 4389, 5056
12313, 4258, 5579, 3989, 5760
12314, 3061, 4203, 3058, 4996
12315, 4644, 4844, 4159, 5349
12316, 2734, 2559, 2752, 5060
12317, 2556, 4191, 2457, 5074
12318, 793, 5289, 4699, 6026
12319, 4416, 5774, 5052, 5938
12320, 4800, 4839, 2258, 5942
12321, 4511, 4808, 4265, 5387
12322, 374, 372, 5342, 5523
12323, 3198, 2144, 3099, 5326
12324, 3997, 4495, 4389, 6088
12325, 4194, 4570, 3973, 4920
12326, 1042, 718, 5462, 5809
12327, 427, 4549, 5439, 5969
12328, 4273, 3946, 5093, 6044
12329, 3969, 4723, 4402, 5799
12330, 740, 747, 4175, 5634
12331, 3906, 5292, 4523, 5575
12332, 847, 4697, 1140, 5589
12333, 4182, 4701, 4113, 4936
12334, 3090, 2334, 4416, 5188
12335, 2608, 3138, 5261, 5736
12336, 4306, 5658, 5504, 6219
12337, 4010, 5223, 4615, 5965
12338, 3978, 4925, 4340, 5394
12339, 4580, 4623, 2583, 5334
12340, 4761, 4998, 4061, 5676
12341, 4338, 5802, 4412, 6164
12342, 3609, 5310, 4928, 6209
12343, 4897, 4986, 3396, 5714
12344, 4194, 3973, 4570, 4872
12345, 4729, 5068, 4152, 5731
12346, 1075, 4752, 1076, 5597
12347, 904, 4467, 903, 5844
12348, 1040, 4210, 1105, 5997
12349, 761, 5203, 705, 5733
12350, 712, 683, 4542, 4770
12351, 3910, 4756, 4275, 6147
12352, 2825, 4655, 2821, 5980
12353, 4558, 5477, 5643, 5837
12354, 4233, 5417, 886, 5612
12355, 4117, 4588, 5527, 5906
12356, 3284, 3099, 5326, 5413
12357, 4432, 4740, 4447, 5209
12358, 4477, 4626, 3982, 5175
12359, 4009, 4529, 4315, 5007
12360, 770, 4474, 4776, 5027
12361, 306, 1319, 885, 5725
12362, 4418, 5181, 4747, 5757
12363, 1264, 4601, 1059, 4687
12364, 4294, 5589, 5216, 6018
12365, 2425, 4300, 2400, 5224
12366, 3958, 4696, 4589, 5463
12367, 3428, 4437, 3402, 5776
12368, 4659, 5152, 4167, 5513
12369, 4383, 5216, 5589, 6018
12370, 4329, 4028, 4765, 5953
12371, 3888, 3740, 3731, 5284
12372, 3720, 2135, 3821, 5136
12373, 2835, 4301, 4760, 5312
12374, 3549, 4473, 1383, 6004
12375, 4564, 5541, 3941, 6010
12376, 4175, 4564, 4082, 5101
12377, 4116, 4870, 5151, 5929
12378, 2150, 3118, 3605, 4928
12379, 3805, 3864, 5197, 6221
12380, 2872, 5261, 4521, 5558
12381, 3793, 3791, 4534, 5260
12382, 4261, 4739, 580, 5380
12383, 3422, 3313, 4449, 5714
12384, 4179, 4791, 4460, 5783
12385, 2230, 2237, 2229, 6001
12386, 2978, 2536, 2794, 4736
12387, 5387, 5731, 4152, 6113
12388, 3679, 5178, 4683, 5971
12389, 4045, 5511, 4114, 5786
12390, 4261, 3989, 4904, 4949
12391, 1339, 338, 4254, 5233
12392, 365, 4840, 4213, 5575
12393, 3390, 3404, 3393, 4405
12394, 3500, 3524, 3578, 4640
12395, 3767, 4675, 4492, 6082
12396, 3017, 4743, 4114, 5334
12397, 3932, 4860, 5298, 5876
12398, 3035, 4153, 2335, 5188
12399, 5246, 5302, 3937, 5462
12400, 3025, 4817, 4430, 5630
12401, 3699, 3856, 3826, 4435
12402, 4470, 1187, 4742, 6097
12403, 533, 4178, 1233, 5519
12404, 4104, 5293, 5529, 5829
12405, 672, 4229, 4873, 6037
12406, 4300, 3992, 5189, 5982
12407, 2935, 2168, 5106, 5959
12408, 4686, 4856, 756, 5750
12409, 1126, 4662, 855, 4868
12410, 4225, 4917, 4222, 5150
12411, 3146, 4637, 3186, 4646
12412, 4255, 5666, 4548, 5908
12413, 4020, 4628, 4163, 5216
12414, 697, 5049, 4230, 5371
12415, 4170, 2960, 5086, 5748
12416, 3303, 4448, 3237, 5021
12417, 4237, 3920, 5011, 6047
12418, 4131, 4726, 5128, 5600
12419, 3953, 4238, 4799, 5716
12420, 4260, 3911, 4698, 5850
12421, 2489, 2169, 2171, 4205
12422, 4139, 3936, 5204, 5596
12423, 4428, 5236, 4348, 5352
12424, 3930, 4659, 4167, 5513
12425, 3988, 5889, 4803, 6164
12426, 3936, 4140, 5267, 6228
12427, 450, 4155, 448, 5530
12428, 3937, 4961, 4373, 5690
12429, 4469, 4814, 4318, 5572
12430, 4011, 4262, 5172, 5549
12431, 4124, 4445, 3899, 5725
12432, 4707, 4796, 3497, 5598
12433, 4428, 5094, 4348, 5236
12434, 3431, 5141, 4488, 5213
12435, 4125, 5448, 5098, 6136
12436, 4000, 4448, 5021, 5452
12437, 3436, 4897, 3396, 5714
12438, 1185, 4427, 794, 5156
12439, 4668, 6028, 2533, 6154
12440, 3987, 4546, 5929, 5972
12441, 724, 726, 1304, 4487
12442, 4501, 4736, 4156, 5848
12443, 306, 885, 3281, 4445
12444, 4121, 4315, 4905, 5070
12445, 4548, 4255, 5596, 5666
12446, 4031, 4569, 4461, 5232
12447, 3913, 4265, 5017, 6113
12448, 494, 5167, 493, 5317
12449, 3917, 4699, 5118, 5576
12450, 840, 4332, 874, 4812
12451, 3461, 5082, 4828, 5562
12452, 5235, 5397, 4492, 5792
12453, 4228, 4617, 3992, 5189
12454, 3554, 5112, 3559, 5220
12455, 4557, 5313, 3997, 5458
12456, 3924, 5203, 4785, 5916
12457, 4097, 4838, 5239, 6063
12458, 2747, 4809, 4730, 5764
12459, 5039, 5110, 4276, 5994
12460, 4304, 4408, 4022, 4923
12461, 3274, 5294, 3282, 6038
12462, 1156, 568, 4184, 5645
12463, 4130, 5674, 5767, 5787
12464, 4160, 4021, 5219, 5280
12465, 2668, 4190, 4843, 5297
12466, 4467, 4482, 4002, 5844
12467, 1285, 445, 4622, 5305
12468, 4622, 5305, 445, 5342
12469, 2393, 3025, 3026, 4817
12470, 981, 980, 4661, 6104
12471, 4309, 5031, 4630, 6058
12472, 3900, 4242, 4657, 5438
12473, 4164, 4836, 5259, 6062
12474, 3932, 4805, 4333, 5611
12475, 3058, 4528, 4996, 5688
12476, 579, 578, 4261, 5195
12477, 3986, 5052, 4643, 5774
12478, 4040, 5042, 4218, 5631
12479, 5683, 5989, 4049, 6234
12480, 3721, 3057, 3741, 5321
12481, 2795, 2763, 2498, 4907
12482, 3985, 4395, 4385, 5557
12483, 4185, 5741, 627, 5750
12484, 4948, 5481, 4275, 6180
12485, 3984, 4574, 5482, 5610
12486, 2673, 2627, 2571, 4532
12487, 4166, 3947, 4951, 5088
12488, 3946, 4117, 4705, 5201
12489, 4522, 5336, 3206, 5694
12490, 3795, 3793, 3824, 4534
12491, 1214, 4291, 5117, 5845
12492, 2205, 4565, 2203, 5476
12493, 4981, 5087, 4581, 6049
12494, 4387, 5397, 5235, 5470
12495, 3987, 4257, 4408, 5586
12496, 3683, 4274, 3642, 5421
12497, 2228, 4802, 4363, 5587
12498, 3899, 4169, 4624, 4895
12499, 2192, 4653, 2191, 5389
12500, 454, 449, 455, 4346
12501, 4004, 4889, 4219, 4914
12502, 964, 811, 783, 4310
12503, 4613, 4896, 4164, 5259
12504, 2450, 2451, 4663, 4769
12505, 4037, 5263, 5077, 5437
12506, 2906, 4497, 2914, 5514
12507, 811, 783, 4310, 5058
12508, 590, 4447, 4735, 5024
12509, 2373, 4677, 2374, 5034
12510, 2935, 5106, 4618, 5959
12511, 4223, 4619, 3966, 4863
12512, 2330, 4746, 2206, 5476
12513, 4333, 4566, 3932, 5251
12514, 868, 4460, 5211, 5360
12515, 4443, 825, 4689, 5477
12516, 4189, 4810, 4509, 6075
12517, 3932, 4566, 4805, 5701
12518, 400, 1148, 4757, 5993
12519, 3940, 4359, 5174, 6136
12520, 2621, 4281, 4902, 5915
12521, 3227, 1211, 3273, 5495
12522, 502, 4550, 1125, 4662
12523, 3952, 5205, 4947, 6002
12524, 4421, 5283, 4052, 5518
12525, 3990, 5400, 4486, 5739
12526, 2815, 2814, 4358, 4919
12527, 364, 447, 365, 5575
12528, 1315, 4781, 1379, 4793
12529, 4200, 5133, 4503, 6230
12530, 4190, 2751, 4843, 5129
12531, 3328, 4648, 3380, 5368
12532, 675, 4780, 690, 5355
12533, 684, 1004, 4459, 4816
12534, 4006, 4481, 4878, 5391
12535, 4328, 4700, 702, 5311
12536, 4437, 4884, 4370, 6118
12537, 3954, 4972, 4202, 5808
12538, 1207, 920, 748, 4319
12539, 3927, 5128, 4726, 5600
12540, 4921, 5330, 4337, 5689
12541, 4860, 5298, 4380, 5574
12542, 4093, 5482, 4574, 5610
12543, 4431, 5384, 4212, 5543
12544, 548, 684, 1004, 4459
12545, 3976, 4917, 4388, 5592
12546, 3937, 4961, 5274, 6065
12547, 3903, 4624, 4185, 4879
12548, 2114, 3206, 4522, 5336
12549, 1093, 4399, 598, 5870
12550, 2484, 4237, 2951, 5382
12551, 2621, 5464, 4281, 5915
12552, 3965, 5538, 5716, 5738
12553, 3953, 4607, 4271, 5748
12554, 3198, 5326, 3099, 5413
12555, 347, 3333, 894, 5562
12556, 4460, 4791, 3981, 5783
12557, 3915, 4679, 4277, 5290
12558, 418, 4369, 4665, 5914
12559, 2441, 2871, 2494, 5558
12560, 4281, 5344, 4132, 5464
12561, 3924, 5145, 4647, 5733
12562, 1260, 5051, 4357, 6009
12563, 3939, 4738, 5006, 6172
12564, 2556, 2555, 4191, 5296
12565, 4312, 4000, 4854, 5021
12566, 3037, 2393, 4173, 5740
12567, 2395, 4304, 2397, 4988
12568, 4370, 4884, 6117, 6144
12569, 1125, 854, 855, 4239
12570, 3906, 4520, 5292, 5575
12571, 3940, 4757, 4544, 5303
12572, 4226, 2535, 5706, 5999
12573, 3978, 4340, 4717, 5394
12574, 4339, 5333, 4877, 5787
12575, 3394, 4986, 4378, 5054
12576, 2267, 4720, 2256, 4959
12577, 4300, 4708, 2400, 5224
12578, 3795, 4534, 3824, 4752
12579, 4265, 6036, 2940, 6113
12580, 2780, 4480, 4588, 5527
12581, 2895, 4140, 5224, 5227
12582, 325, 4529, 3324, 5131
12583, 4893, 4924, 4392, 5207
12584, 3975, 4317, 4824, 5399
12585, 4188, 5162, 4980, 5672
12586, 3252, 4944, 3294, 5531
12587, 3403, 3318, 2127, 4884
12588, 3927, 4456, 5274, 5600
12589, 440, 441, 448, 4764
12590, 507, 4176, 506, 6096
12591, 4118, 3938, 4832, 5180
12592, 4154, 4608, 3934, 6005
12593, 5030, 5350, 4355, 5918
12594, 548, 684, 4459, 4816
12595, 3536, 4219, 5248, 6045
12596, 572, 4268, 4958, 5645
12597, 1127, 5108, 799, 5816
12598, 967, 5196, 5061, 5625
12599, 667, 4471, 4392, 4924
12600, 3919, 4319, 4740, 5796
12601, 4292, 4664, 3952, 6008
12602, 4126, 5489, 4584, 5809
12603, 883, 1115, 5072, 6070
12604, 491, 490, 4836, 6062
12605, 1029, 4571, 1025, 5573
12606, 3237, 3286, 5021, 5452
12607, 2433, 4450, 2436, 5487
12608, 4185, 4624, 4169, 4895
12609, 2340, 2346, 4271, 5817
12610, 2994, 5191, 4353, 5527
12611, 4383, 5589, 4294, 6018
12612, 3992, 4762, 4701, 5430
12613, 3902, 4299, 4882, 5005
12614, 3985, 5557, 4478, 5624
12615, 4368, 3905, 4646, 5428
12616, 4006, 5121, 4233, 5417
12617, 1022, 4333, 1020, 5789
12618, 721, 4614, 719, 4849
12619, 335, 1390, 1091, 4880
12620, 3747, 5062, 3749, 5400
12621, 4198, 4045, 5035, 5511
12622, 2593, 4754, 5382, 6056
12623, 4191, 5074, 2556, 5296
12624, 4196, 3916, 5165, 5202
12625, 3845, 4349, 3276, 5452
12626, 3906, 4563, 4205, 4937
12627, 2512, 3020, 4926, 5705
12628, 696, 1065, 631, 4218
12629, 2335, 4153, 3035, 5858
12630, 3839, 4395, 3693, 5286
12631, 4270, 3913, 5017, 6096
12632, 4174, 5144, 645, 5545
12633, 2423, 4161, 5618, 5627
12634, 3958, 5463, 4589, 5786
12635, 4351, 4433, 4014, 5332
12636, 3592, 3620, 3658, 6091
12637, 4084, 5033, 4250, 5909
12638, 4336, 4319, 5546, 5796
12639, 700, 627, 4856, 4879
12640, 4903, 5320, 4241, 6032
12641, 603, 1251, 941, 4791
12642, 2341, 4561, 2346, 5817
12643, 4165, 5441, 2289, 5991
12644, 3353, 4201, 3352, 5524
12645, 902, 4784, 903, 5989
12646, 3965, 5032, 4430, 5538
12647, 4099, 4888, 4381, 5974
12648, 4240, 4033, 4793, 5459
12649, 1408, 4334, 5049, 6190
12650, 1252, 5276, 801, 5633
12651, 3992, 4701, 4182, 4936
12652, 2397, 4988, 4304, 5087
12653, 3976, 4532, 4985, 5234
12654, 4738, 6071, 5006, 6172
12655, 3146, 2440, 3186, 4637
12656, 4377, 5127, 4058, 5559
12657, 515, 4691, 513, 5917
12658, 1114, 4578, 5594, 5874
12659, 5065, 5218, 4729, 5655
12660, 388, 4773, 4212, 5584
12661, 3992, 4701, 4291, 5430
12662, 4518, 4481, 5893, 6090
12663, 4139, 4793, 1315, 5204
12664, 3642, 4274, 4751, 5421
12665, 2653, 4815, 2655, 5943
12666, 3999, 5295, 4923, 6223
12667, 3909, 5219, 4538, 5318
12668, 4674, 4820, 4062, 5420
12669, 2985, 2557, 2689, 4518
12670, 4381, 5085, 2808, 5960
12671, 4238, 5716, 5538, 5738
12672, 4245, 4705, 4676, 6128
12673, 3928, 4967, 4214, 5123
12674, 2680, 4299, 4664, 5074
12675, 4385, 4395, 3985, 4858
12676, 4527, 4666, 4264, 5535
12677, 4948, 5345, 4275, 5481
12678, 1387, 937, 4475, 5340
12679, 485, 4263, 484, 5217
12680, 4658, 5165, 3916, 5202
12681, 3932, 4519, 4347, 5251
12682, 830, 4858, 5286, 5852
12683, 4168, 4792, 4179, 5783
12684, 4746, 5341, 4181, 6112
12685, 4783, 5200, 4227, 6156
12686, 427, 5439, 4549, 5985
12687, 990, 5196, 4286, 5539
12688, 3927, 5065, 4729, 5655
12689, 4147, 5700, 5003, 6033
12690, 4004, 4219, 4889, 5907
12691, 2509, 5705, 4926, 5799
12692, 840, 4332, 4812, 6027
12693, 4689, 4443, 5477, 5643
12694, 2279, 2276, 4823, 6089
12695, 504, 4922, 939, 5212
12696, 4071, 4649, 4917, 5205
12697, 4223, 3966, 4825, 4863
12698, 2790, 4580, 2583, 5334
12699, 4080, 4143, 5140, 5403
12700, 4190, 3975, 5129, 5753
12701, 2228, 4363, 4802, 5857
12702, 3447, 5131, 4437, 5776
12703, 2835, 2837, 4301, 5312
12704, 2593, 4754, 4237, 5382
12705, 3957, 4693, 4401, 5086
12706, 2751, 4190, 3048, 5221
12707, 3926, 4892, 5168, 5473
12708, 3980, 4878, 4207, 4946
12709, 4290, 4932, 4223, 4963
12710, 357, 4366, 626, 6197
12711, 1114, 5594, 1117, 5874
12712, 5688, 5720, 4528, 6138
12713, 3642, 3683, 3643, 5178
12714, 932, 4694, 4287, 5750
12715, 4211, 4851, 3922, 5696
12716, 3582, 3508, 3507, 5111
12717, 1156, 568, 566, 5181
12718, 4694, 4967, 4337, 5741
12719, 2544, 4275, 2543, 6147
12720, 902, 901, 903, 5759
12721, 4422, 5654, 3377, 5843
12722, 4526, 4888, 4381, 5085
12723, 2539, 4938, 4249, 5978
12724, 4863, 5064, 4463, 6162
12725, 3679, 4683, 3647, 5971
12726, 2593, 5382, 2909, 6056
12727, 3982, 4917, 4649, 5205
12728, 3579, 3504, 5077, 5666
12729, 2780, 3167, 4480, 5527
12730, 4091, 5462, 4425, 5525
12731, 3996, 4346, 4592, 5008
12732, 3952, 4622, 4947, 5205
12733, 4636, 4885, 3556, 5722
12734, 2960, 2923, 4170, 5742
12735, 4928, 5310, 4224, 6209
12736, 3037, 5740, 4173, 5853
12737, 2976, 4959, 4559, 5822
12738, 4377, 4901, 4058, 5127
12739, 4626, 5335, 4057, 5427
12740, 801, 4188, 734, 6021
12741, 1036, 4692, 4726, 5570
12742, 4159, 5327, 4367, 5805
12743, 4058, 5152, 4659, 5182
12744, 2607, 2678, 4531, 4717
12745, 2802, 3078, 2803, 5599
12746, 2843, 2228, 4363, 5587
12747, 4076, 4645, 5190, 5866
12748, 3315, 4488, 3431, 5141
12749, 4279, 4774, 4064, 4847
12750, 2892, 4478, 4817, 5474
12751, 4154, 3934, 5700, 6005
12752, 544, 4238, 546, 5130
12753, 3083, 5107, 4543, 5944
12754, 1373, 5304, 4309, 5919
12755, 4400, 3914, 5245, 5810
12756, 4808, 5369, 4658, 6026
12757, 4699, 5289, 4270, 6026
12758, 2472, 4160, 3144, 6237
12759, 4313, 5237, 859, 5588
12760, 3389, 5176, 4397, 5947
12761, 4638, 5278, 4092, 5552
12762, 2751, 5129, 4190, 5221
12763, 3789, 4880, 5260, 5370
12764, 4113, 4936, 3908, 6189
12765, 3986, 5611, 5422, 6006
12766, 4013, 4513, 4254, 5591
12767, 4329, 4184, 4765, 4957
12768, 1127, 5537, 5108, 5816
12769, 2172, 2306, 5175, 5800
12770, 938, 5268, 727, 5961
12771, 4449, 4911, 5683, 5714
12772, 3944, 4155, 5000, 5530
12773, 4495, 5012, 3910, 5379
12774, 4838, 5040, 4298, 5886
12775, 3396, 4986, 3394, 5054
12776, 3902, 4299, 5005, 5627
12777, 1270, 4171, 397, 5103
12778, 4003, 4157, 4671, 5603
12779, 4147, 5700, 3934, 6005
12780, 4508, 5598, 3494, 6159
12781, 3963, 4669, 5561, 5801
12782, 2114, 2695, 3318, 4522
12783, 3809, 5331, 3811, 5888
12784, 4186, 4509, 3901, 6075
12785, 4090, 4611, 4521, 5261
12786, 4002, 4352, 4906, 5137
12787, 4412, 5225, 2789, 5512
12788, 4484, 5102, 554, 5440
12789, 4832, 4938, 4249, 5950
12790, 4659, 5182, 3930, 5439
12791, 2343, 4559, 2976, 4959
12792, 806, 4728, 4542, 5459
12793, 2432, 3030, 2504, 5036
12794, 4007, 5118, 6030, 6118
12795, 4302, 4501, 3934, 5084
12796, 4207, 4800, 3980, 4946
12797, 3915, 4763, 4761, 5963
12798, 4080, 4143, 4795, 5113
12799, 4497, 5115, 4048, 5719
12800, 4133, 5492, 5276, 6238
12801, 4066, 5334, 4743, 5630
12802, 3926, 4892, 5481, 5500
12803, 4048, 5115, 4514, 5719
12804, 4406, 4908, 4559, 5822
12805, 3967, 5073, 4183, 5681
12806, 3748, 3749, 5062, 5400
12807, 1288, 1029, 1025, 5573
12808, 3973, 4101, 4916, 5108
12809, 1235, 4620, 591, 4898
12810, 4698, 5840, 4260, 5850
12811, 4375, 4580, 4114, 5455
12812, 4827, 5442, 4027, 5485
12813, 3951, 5269, 4371, 5604
12814, 4028, 4125, 4919, 6115
12815, 3924, 4269, 4785, 4866
12816, 499, 4277, 4679, 5317
12817, 591, 4898, 4620, 5865
12818, 3390, 3404, 4405, 4911
12819, 2280, 4823, 2278, 5660
12820, 3400, 4378, 2707, 5651
12821, 588, 5120, 529, 6126
12822, 3959, 4747, 4329, 5050
12823, 967, 5061, 5451, 5625
12824, 3957, 4119, 4844, 5192
12825, 3733, 5045, 3706, 5656
12826, 3993, 4835, 4345, 5979
12827, 4333, 4894, 4706, 5789
12828, 3073, 5240, 2849, 5497
12829, 4702, 4957, 4184, 5645
12830, 4679, 4975, 4277, 5371
12831, 4069, 4486, 5400, 5739
12832, 4778, 5158, 4364, 5861
12833, 3089, 3091, 5296, 5316
12834, 3987, 4257, 4439, 5071
12835, 4916, 5793, 4588, 5920
12836, 3942, 4357, 4992, 5210
12837, 2260, 2537, 4682, 4813
12838, 4430, 5032, 5022, 5538
12839, 4289, 4711, 3918, 5691
12840, 1231, 4284, 1038, 6062
12841, 4452, 5305, 4622, 5342
12842, 4431, 3979, 5384, 5543
12843, 2908, 2259, 5382, 5517
12844, 4686, 4856, 3899, 5725
12845, 780, 1339, 4859, 5564
12846, 3990, 4769, 4537, 5431
12847, 2291, 3007, 3014, 5691
12848, 3961, 5029, 4517, 6187
12849, 407, 5210, 1260, 5752
12850, 4153, 4667, 4416, 5188
12851, 2583, 4623, 4580, 5377
12852, 2819, 2330, 5298, 5483
12853, 3848, 2148, 3721, 4448
12854, 4384, 4641, 3371, 5266
12855, 558, 4898, 4787, 5735
12856, 3913, 4613, 4270, 5042
12857, 711, 4485, 683, 4770
12858, 3120, 4368, 4704, 5763
12859, 728, 519, 4553, 4698
12860, 2929, 4666, 2414, 6128
12861, 3534, 3533, 3535, 5248
12862, 3118, 3673, 3605, 4928
12863, 4203, 4677, 2431, 5688
12864, 4263, 5081, 4727, 5743
12865, 4099, 4381, 4903, 5974
12866, 4002, 4397, 4906, 5176
12867, 4229, 5355, 5012, 5419
12868, 3906, 4523, 4162, 4763
12869, 4056, 4952, 4435, 5079
12870, 4244, 5872, 4825, 6191
12871, 1114, 4578, 1128, 5594
12872, 1185, 4427, 4758, 6126
12873, 4473, 5458, 1383, 6004
12874, 562, 561, 560, 4829
12875, 4031, 4461, 4569, 5098
12876, 1064, 1050, 1060, 5425
12877, 4894, 5573, 4333, 5938
12878, 4428, 4858, 4395, 5286
12879, 4308, 4766, 3901, 6075
12880, 4581, 4061, 4998, 5676
12881, 4224, 4928, 2676, 5310
12882, 3944, 4959, 5126, 5622
12883, 4040, 4642, 5042, 5631
12884, 2189, 4498, 5351, 5389
12885, 4059, 4395, 4320, 5447
12886, 4192, 4276, 5110, 5994
12887, 3973, 4245, 4666, 5028
12888, 2228, 2843, 4363, 5857
12889, 2205, 3064, 2236, 4342
12890, 4017, 4238, 5538, 6014
12891, 4199, 4590, 3936, 5596
12892, 4311, 5481, 4892, 5500
12893, 4056, 4952, 5079, 5715
12894, 740, 4175, 747, 5673
12895, 4512, 4597, 2753, 5928
12896, 4208, 5030, 4631, 5918
12897, 4223, 5004, 4969, 5901
12898, 4174, 4829, 4792, 5545
12899, 4416, 4667, 4153, 5076
12900, 4776, 5027, 3902, 5791
12901, 4417, 4722, 4236, 5208
12902, 3987, 4439, 4257, 6221
12903, 3920, 4542, 4485, 4770
12904, 4151, 5006, 3930, 5439
12905, 4187, 5063, 5507, 6229
12906, 3683, 5178, 4274, 5623
12907, 1020, 1024, 1182, 5493
12908, 922, 1365, 800, 4274
12909, 4631, 5030, 4208, 5099
12910, 3930, 5278, 4267, 6109
12911, 903, 4467, 1349, 6229
12912, 4093, 5488, 5161, 5610
12913, 2740, 2504, 3030, 4340
12914, 3980, 4458, 4295, 4794
12915, 561, 604, 559, 4680
12916, 1363, 4539, 344, 4796
12917, 2447, 4358, 2814, 4888
12918, 4758, 5010, 4442, 5120
12919, 3492, 3498, 3572, 4796
12920, 4616, 4626, 4057, 5427
12921, 3964, 4119, 4912, 5192
12922, 4014, 4433, 4351, 5260
12923, 4348, 4435, 4016, 5236
12924, 5270, 5740, 2350, 5898
12925, 3025, 3026, 4817, 5630
12926, 4929, 5526, 4039, 5971
12927, 4544, 5303, 4877, 5767
12928, 4804, 4996, 2745, 5668
12929, 3955, 4268, 4745, 4847
12930, 4278, 4517, 3994, 5252
12931, 551, 522, 496, 4610
12932, 2120, 4831, 3170, 5375
12933, 622, 4231, 623, 5870
12934, 4947, 5205, 4071, 6002
12935, 3923, 5019, 5239, 6063
12936, 1312, 4296, 4924, 5461
12937, 3980, 4466, 5884, 5909
12938, 2256, 2257, 2251, 4720
12939, 4263, 5140, 4979, 6125
12940, 2505, 2450, 2988, 5431
12941, 4062, 4475, 4857, 6101
12942, 4416, 5076, 4153, 5188
12943, 4299, 4947, 4305, 5005
12944, 408, 407, 4180, 5210
12945, 631, 4218, 1065, 5120
12946, 2923, 2960, 4170, 5748
12947, 3194, 3209, 3016, 4228
12948, 4215, 4670, 1275, 5359
12949, 4297, 4972, 4842, 6023
12950, 558, 556, 4787, 4898
12951, 4159, 3957, 4778, 4844
12952, 3991, 4353, 5187, 5241
12953, 4271, 4561, 3965, 4743
12954, 4380, 5298, 2330, 5483
12955, 4501, 5162, 5084, 5885
12956, 4186, 3901, 4509, 5788
12957, 4259, 5488, 5282, 5533
12958, 2643, 4928, 4688, 5361
12959, 3312, 4394, 3344, 5392
12960, 2554, 2583, 4580, 5377
12961, 990, 4779, 4286, 5625
12962, 4231, 4300, 5241, 6053
12963, 3917, 4808, 4265, 4970
12964, 4149, 5782, 4770, 6068
12965, 670, 4398, 637, 5156
12966, 4129, 4639, 5250, 5649
12967, 4013, 4492, 5041, 5235
12968, 4370, 4604, 4007, 4960
12969, 3413, 295, 4454, 4897
12970, 3424, 3304, 322, 4491
12971, 5047, 5663, 4496, 5729
12972, 3351, 4828, 3461, 5082
12973, 4135, 3933, 4849, 5037
12974, 4418, 5181, 4744, 6138
12975, 4292, 4850, 4057, 5335
12976, 4089, 4511, 5202, 5465
12977, 4194, 4872, 4264, 5243
12978, 3901, 4262, 4509, 4788
12979, 2431, 4203, 3061, 5811
12980, 4182, 3992, 4936, 5411
12981, 4637, 4646, 3905, 5428
12982, 412, 5386, 5693, 6073
12983, 4280, 5218, 3033, 5731
12984, 4232, 4971, 4100, 5168
12985, 4061, 4286, 5657, 5676
12986, 1048, 4957, 4329, 6218
12987, 3120, 4646, 4368, 5763
12988, 3111, 4831, 4531, 5375
12989, 4066, 5235, 5397, 5470
12990, 4082, 4175, 5101, 6162
12991, 2680, 4664, 3089, 5074
12992, 3953, 4159, 4778, 4965
12993, 4444, 5338, 4231, 5870
12994, 2268, 4862, 2257, 5822
12995, 4215, 5164, 4064, 6084
12996, 3127, 4576, 2727, 4999
12997, 3136, 4804, 2745, 5668
12998, 3905, 4637, 4303, 4646
12999, 4267, 5278, 5006, 6109
13000, 4630, 5337, 4309, 5919
13001, 3961, 4517, 5029, 5322
13002, 4221, 6030, 5118, 6118
13003, 4289, 5140, 4711, 6125
13004, 4387, 2615, 4817, 5474
13005, 3918, 4289, 4979, 5140
13006, 4280, 5068, 4729, 5731
13007, 2695, 2127, 3318, 4522
13008, 3958, 4945, 4589, 4965
13009, 3932, 4111, 4805, 5611
13010, 3357, 4905, 4415, 5336
13011, 1185, 4758, 4427, 5156
13012, 304, 5365, 4436, 5797
13013, 3945, 4724, 4414, 5163
13014, 3261, 3259, 4246, 4848
13015, 2729, 3699, 4435, 5620
13016, 3923, 4608, 4298, 5040
13017, 1152, 643, 615, 4740
13018, 4246, 4848, 3259, 5147
13019, 4256, 5431, 4220, 5739
13020, 5118, 5465, 4226, 5652
13021, 896, 1327, 1409, 5637
13022, 4181, 4777, 3942, 4833
13023, 4450, 4826, 2436, 5487
13024, 2555, 4988, 4191, 5296
13025, 5130, 5538, 4596, 5738
13026, 801, 5633, 4188, 6021
13027, 4062, 4674, 4314, 4857
13028, 600, 499, 1146, 5371
13029, 4053, 4933, 4451, 5302
13030, 4621, 5612, 4150, 5894
13031, 4493, 4780, 4144, 5849
13032, 4032, 4187, 4632, 5806
13033, 4023, 4948, 4389, 5220
13034, 3955, 4774, 5095, 5944
13035, 2874, 4821, 4489, 4934
13036, 1252, 1245, 745, 5504
13037, 3284, 3301, 3235, 5413
13038, 4033, 4139, 4781, 5111
13039, 734, 4188, 801, 5276
13040, 4872, 5170, 4072, 6219
13041, 4428, 5352, 4317, 5360
13042, 2194, 2195, 2193, 4932
13043, 1006, 5051, 4241, 5502
13044, 1290, 4233, 886, 5612
13045, 4194, 4083, 5243, 5952
13046, 4080, 4143, 5113, 5140
13047, 3901, 5788, 4186, 6184
13048, 4438, 4795, 4682, 5721
13049, 4606, 3532, 5248, 5308
13050, 4056, 5079, 4435, 5715
13051, 4043, 4336, 5546, 5796
13052, 3902, 4162, 4761, 5005
13053, 4102, 5815, 5115, 5924
13054, 4204, 4673, 3931, 5067
13055, 4371, 4938, 5737, 5978
13056, 4297, 1098, 6023, 6035
13057, 408, 4180, 407, 5752
13058, 478, 523, 4259, 5533
13059, 2325, 2326, 5482, 5660
13060, 4293, 3956, 4556, 4874
13061, 2670, 5221, 3048, 5297
13062, 2875, 4788, 4262, 5549
13063, 3924, 4282, 4785, 5203
13064, 1038, 4284, 1231, 5892
13065, 3017, 5334, 4114, 5795
13066, 3261, 3259, 3301, 4246
13067, 2954, 2550, 3009, 4753
13068, 4560, 4006, 5030, 6140
13069, 4979, 5140, 4289, 6125
13070, 2751, 2668, 3048, 4190
13071, 2179, 2177, 4850, 5316
13072, 389, 4773, 4431, 5359
13073, 1125, 854, 4239, 5398
13074, 4222, 4985, 4689, 5837
13075, 3971, 4620, 5032, 5325
13076, 2108, 5294, 3274, 6038
13077, 3198, 4246, 3119, 5326
13078, 3402, 4604, 4437, 4884
13079, 4674, 4820, 4050, 5713
13080, 1407, 4291, 1214, 5338
13081, 4833, 5489, 4126, 5574
13082, 4609, 4973, 4075, 5389
13083, 4240, 4943, 4033, 5459
13084, 4223, 4932, 4290, 5004
13085, 2236, 4342, 3064, 5085
13086, 4376, 5672, 4476, 5700
13087, 2278, 2280, 2279, 4823
13088, 3984, 5482, 4266, 5610
13089, 1015, 1269, 1014, 4461
13090, 3312, 4394, 934, 4956
13091, 2364, 5756, 5142, 5846
13092, 3926, 4892, 4311, 5481
13093, 857, 5337, 4137, 5563
13094, 5251, 4095, 5611, 5938
13095, 4002, 5137, 4467, 5844
13096, 3189, 4417, 3224, 5326
13097, 4894, 5573, 1229, 5789
13098, 3946, 5162, 4133, 5276
13099, 2916, 2919, 2930, 5252
13100, 3528, 4885, 3532, 5308
13101, 4101, 5002, 799, 5816
13102, 4861, 4920, 880, 5899
13103, 3931, 4167, 5206, 5281
13104, 4044, 5009, 4470, 5488
13105, 4461, 4569, 3970, 4855
13106, 5033, 5390, 4598, 5926
13107, 4083, 4920, 4194, 5243
13108, 4060, 5161, 4575, 5460
13109, 773, 4889, 713, 5782
13110, 3522, 4976, 4209, 5402
13111, 3030, 4340, 2504, 5036
13112, 2856, 2855, 2854, 4991
13113, 3999, 4893, 4446, 4924
13114, 1026, 4571, 5333, 5493
13115, 4495, 2491, 6088, 6235
13116, 792, 879, 4927, 5722
13117, 4130, 5767, 4544, 5787
13118, 3033, 2415, 2840, 5991
13119, 3211, 4193, 2698, 5125
13120, 4191, 4988, 4304, 5581
13121, 4033, 4521, 4199, 5111
13122, 4716, 5002, 4585, 6193
13123, 2550, 4463, 4753, 5509
13124, 617, 4766, 1180, 5244
13125, 4186, 5396, 5372, 6184
13126, 2670, 4504, 5221, 5297
13127, 463, 4851, 1107, 6050
13128, 4175, 3966, 5101, 6162
13129, 2937, 3207, 2122, 5665
13130, 4030, 4971, 4232, 5168
13131, 4250, 4621, 1284, 6104
13132, 4485, 4542, 3920, 4943
13133, 3943, 4518, 4208, 5350
13134, 4066, 4743, 4430, 5630
13135, 2760, 2545, 2759, 4586
13136, 4196, 5165, 4658, 5202
13137, 4228, 3992, 4762, 5189
13138, 685, 4585, 5276, 5816
13139, 3001, 4645, 4563, 4989
13140, 4924, 5207, 4893, 6167
13141, 4170, 4778, 3957, 4844
13142, 3353, 4201, 5524, 5770
13143, 3980, 4295, 4458, 4750
13144, 4181, 4525, 3972, 4703
13145, 4075, 5543, 5351, 6034
13146, 399, 4171, 1270, 5232
13147, 4317, 4824, 4460, 5878
13148, 2840, 3033, 5218, 5731
13149, 1114, 1117, 5185, 5874
13150, 3933, 4925, 4135, 5301
13151, 3077, 3075, 4290, 5004
13152, 3983, 5186, 4413, 5941
13153, 4572, 4724, 4210, 5997
13154, 4682, 4813, 4438, 5721
13155, 4266, 5482, 4093, 5610
13156, 4414, 4685, 3922, 5828
13157, 3994, 5029, 4517, 5258
13158, 3961, 4481, 4850, 5316
13159, 3031, 4347, 2823, 5052
13160, 3927, 4729, 4280, 5068
13161, 949, 831, 4317, 5360
13162, 890, 1343, 891, 4206
13163, 4018, 4679, 4523, 4763
13164, 2786, 5362, 4234, 5944
13165, 4527, 4683, 4365, 5243
13166, 4101, 4916, 4390, 5002
13167, 4036, 5245, 4467, 5396
13168, 3917, 4265, 4808, 5042
13169, 4257, 4731, 4061, 5657
13170, 3923, 5019, 4240, 5239
13171, 3141, 4148, 5377, 5583
13172, 4329, 5050, 4747, 5144
13173, 2747, 2746, 4730, 4809
13174, 2314, 4272, 2315, 5075
13175, 2747, 4730, 5695, 5764
13176, 3020, 3009, 4361, 5705
13177, 1065, 5120, 4218, 5289
13178, 3989, 5579, 4733, 5760
13179, 770, 1348, 4474, 5027
13180, 692, 639, 624, 4240
13181, 3678, 3618, 3660, 4968
13182, 3938, 4118, 4867, 5180
13183, 617, 4432, 4766, 5244
13184, 3944, 4343, 5504, 5530
13185, 4338, 4027, 5442, 5485
13186, 3935, 4627, 4280, 5065
13187, 3128, 5074, 4581, 5627
13188, 4001, 4999, 4365, 5243
13189, 4636, 5248, 4885, 5907
13190, 4261, 3989, 4949, 5760
13191, 760, 4920, 4390, 5108
13192, 2192, 2191, 2190, 5389
13193, 3949, 4536, 5378, 5918
13194, 412, 5386, 1153, 5693
13195, 3877, 5408, 4281, 5888
13196, 4665, 5466, 3972, 5532
13197, 4287, 4568, 950, 5772
13198, 799, 5002, 4101, 5108
13199, 4563, 4645, 3001, 6206
13200, 3960, 5216, 4383, 5273
13201, 2296, 4955, 4645, 5618
13202, 4013, 5041, 4254, 5235
13203, 4482, 4651, 691, 5358
13204, 4111, 3932, 4805, 4933
13205, 4887, 4962, 4047, 5550
13206, 866, 949, 1246, 5399
13207, 1139, 847, 1140, 5589
13208, 4176, 4726, 3927, 5128
13209, 3326, 3441, 3414, 4436
13210, 4037, 5077, 4548, 5596
13211, 3923, 4533, 5967, 6005
13212, 770, 4776, 1326, 5027
13213, 4191, 3902, 4581, 5074
13214, 322, 4491, 1313, 4997
13215, 3975, 4190, 4824, 5753
13216, 2364, 2362, 5756, 5846
13217, 4215, 3979, 4963, 5359
13218, 1392, 4291, 323, 5117
13219, 3953, 5119, 4238, 5716
13220, 2494, 5558, 4837, 5886
13221, 3936, 4140, 5055, 5267
13222, 3025, 4430, 2393, 5740
13223, 3089, 4664, 3091, 5316
13224, 3560, 3662, 3595, 4539
13225, 3897, 3845, 3727, 4349
13226, 3995, 4223, 4963, 5004
13227, 896, 5556, 1327, 5637
13228, 4099, 4903, 4381, 6185
13229, 4291, 5338, 3992, 6053
13230, 4812, 5939, 4383, 6230
13231, 3933, 4845, 4277, 5290
13232, 4010, 4403, 4351, 6153
13233, 4188, 5454, 4980, 6021
13234, 3995, 4545, 4359, 5004
13235, 3101, 3592, 3658, 6091
13236, 3996, 5039, 4276, 5833
13237, 3910, 4540, 4275, 4756
13238, 4464, 4845, 4814, 6232
13239, 4666, 5028, 4245, 6128
13240, 4007, 4370, 5118, 6118
13241, 2150, 4928, 3605, 5310
13242, 5061, 5196, 4088, 5625
13243, 5082, 5125, 3350, 5357
13244, 4287, 5409, 5772, 5890
13245, 3937, 4599, 4157, 4930
13246, 4584, 5489, 4373, 5809
13247, 670, 669, 637, 4398
13248, 3925, 5003, 4695, 5700
13249, 3522, 4209, 4976, 5637
13250, 4308, 3901, 4810, 6075
13251, 2684, 4579, 4417, 5326
13252, 4503, 5133, 4163, 6230
13253, 4125, 4028, 4919, 6024
13254, 4903, 5974, 4381, 6032
13255, 4428, 4858, 4317, 5352
13256, 4363, 4877, 4042, 5303
13257, 4144, 5471, 1212, 5849
13258, 2532, 4668, 2533, 5999
13259, 4218, 3917, 4883, 5405
13260, 4023, 4909, 4586, 5345
13261, 3764, 4915, 3769, 5447
13262, 4121, 5070, 4538, 5449
13263, 2929, 2482, 2414, 4666
13264, 3634, 3633, 3598, 4291
13265, 2740, 4340, 3030, 5036
13266, 1064, 4288, 1060, 5520
13267, 2325, 2280, 2326, 5660
13268, 747, 4759, 1296, 5285
13269, 303, 4534, 3705, 4880
13270, 4099, 4888, 4358, 5142
13271, 2489, 4989, 4205, 5230
13272, 2673, 4532, 2571, 5485
13273, 4189, 4974, 4361, 5590
13274, 4590, 4684, 4037, 5596
13275, 4108, 4909, 5112, 5345
13276, 3789, 4410, 3697, 4880
13277, 3933, 4277, 5037, 5290
13278, 1081, 4767, 4396, 6003
13279, 4821, 5788, 4186, 6207
13280, 4232, 5168, 4100, 5473
13281, 857, 1137, 5031, 5337
13282, 3430, 3374, 3377, 5014
13283, 1009, 644, 1006, 4787
13284, 3394, 4378, 3400, 5651
13285, 3917, 4591, 4265, 5042
13286, 4768, 4987, 4146, 6236
13287, 624, 4240, 639, 5146
13288, 446, 4714, 5584, 6196
13289, 4477, 5335, 2174, 6022
13290, 4094, 5043, 5582, 5827
13291, 3982, 4917, 5205, 6002
13292, 417, 4599, 423, 5462
13293, 3978, 4717, 4925, 5394
13294, 2320, 2338, 4589, 4696
13295, 689, 690, 4557, 5355
13296, 3901, 4186, 5372, 6184
13297, 2798, 5362, 2786, 5944
13298, 4049, 4378, 5414, 6152
13299, 4497, 5815, 5514, 5924
13300, 4324, 5283, 4421, 5518
13301, 630, 4328, 702, 5311
13302, 3929, 4140, 4605, 5055
13303, 2457, 2455, 2397, 4988
13304, 4840, 4967, 4213, 5891
13305, 2184, 2186, 4800, 4973
13306, 4634, 4905, 4315, 5070
13307, 742, 4141, 5500, 5503
13308, 2946, 4505, 2278, 4823
13309, 552, 4610, 4484, 5440
13310, 4134, 4813, 5517, 5744
13311, 2949, 2537, 2255, 5867
13312, 2935, 2934, 2168, 5959
13313, 4249, 5950, 2539, 5978
13314, 2745, 4996, 2744, 5668
13315, 2892, 4817, 2615, 5474
13316, 5342, 5523, 372, 6072
13317, 3251, 3294, 4944, 5495
13318, 2120, 3170, 3111, 5375
13319, 967, 989, 5061, 5196
13320, 3940, 4802, 4359, 5499
13321, 4003, 4671, 4157, 5607
13322, 3263, 5194, 4475, 6101
13323, 4453, 5075, 3916, 5179
13324, 3103, 3562, 4508, 5639
13325, 2663, 4312, 2143, 5375
13326, 4333, 5573, 4894, 5789
13327, 4164, 3913, 4836, 4941
13328, 3923, 5967, 4524, 6005
13329, 3977, 4926, 4750, 4973
13330, 4135, 4530, 5311, 5762
13331, 4689, 5150, 4222, 5836
13332, 4016, 5297, 4348, 5352
13333, 3661, 3724, 3846, 5310
13334, 1056, 1059, 1264, 4601
13335, 4207, 5029, 4946, 6187
13336, 4270, 5017, 4808, 5369
13337, 4300, 4841, 4231, 5241
13338, 2324, 5040, 5227, 5548
13339, 2932, 2278, 2946, 4505
13340, 4715, 4206, 5438, 6132
13341, 3318, 4522, 2127, 4884
13342, 4644, 4742, 4470, 5009
13343, 4391, 4000, 5046, 5321
13344, 3932, 4933, 4111, 5611
13345, 4181, 4832, 4594, 5877
13346, 446, 5584, 4212, 6196
13347, 3987, 4546, 5071, 5929
13348, 402, 1092, 1148, 4248
13349, 622, 5102, 4231, 5870
13350, 3549, 3473, 1383, 4473
13351, 4139, 4793, 4781, 6151
13352, 4223, 4825, 4244, 4963
13353, 4483, 5915, 4902, 6232
13354, 3899, 4624, 4185, 4895
13355, 2296, 4330, 4955, 5618
13356, 4114, 3965, 4743, 4945
13357, 3828, 3860, 4433, 4962
13358, 5032, 5325, 4620, 6046
13359, 1175, 4176, 5450, 5892
13360, 3634, 3633, 4291, 5430
13361, 3915, 4845, 4230, 4987
13362, 1293, 1296, 4339, 5285
13363, 2679, 2113, 4827, 5958
13364, 4342, 4746, 2205, 5341
13365, 3992, 4595, 4113, 4936
13366, 697, 5371, 4230, 6236
13367, 3924, 4323, 5145, 5733
13368, 2724, 4480, 2620, 5199
13369, 1117, 5594, 5185, 5874
13370, 1059, 4601, 1056, 4687
13371, 4010, 4403, 5223, 5965
13372, 2267, 4959, 2976, 5822
13373, 4393, 5329, 5756, 6185
13374, 4201, 5134, 4415, 6029
13375, 2909, 5382, 4516, 6056
13376, 2169, 2171, 4205, 5800
13377, 3951, 5180, 4601, 5324
13378, 4312, 4531, 3978, 4830
13379, 4371, 5269, 4128, 5604
13380, 4613, 5120, 587, 5289
13381, 4175, 5285, 747, 5673
13382, 2441, 5363, 2871, 5558
13383, 4310, 4513, 4013, 5058
13384, 2209, 5341, 4746, 6112
13385, 417, 4425, 419, 5603
13386, 2755, 5407, 4344, 5443
13387, 5115, 5699, 2903, 5815
13388, 3734, 3736, 5045, 5166
13389, 3972, 4525, 4181, 4777
13390, 1240, 5066, 4550, 5347
13391, 3954, 5688, 5808, 6138
13392, 3979, 4223, 4932, 4963
13393, 3915, 4132, 4845, 4987
13394, 4299, 5074, 3122, 5627
13395, 4339, 4977, 1293, 5285
13396, 4257, 5155, 5136, 6087
13397, 886, 4233, 1290, 5293
13398, 815, 5325, 4385, 5852
13399, 4199, 5077, 4684, 5596
13400, 4149, 4770, 4914, 5011
13401, 2504, 4551, 4340, 5647
13402, 4091, 4584, 4373, 5462
13403, 4171, 5098, 4461, 5232
13404, 4009, 4218, 4883, 5007
13405, 4141, 5345, 4948, 5481
13406, 4795, 5559, 4414, 5744
13407, 4001, 5020, 4264, 5243
13408, 4425, 4953, 419, 5603
13409, 4218, 4009, 4883, 5010
13410, 2480, 2986, 2481, 5535
13411, 4362, 998, 5794, 5923
13412, 1258, 5537, 5504, 5658
13413, 4275, 4586, 3926, 5345
13414, 3976, 5100, 4558, 5592
13415, 4511, 3916, 5202, 5465
13416, 4450, 4538, 4121, 5694
13417, 4002, 4906, 4397, 5137
13418, 4076, 4563, 4645, 5866
13419, 463, 4685, 4851, 6050
13420, 2621, 4902, 2510, 5915
13421, 4895, 5060, 3928, 5641
13422, 2370, 5662, 5034, 5681
13423, 3956, 4293, 4556, 5319
13424, 696, 631, 695, 5007
13425, 626, 5015, 4366, 5100
13426, 3755, 5043, 5818, 5827
13427, 4333, 4706, 3986, 5611
13428, 2437, 4826, 2438, 5318
13429, 3115, 4201, 5134, 5524
13430, 4429, 4586, 2759, 5173
13431, 2489, 4205, 2171, 5230
13432, 4705, 5201, 4117, 5906
13433, 812, 4320, 835, 4672
13434, 408, 5210, 4180, 5277
13435, 3931, 4673, 4425, 5709
13436, 4354, 4698, 3911, 5850
13437, 3865, 3774, 3857, 5236
13438, 3611, 4928, 3609, 5310
13439, 465, 541, 4719, 5446
13440, 4320, 5557, 4059, 5927
13441, 2771, 2769, 2773, 5155
13442, 4317, 4858, 4428, 5360
13443, 3966, 4223, 4825, 6191
13444, 4734, 4393, 5756, 5977
13445, 3277, 5147, 3336, 5413
13446, 2799, 5490, 3083, 5944
13447, 3959, 4765, 4184, 6138
13448, 3943, 4379, 4709, 6223
13449, 4280, 4729, 3927, 5065
13450, 3998, 5033, 4466, 6034
13451, 4164, 4896, 4727, 5259
13452, 4133, 4980, 3934, 5084
13453, 1085, 4752, 4534, 5597
13454, 4002, 4352, 5137, 5844
13455, 1023, 1157, 1032, 4961
13456, 4061, 4731, 4465, 5657
13457, 858, 881, 352, 4674
13458, 2903, 2914, 5115, 5815
13459, 3900, 4689, 4985, 5643
13460, 579, 4261, 4904, 5195
13461, 1379, 1070, 955, 4781
13462, 2189, 5351, 2188, 5389
13463, 3920, 5363, 4611, 5975
13464, 3912, 4164, 4727, 5081
13465, 4100, 5168, 4892, 5473
13466, 4180, 4777, 4181, 4833
13467, 720, 4464, 719, 4614
13468, 4715, 5438, 4785, 6132
13469, 4727, 5259, 4109, 6126
13470, 4170, 3953, 4633, 4778
13471, 3549, 3585, 3473, 4473
13472, 4405, 5561, 3963, 5683
13473, 4321, 5552, 5184, 6109
13474, 1089, 4329, 4747, 5144
13475, 922, 4716, 4274, 5421
13476, 4396, 4949, 3989, 5198
13477, 2204, 4565, 2950, 5476
13478, 3955, 5095, 4123, 5649
13479, 2182, 4800, 4207, 4839
13480, 3525, 3507, 4684, 5486
13481, 4784, 5063, 4354, 5376
13482, 2580, 5053, 4409, 5226
13483, 4236, 3899, 4652, 5294
13484, 2653, 2655, 2939, 5943
13485, 4442, 4758, 3909, 5010
13486, 3907, 4160, 4950, 5097
13487, 2150, 2676, 4928, 5310
13488, 5031, 5337, 4630, 6058
13489, 2989, 4252, 2279, 5992
13490, 3983, 5723, 4864, 5941
13491, 4406, 5110, 4217, 5170
13492, 4290, 4963, 4223, 5004
13493, 1010, 1009, 1006, 4855
13494, 903, 4784, 4467, 6229
13495, 5164, 5384, 3979, 5543
13496, 964, 4310, 783, 5664
13497, 2937, 3207, 5665, 5684
13498, 3011, 4403, 5223, 6119
13499, 4352, 4002, 4488, 5844
13500, 3960, 4656, 4332, 5484
13501, 4438, 4795, 4080, 5403
13502, 4422, 4681, 4011, 5153
13503, 3910, 4275, 4540, 5481
13504, 4823, 4912, 4505, 5161
13505, 3772, 4428, 4790, 5236
13506, 3342, 3343, 3462, 5713
13507, 3224, 4417, 3189, 5669
13508, 2251, 4720, 4407, 6168
13509, 2290, 2289, 5441, 5991
13510, 3907, 5280, 4771, 5962
13511, 3944, 5000, 4343, 5530
13512, 3937, 4373, 4933, 5690
13513, 4130, 4969, 3995, 5174
13514, 3929, 4255, 5055, 5415
13515, 3923, 4240, 5146, 5239
13516, 4156, 4705, 5848, 6044
13517, 3525, 4684, 2111, 5486
13518, 4845, 4975, 4230, 5371
13519, 4244, 4797, 4670, 5540
13520, 3864, 3821, 4439, 5136
13521, 378, 5185, 377, 5612
13522, 1104, 4671, 4953, 5401
13523, 4117, 5201, 5187, 6079
13524, 5079, 5236, 4435, 5620
13525, 4401, 5086, 4693, 5659
13526, 4855, 5050, 3970, 5144
13527, 3905, 4303, 4818, 5708
13528, 2433, 4450, 5487, 5601
13529, 4027, 5485, 4338, 5802
13530, 3983, 4842, 4202, 4864
13531, 1049, 4238, 544, 5425
13532, 3947, 5278, 4764, 5366
13533, 4003, 5206, 4216, 5246
13534, 4222, 939, 4922, 5592
13535, 4373, 5462, 4584, 5809
13536, 4260, 4698, 4553, 5840
13537, 1344, 4396, 1081, 4767
13538, 2341, 4743, 4561, 5817
13539, 4196, 5165, 3916, 5179
13540, 4146, 4987, 4768, 5657
13541, 2988, 4220, 2450, 6057
13542, 3986, 4131, 4706, 5179
13543, 4230, 4975, 3915, 4987
13544, 2655, 4815, 5457, 5943
13545, 4386, 4641, 3993, 4875
13546, 3910, 4756, 4145, 5812
13547, 4664, 4882, 4051, 5296
13548, 630, 701, 702, 4328
13549, 2179, 4850, 4481, 5316
13550, 3930, 4901, 4158, 5006
13551, 1382, 807, 953, 5257
13552, 1392, 1214, 4291, 5117
13553, 4107, 5158, 4778, 5861
13554, 4524, 4608, 6005, 6093
13555, 3899, 4624, 4169, 5443
13556, 3959, 4792, 4168, 5783
13557, 4161, 4761, 4162, 5005
13558, 3422, 3432, 3313, 5714
13559, 2142, 3539, 2973, 5486
13560, 3789, 5260, 3790, 5370
13561, 4177, 4839, 4800, 5942
13562, 5061, 4088, 5451, 5625
13563, 4021, 4227, 5219, 6156
13564, 3912, 4427, 4783, 5373
13565, 3971, 4817, 4387, 5470
13566, 4191, 4882, 3902, 5074
13567, 4254, 5564, 4513, 6106
13568, 1270, 1014, 4461, 5103
13569, 3875, 4116, 5151, 5727
13570, 3101, 3658, 2116, 6091
13571, 4240, 5239, 5019, 6063
13572, 4381, 4888, 4099, 5846
13573, 4846, 5310, 3603, 6209
13574, 812, 4320, 4672, 5058
13575, 3911, 4698, 4354, 4869
13576, 2684, 4579, 2483, 4722
13577, 4328, 4624, 4124, 5875
13578, 2780, 4588, 4480, 5920
13579, 4198, 4513, 3968, 5423
13580, 558, 557, 4898, 5735
13581, 876, 1309, 5237, 5364
13582, 4731, 4987, 4465, 5657
13583, 3908, 5793, 4751, 6189
13584, 4410, 5508, 4297, 5966
13585, 850, 5563, 857, 5881
13586, 357, 4366, 4782, 5675
13587, 3071, 4526, 2817, 4919
13588, 4369, 4867, 4118, 5180
13589, 3863, 4439, 4870, 5197
13590, 4366, 5015, 626, 6197
13591, 835, 4672, 4320, 4915
13592, 693, 4806, 649, 5820
13593, 3981, 4528, 4418, 5808
13594, 4086, 4802, 4359, 5767
13595, 4392, 4471, 667, 4904
13596, 4432, 3919, 4740, 5209
13597, 3973, 4916, 4245, 5028
13598, 4106, 5214, 4690, 5322
13599, 4286, 5586, 4022, 6049
13600, 3386, 4488, 3437, 4906
13601, 4008, 4814, 4469, 5572
13602, 2790, 2554, 2583, 4580
13603, 4110, 4730, 5012, 5873
13604, 1073, 657, 4308, 6042
13605, 605, 1186, 606, 4954
13606, 3917, 4221, 5118, 6118
13607, 357, 626, 1193, 6197
13608, 3902, 5074, 4299, 5627
13609, 780, 782, 1339, 5564
13610, 653, 593, 5354, 5829
13611, 4091, 4425, 5246, 6161
13612, 4139, 5077, 4199, 5596
13613, 3999, 4924, 4446, 5295
13614, 4091, 5253, 5489, 6073
13615, 2915, 2305, 4232, 5911
13616, 832, 880, 4861, 4920
13617, 4326, 4829, 4174, 5644
13618, 2544, 5056, 4275, 6147
13619, 3857, 4435, 3856, 5620
13620, 5504, 5658, 4120, 6219
13621, 2993, 2956, 2264, 4798
13622, 2260, 2266, 2265, 4813
13623, 2267, 2343, 2976, 4959
13624, 3510, 5111, 4521, 5577
13625, 3128, 4581, 4998, 5627
13626, 2475, 5379, 4881, 6235
13627, 3976, 4222, 4985, 5832
13628, 3167, 2620, 4480, 5527
13629, 3997, 5012, 4730, 5873
13630, 1261, 4585, 978, 6193
13631, 2760, 4891, 4429, 5242
13632, 1264, 4601, 5412, 5693
13633, 558, 557, 556, 4898
13634, 731, 4354, 821, 5850
13635, 4641, 4648, 4386, 5014
13636, 3946, 4133, 5162, 5201
13637, 2209, 4746, 5609, 6112
13638, 4132, 4483, 4419, 4845
13639, 2348, 5270, 4561, 5740
13640, 4477, 5205, 3952, 6002
13641, 4323, 4715, 5203, 5916
13642, 4495, 5379, 2491, 6235
13643, 399, 4757, 4171, 5232
13644, 4677, 5406, 5034, 5830
13645, 956, 4849, 501, 5961
13646, 3337, 4820, 5044, 5413
13647, 4774, 5599, 4064, 5778
13648, 2948, 4935, 4419, 5621
13649, 2350, 5270, 2348, 5740
13650, 4246, 4579, 4050, 5044
13651, 4080, 4514, 5300, 5542
13652, 3936, 4590, 4199, 5315
13653, 4263, 3918, 5140, 5217
13654, 3993, 5145, 4835, 5979
13655, 3933, 4814, 4464, 4845
13656, 934, 4394, 877, 4956
13657, 4123, 5095, 3998, 5926
13658, 3286, 4931, 3239, 5934
13659, 683, 711, 682, 4485
13660, 4509, 4788, 4262, 5247
13661, 3821, 4439, 2922, 5151
13662, 2661, 4717, 2527, 4854
13663, 4926, 5705, 4189, 5799
13664, 1092, 1148, 4248, 5265
13665, 4032, 5679, 5376, 5806
13666, 2320, 2277, 2338, 4696
13667, 630, 4879, 4328, 5311
13668, 2596, 2475, 4455, 4881
13669, 2872, 2608, 3138, 5558
13670, 837, 4811, 4656, 5860
13671, 4202, 4864, 4842, 5723
13672, 4272, 2315, 5075, 5678
13673, 4402, 4964, 3969, 5309
13674, 3908, 4113, 4716, 4936
13675, 4386, 4648, 4641, 5266
13676, 2248, 4609, 5416, 6227
13677, 507, 5369, 4176, 6096
13678, 4598, 5390, 4123, 5926
13679, 4383, 4656, 3960, 6102
13680, 4174, 4855, 1011, 5144
13681, 4222, 4917, 4225, 5832
13682, 4066, 4430, 5032, 5630
13683, 4375, 4663, 3962, 5992
13684, 2895, 5224, 4140, 6155
13685, 3936, 5267, 4298, 6228
13686, 4633, 5086, 2960, 5748
13687, 3441, 4436, 4900, 5797
13688, 3486, 2973, 3539, 5486
13689, 4164, 4836, 4613, 5259
13690, 4006, 5099, 4518, 5121
13691, 3955, 5250, 4639, 5649
13692, 3950, 4239, 4662, 4868
13693, 4568, 4857, 4314, 6017
13694, 3900, 4689, 4282, 5150
13695, 4729, 5065, 4280, 5218
13696, 4209, 4771, 3907, 5556
13697, 4213, 3906, 5190, 5575
13698, 4662, 4868, 1126, 5083
13699, 4645, 4955, 4330, 5618
13700, 4716, 5421, 818, 6150
13701, 3975, 4824, 4317, 5753
13702, 842, 4656, 839, 4812
13703, 2447, 2815, 2814, 4358
13704, 4499, 4668, 2868, 6173
13705, 2289, 5441, 4165, 5616
13706, 574, 4197, 576, 6019
13707, 4984, 5085, 4526, 6032
13708, 4121, 5336, 4905, 5839
13709, 3536, 5248, 3552, 6045
13710, 1315, 4139, 1413, 6151
13711, 3071, 4526, 4919, 5648
13712, 3942, 4992, 4660, 5210
13713, 2892, 2617, 4478, 5474
13714, 2343, 4559, 4959, 5356
13715, 1239, 1230, 5730, 6021
13716, 4193, 4976, 4065, 5082
13717, 4076, 4921, 5123, 5689
13718, 4275, 4948, 4023, 5345
13719, 4164, 5259, 490, 6062
13720, 1157, 4373, 1032, 4961
13721, 2176, 4850, 4292, 5335
13722, 3301, 4246, 3259, 5413
13723, 2836, 4301, 2837, 5312
13724, 4087, 4658, 4808, 5202
13725, 4318, 4483, 4008, 4814
13726, 3954, 4202, 4744, 5808
13727, 4207, 4839, 4800, 4946
13728, 4244, 4825, 4223, 6191
13729, 3194, 4228, 3016, 5226
13730, 4693, 4844, 4119, 5742
13731, 420, 417, 419, 5603
13732, 4240, 5019, 3923, 5146
13733, 3950, 4918, 4559, 5170
13734, 1206, 5035, 5092, 5912
13735, 4132, 4987, 3974, 5344
13736, 4139, 5111, 3506, 6151
13737, 1251, 4791, 603, 5757
13738, 614, 4447, 590, 5024
13739, 4074, 5410, 5060, 5468
13740, 3968, 4421, 4859, 5564
13741, 852, 5031, 4725, 5881
13742, 3380, 4886, 4648, 5014
13743, 384, 4295, 385, 5584
13744, 332, 5045, 4487, 5656
13745, 4418, 4528, 3981, 5783
13746, 3855, 5136, 4424, 5331
13747, 2964, 4769, 4537, 6142
13748, 4129, 5406, 4677, 5830
13749, 3603, 4846, 3724, 5310
13750, 4023, 4389, 4948, 5056
13751, 3916, 5179, 4272, 5202
13752, 4600, 5621, 2758, 5932
13753, 1247, 1126, 4868, 5083
13754, 3011, 2479, 5025, 6119
13755, 4102, 5699, 5115, 5815
13756, 3799, 4870, 4296, 5711
13757, 3906, 4937, 4213, 5866
13758, 3120, 3186, 2440, 4646
13759, 4234, 4639, 4038, 5649
13760, 2512, 4926, 2509, 5705
13761, 4885, 5248, 4004, 5907
13762, 4202, 3983, 4864, 4972
13763, 3983, 4413, 5723, 5941
13764, 3955, 4279, 4774, 5406
13765, 697, 651, 5371, 6236
13766, 3437, 4906, 4488, 6127
13767, 4013, 4320, 4675, 5927
13768, 3958, 4742, 4644, 5009
13769, 3048, 5221, 4190, 5297
13770, 3982, 4917, 4235, 5175
13771, 636, 635, 637, 4758
13772, 2265, 4516, 2259, 4813
13773, 2548, 4463, 2550, 5509
13774, 4049, 5989, 5569, 6234
13775, 2479, 5025, 4546, 5851
13776, 3967, 4279, 5073, 5681
13777, 747, 4759, 5285, 5634
13778, 4370, 4907, 2763, 5706
13779, 3905, 5428, 4368, 5505
13780, 4446, 5091, 4923, 5295
13781, 3865, 5236, 3857, 5620
13782, 770, 1326, 1348, 5027
13783, 3902, 4776, 4474, 5027
13784, 3797, 3813, 3799, 4296
13785, 4016, 4460, 4317, 5360
13786, 4305, 4776, 3902, 5791
13787, 4017, 5022, 4561, 5270
13788, 4183, 5034, 5662, 5681
13789, 3945, 4374, 4876, 5401
13790, 1185, 4758, 635, 6126
13791, 4076, 4645, 4563, 6206
13792, 3542, 3570, 3587, 5437
13793, 775, 4993, 4394, 5392
13794, 478, 4259, 523, 5460
13795, 4517, 5252, 4278, 5427
13796, 4352, 4911, 4397, 5137
13797, 3764, 4672, 4675, 6082
13798, 4689, 5477, 825, 5837
13799, 4009, 5007, 4315, 5449
13800, 3328, 3378, 3380, 4648
13801, 341, 859, 5237, 5588
13802, 4309, 4868, 4239, 5020
13803, 4061, 5586, 4286, 6049
13804, 3906, 5190, 4645, 5866
13805, 1187, 536, 795, 4742
13806, 490, 5259, 4164, 5743
13807, 4264, 5020, 4999, 5871
13808, 3961, 5214, 4292, 5322
13809, 4754, 5011, 3920, 6047
13810, 4062, 4857, 4314, 5420
13811, 4997, 5556, 895, 5562
13812, 4265, 4808, 4270, 5017
13813, 3951, 4650, 4371, 4938
13814, 4264, 4666, 3973, 4872
13815, 2747, 2746, 4809, 5764
13816, 4287, 5409, 4568, 5772
13817, 589, 5063, 1067, 6229
13818, 352, 4674, 881, 6086
13819, 3931, 5206, 4425, 6161
13820, 3918, 5471, 4263, 6215
13821, 3996, 4276, 5039, 5110
13822, 4328, 4700, 4195, 5257
13823, 2779, 4140, 5227, 5267
13824, 3864, 5136, 4439, 6221
13825, 4222, 4922, 939, 5836
13826, 420, 419, 4953, 5603
13827, 2680, 3122, 4299, 5074
13828, 3942, 4380, 4860, 6203
13829, 1413, 4139, 5204, 5666
13830, 4117, 4705, 4501, 5162
13831, 725, 4350, 723, 5268
13832, 3460, 4491, 3424, 4828
13833, 997, 4899, 647, 5536
13834, 4134, 5517, 2255, 5867
13835, 4309, 5020, 4239, 5544
13836, 3993, 5090, 4253, 5145
13837, 4041, 5239, 4237, 5553
13838, 1106, 4851, 5554, 5964
13839, 3921, 4691, 5124, 5840
13840, 4347, 4451, 5626, 5980
13841, 5295, 6051, 4379, 6059
13842, 4404, 2507, 4789, 5433
13843, 4514, 4627, 2907, 6198
13844, 4083, 4194, 4920, 5952
13845, 4008, 4483, 4318, 4902
13846, 4173, 4817, 4430, 5740
13847, 852, 4725, 848, 5881
13848, 378, 5072, 1114, 5185
13849, 4053, 5489, 4833, 5574
13850, 4290, 4755, 2848, 5599
13851, 1231, 5892, 4284, 6062
13852, 3907, 5264, 4209, 5556
13853, 4152, 3913, 4865, 5068
13854, 4170, 4778, 4159, 4965
13855, 677, 4446, 4924, 5295
13856, 4414, 4724, 3945, 4795
13857, 4670, 5359, 4963, 5946
13858, 3754, 5582, 5043, 5827
13859, 2428, 4803, 4412, 5512
13860, 3907, 4950, 4160, 5280
13861, 4183, 3967, 4547, 4765
13862, 4002, 4482, 4467, 5396
13863, 2160, 3068, 2158, 4283
13864, 2177, 2179, 3092, 5316
13865, 4171, 5098, 5232, 5448
13866, 4225, 4985, 4222, 5832
13867, 4125, 4028, 6024, 6136
13868, 4362, 4745, 998, 5923
13869, 3945, 4210, 4724, 5401
13870, 2314, 2315, 4272, 5774
13871, 4427, 4493, 5373, 6037
13872, 2460, 4509, 2435, 5247
13873, 538, 4799, 4307, 5349
13874, 4009, 5010, 5007, 5449
13875, 3917, 5118, 4370, 6118
13876, 3876, 5136, 3855, 5331
13877, 3061, 4804, 4203, 4996
13878, 4771, 5280, 4873, 5962
13879, 4745, 4847, 4268, 5923
13880, 4650, 4991, 4107, 5659
13881, 3301, 3261, 4246, 5326
13882, 1418, 4491, 822, 5478
13883, 4214, 5138, 5100, 5841
13884, 3916, 4808, 4658, 5202
13885, 791, 4851, 1106, 5381
13886, 3862, 4351, 5260, 5388
13887, 2289, 5616, 4165, 5785
13888, 3945, 4876, 4210, 5401
13889, 4023, 4586, 4275, 5345
13890, 1050, 5425, 4587, 5617
13891, 4132, 5344, 4281, 6232
13892, 4238, 5130, 544, 5738
13893, 2848, 4755, 4290, 5497
13894, 3502, 4138, 3501, 5263
13895, 3932, 4347, 4655, 4933
13896, 601, 4975, 1198, 5027
13897, 3440, 5759, 4911, 6095
13898, 357, 4782, 358, 5675
13899, 4111, 4373, 4961, 5690
13900, 2176, 4292, 2175, 5335
13901, 2195, 5004, 2194, 5901
13902, 3865, 4348, 5236, 5620
13903, 3922, 4685, 4143, 5403
13904, 3340, 3338, 3334, 4942
13905, 4323, 3924, 5203, 5733
13906, 4462, 3983, 5186, 5777
13907, 2758, 5621, 4600, 6174
13908, 2741, 4225, 2570, 5755
13909, 4167, 5152, 4659, 5749
13910, 3564, 3486, 3539, 5486
13911, 2572, 4581, 3128, 5074
13912, 4823, 5488, 4252, 5515
13913, 3950, 4194, 4868, 5083
13914, 2306, 5175, 5800, 5959
13915, 3199, 5695, 5078, 5764
13916, 3967, 4765, 4184, 4957
13917, 2783, 5490, 2970, 5882
13918, 4441, 4687, 1061, 5784
13919, 3435, 3396, 4897, 4986
13920, 3923, 4298, 4838, 5040
13921, 3906, 5005, 4162, 5292
13922, 3404, 4449, 3432, 5714
13923, 3111, 4531, 2678, 5375
13924, 5170, 5761, 4072, 6219
13925, 2191, 4653, 2192, 4932
13926, 2266, 2265, 4438, 5148
13927, 728, 729, 519, 4698
13928, 4049, 5054, 4986, 5714
13929, 3422, 326, 4897, 5714
13930, 4248, 5265, 4544, 5303
13931, 4235, 5175, 4917, 5832
13932, 3413, 4454, 3435, 4897
13933, 4175, 4082, 4564, 5089
13934, 4328, 5257, 4195, 5608
13935, 4071, 5205, 4917, 6002
13936, 362, 5143, 4214, 5675
13937, 4375, 5009, 3962, 5283
13938, 4214, 5100, 5675, 5841
13939, 4343, 5093, 5000, 5126
13940, 877, 4394, 775, 5015
13941, 3956, 4874, 4381, 6185
13942, 4560, 4800, 3980, 4878
13943, 4556, 5740, 5270, 5898
13944, 4203, 3983, 4804, 5811
13945, 2948, 4419, 4935, 6012
13946, 1032, 4373, 1157, 5462
13947, 3944, 4720, 4217, 4959
13948, 2113, 3421, 4827, 5958
13949, 1184, 679, 1250, 4194
13950, 2861, 4938, 3066, 5978
13951, 4551, 5036, 3903, 5560
13952, 3930, 4151, 4901, 5006
13953, 4199, 5077, 4139, 5111
13954, 3129, 4193, 3211, 5078
13955, 4011, 5172, 4285, 5549
13956, 4304, 3999, 5025, 5851
13957, 3960, 4503, 4332, 4812
13958, 2525, 2529, 4600, 5394
13959, 4222, 3976, 4917, 5832
13960, 4047, 5550, 4410, 5966
13961, 4467, 5024, 4187, 5245
13962, 4168, 5720, 3959, 5783
13963, 523, 4697, 524, 5460
13964, 2270, 4912, 2272, 5640
13965, 4728, 5577, 5291, 5766
13966, 1233, 5519, 4178, 6163
13967, 3424, 4828, 4491, 5562
13968, 1419, 4219, 5595, 6045
13969, 3043, 4734, 5129, 5221
13970, 3900, 4940, 4242, 5438
13971, 4075, 5384, 4498, 5543
13972, 4182, 4480, 5527, 6189
13973, 364, 365, 363, 4840
13974, 5206, 5246, 4425, 6161
13975, 4304, 3999, 5851, 6223
13976, 1219, 4523, 1160, 5292
13977, 4611, 5261, 4090, 5736
13978, 2143, 4312, 2661, 5021
13979, 3277, 3232, 3336, 5147
13980, 2493, 2874, 2418, 4489
13981, 2531, 2868, 4668, 6173
13982, 3937, 4373, 4961, 5462
13983, 1160, 5292, 4162, 5791
13984, 3330, 2113, 3421, 4827
13985, 2923, 5456, 4170, 5742
13986, 4003, 4216, 4930, 5246
13987, 2655, 4356, 2658, 5457
13988, 626, 5015, 1193, 6197
13989, 3989, 4471, 4396, 5198
13990, 3937, 4760, 5274, 5312
13991, 3975, 4734, 5329, 5813
13992, 4467, 5137, 4352, 5844
13993, 3983, 4203, 4804, 4864
13994, 1043, 1161, 572, 5923
13995, 2848, 4290, 3077, 5497
13996, 3968, 4513, 5564, 6106
13997, 4133, 5084, 3934, 5162
13998, 647, 4899, 4745, 5536
13999, 3950, 4872, 4306, 5170
14000, 4458, 4794, 3980, 4946
14001, 3864, 4439, 5197, 6221
14002, 3077, 4290, 2848, 5599
14003, 4255, 5299, 4541, 5686
14004, 3542, 3587, 5263, 5437
14005, 3920, 4914, 4770, 5011
14006, 2471, 5134, 4538, 5905
14007, 1344, 4396, 4767, 5195
14008, 4207, 3980, 4800, 4878
14009, 4470, 5488, 3962, 5533
14010, 4251, 3972, 5466, 5532
14011, 4636, 4889, 4219, 5907
14012, 1198, 656, 1362, 5539
14013, 4435, 3856, 5114, 5715
14014, 3992, 4228, 5430, 6055
14015, 3978, 4717, 4172, 4925
14016, 3992, 4113, 4701, 4936
14017, 1275, 4670, 4215, 5636
14018, 4468, 1107, 4851, 6050
14019, 5720, 5808, 4528, 6138
14020, 3219, 3178, 2620, 4182
14021, 4528, 4168, 5720, 6178
14022, 887, 5417, 4583, 5896
14023, 3949, 4631, 5030, 5918
14024, 3245, 4830, 4195, 5869
14025, 4177, 3980, 4750, 4800
14026, 531, 4719, 541, 5658
14027, 3619, 4968, 3618, 5734
14028, 859, 5237, 4313, 5364
14029, 702, 804, 805, 4700
14030, 4685, 4971, 3922, 5314
14031, 972, 5196, 990, 5539
14032, 3955, 4745, 4362, 4847
14033, 3986, 4706, 4131, 5422
14034, 4683, 5178, 4861, 5682
14035, 2481, 5535, 3052, 5871
14036, 4695, 5003, 4147, 5700
14037, 3938, 4867, 4369, 5180
14038, 4904, 4949, 4396, 5195
14039, 4011, 4386, 4648, 5014
14040, 1304, 332, 4487, 5656
14041, 1070, 955, 4781, 5459
14042, 3438, 5797, 4900, 5814
14043, 2200, 4802, 4359, 5585
14044, 4207, 4800, 4560, 4878
14045, 3965, 5716, 5160, 5738
14046, 4417, 5194, 4848, 6101
14047, 3115, 2697, 2700, 4201
14048, 2532, 5177, 4668, 5999
14049, 5076, 5931, 5159, 6200
14050, 4468, 5011, 4149, 5168
14051, 1014, 1012, 4461, 5144
14052, 4706, 4894, 1229, 5789
14053, 4230, 5049, 4464, 5371
14054, 4659, 5152, 4374, 5749
14055, 3263, 4475, 4848, 6101
14056, 737, 414, 5157, 5525
14057, 4244, 5540, 4670, 5946
14058, 4429, 5168, 4030, 5242
14059, 4264, 5243, 4527, 5535
14060, 3352, 4201, 3353, 5082
14061, 3009, 5432, 4361, 5705
14062, 4069, 4656, 4332, 6027
14063, 3036, 4982, 4416, 5188
14064, 4292, 5214, 4664, 6008
14065, 4011, 5549, 4386, 5838
14066, 4220, 4079, 4910, 5273
14067, 2842, 5115, 4497, 5719
14068, 2143, 2663, 2661, 4312
14069, 4629, 4776, 4474, 4981
14070, 3950, 4918, 4239, 5544
14071, 2513, 2484, 4754, 5975
14072, 4579, 4050, 5044, 5949
14073, 2658, 4356, 4908, 5871
14074, 4302, 4708, 2356, 6105
14075, 4564, 5101, 4175, 5285
14076, 2877, 5223, 5727, 5929
14077, 4610, 5084, 4980, 6238
14078, 4009, 5007, 4883, 6118
14079, 4308, 4810, 4766, 6075
14080, 3938, 4867, 4180, 5386
14081, 840, 874, 841, 4812
14082, 3953, 4799, 4159, 4965
14083, 2655, 2658, 4356, 6214
14084, 3984, 4910, 4259, 4954
14085, 3969, 4810, 4189, 5522
14086, 3984, 4259, 4697, 4954
14087, 2145, 3097, 3493, 5125
14088, 4004, 4889, 4914, 5907
14089, 3948, 5544, 4309, 5831
14090, 4194, 5243, 5020, 5952
14091, 2738, 5410, 2686, 5669
14092, 5000, 5093, 4273, 5126
14093, 3977, 4609, 4361, 4926
14094, 4016, 5297, 5352, 5878
14095, 3971, 4817, 4478, 5927
14096, 3188, 3123, 2148, 4448
14097, 2176, 2281, 2178, 4850
14098, 725, 859, 5149, 5364
14099, 3935, 4164, 4749, 4941
14100, 4168, 4792, 4748, 6178
14101, 4165, 4896, 3912, 5081
14102, 1259, 4842, 4202, 5823
14103, 3977, 4750, 4609, 4973
14104, 3598, 3633, 3632, 5117
14105, 2174, 2173, 4477, 6022
14106, 2667, 4843, 4348, 5297
14107, 3747, 3748, 3749, 5062
14108, 1387, 4475, 3270, 5340
14109, 3615, 3613, 3614, 5133
14110, 2437, 5318, 2987, 6054
14111, 4429, 4457, 4004, 5173
14112, 3921, 5076, 5159, 6200
14113, 3120, 4368, 4646, 5428
14114, 4396, 4471, 4014, 5198
14115, 4374, 5163, 3945, 5559
14116, 4540, 4756, 4145, 5262
14117, 4362, 4745, 3955, 5095
14118, 4001, 4576, 5457, 6124
14119, 2907, 4627, 4514, 5719
14120, 4318, 5166, 4469, 5572
14121, 3439, 3443, 4886, 5141
14122, 4293, 4496, 4017, 5279
14123, 3488, 2983, 2121, 4640
14124, 4590, 4837, 4199, 5315
14125, 4254, 5235, 5041, 6106
14126, 4745, 4958, 1161, 5923
14127, 3564, 3539, 4521, 5486
14128, 4053, 4933, 4373, 5574
14129, 3027, 2589, 4463, 4863
14130, 2205, 4746, 4342, 5476
14131, 877, 775, 1193, 5015
14132, 2610, 4537, 2964, 4769
14133, 3380, 3376, 4886, 5014
14134, 2200, 4359, 4802, 5499
14135, 3136, 2899, 3147, 4462
14136, 716, 741, 690, 4780
14137, 443, 886, 5417, 5612
14138, 3979, 4223, 4653, 4932
14139, 3937, 4216, 4760, 5302
14140, 3454, 4394, 4956, 5442
14141, 3989, 4853, 4392, 5207
14142, 4956, 5015, 877, 5477
14143, 2481, 4264, 5535, 5871
14144, 3982, 4626, 4477, 5132
14145, 967, 971, 989, 5196
14146, 909, 4488, 906, 5141
14147, 4785, 4789, 3924, 5916
14148, 4265, 4591, 3917, 4970
14149, 3747, 5400, 3761, 5665
14150, 2596, 2473, 2475, 4881
14151, 3791, 4880, 4534, 5260
14152, 3982, 4866, 4434, 4922
14153, 4477, 5132, 4292, 5205
14154, 1270, 4171, 5103, 5232
14155, 3436, 3435, 3396, 4897
14156, 4244, 4223, 4969, 6191
14157, 3746, 3744, 3745, 5613
14158, 4289, 5300, 2287, 5441
14159, 4817, 5474, 4478, 5927
14160, 4888, 5142, 4099, 5846
14161, 4792, 5050, 4358, 5974
14162, 4174, 3959, 4792, 5050
14163, 1070, 4781, 4728, 5459
14164, 4272, 3986, 4643, 5774
14165, 4519, 5251, 4363, 5445
14166, 3208, 4365, 3127, 5535
14167, 3961, 4690, 5214, 5322
14168, 832, 4390, 760, 4920
14169, 4347, 4519, 3932, 5980
14170, 4225, 5602, 2570, 5755
14171, 3950, 4194, 4872, 5020
14172, 4809, 5764, 3517, 5825
14173, 315, 959, 3823, 4469
14174, 4690, 5029, 3961, 5185
14175, 2779, 4140, 5267, 6155
14176, 3963, 4354, 5229, 5376
14177, 4534, 4752, 3795, 5388
14178, 4215, 4963, 4670, 5359
14179, 3010, 2522, 4483, 5013
14180, 682, 639, 4485, 5146
14181, 3953, 4799, 4965, 5716
14182, 1011, 4855, 4174, 5644
14183, 2806, 5898, 4874, 5960
14184, 4201, 5097, 5134, 6029
14185, 4404, 4789, 2507, 5491
14186, 5672, 6172, 4188, 6211
14187, 4078, 5402, 3516, 5764
14188, 738, 1267, 4716, 6193
14189, 2306, 5800, 2934, 5959
14190, 1096, 1095, 301, 5508
14191, 3997, 4871, 5012, 5873
14192, 4362, 4215, 4847, 5794
14193, 3595, 3628, 3494, 6159
14194, 323, 833, 1395, 4939
14195, 3923, 4298, 5019, 6063
14196, 4724, 4795, 4143, 5113
14197, 4923, 5851, 3999, 6223
14198, 4230, 4987, 4768, 6236
14199, 2707, 4378, 3400, 5921
14200, 3959, 4418, 5720, 6138
14201, 4189, 4361, 4974, 5705
14202, 4301, 5274, 4760, 5312
14203, 3966, 4969, 4223, 6191
14204, 4559, 5170, 4406, 5822
14205, 3907, 4507, 5097, 5835
14206, 2428, 4412, 2789, 5512
14207, 4332, 4846, 4224, 5062
14208, 4150, 5612, 4621, 6187
14209, 3923, 4533, 4524, 5967
14210, 4440, 5489, 4594, 5983
14211, 2679, 2736, 2113, 5958
14212, 4460, 4824, 4179, 5783
14213, 4027, 4985, 4532, 5234
14214, 1182, 5265, 4566, 5493
14215, 4322, 4869, 732, 5710
14216, 2330, 4746, 4380, 5609
14217, 3386, 4488, 4906, 5213
14218, 3552, 3531, 4636, 5248
14219, 2593, 2484, 2951, 5382
14220, 792, 1306, 879, 5722
14221, 4042, 5251, 4363, 5876
14222, 2182, 4207, 2181, 6080
14223, 3129, 2698, 3211, 4193
14224, 886, 4233, 5293, 5417
14225, 3939, 6172, 5672, 6211
14226, 319, 1335, 1414, 5426
14227, 3907, 4950, 5280, 5962
14228, 955, 1379, 4781, 4793
14229, 4030, 5011, 4468, 5168
14230, 3945, 4514, 4876, 5115
14231, 4854, 5021, 4000, 5321
14232, 2624, 2694, 3220, 4415
14233, 4082, 5541, 4564, 6208
14234, 3981, 4535, 4202, 4791
14235, 4080, 5542, 5300, 6125
14236, 3983, 4842, 4864, 5723
14237, 3864, 3720, 3821, 5136
14238, 4148, 3141, 5377, 5792
14239, 3286, 5021, 4931, 5934
14240, 3968, 4859, 4421, 5323
14241, 3962, 4663, 4375, 5283
14242, 3221, 4606, 5261, 5736
14243, 4259, 3962, 4602, 4910
14244, 3981, 4824, 4504, 5878
14245, 3531, 4885, 4636, 5248
14246, 4672, 4675, 4320, 5447
14247, 735, 4414, 4724, 5163
14248, 3983, 4462, 4804, 5811
14249, 3285, 4848, 4475, 6192
14250, 3971, 5032, 4310, 5325
14251, 1383, 4473, 944, 5458
14252, 725, 4350, 5268, 5364
14253, 2948, 2402, 4935, 5621
14254, 4025, 5301, 4350, 5628
14255, 4332, 4656, 4069, 5484
14256, 4098, 5366, 4687, 5412
14257, 4664, 5214, 4292, 5316
14258, 2866, 4496, 4607, 5270
14259, 4320, 4672, 4013, 4675
14260, 3928, 4786, 4169, 4921
14261, 3939, 4156, 5093, 5672
14262, 2789, 2428, 2675, 4412
14263, 3981, 4791, 4202, 5808
14264, 3899, 4445, 5116, 5998
14265, 3527, 4316, 3528, 6177
14266, 4042, 4877, 4544, 5303
14267, 4613, 4109, 5120, 5631
14268, 4770, 5782, 713, 6068
14269, 4541, 5204, 4255, 5686
14270, 3924, 4647, 5145, 6107
14271, 4463, 5416, 4753, 5796
14272, 2996, 4926, 4177, 5942
14273, 408, 5386, 4180, 5752
14274, 4021, 4427, 4493, 4783
14275, 4750, 4926, 4177, 4973
14276, 528, 4660, 406, 5277
14277, 4437, 5776, 5131, 6030
14278, 2259, 4813, 4516, 5517
14279, 3944, 4951, 4166, 5000
14280, 1065, 4218, 696, 5405
14281, 731, 821, 4354, 4869
14282, 2330, 2894, 5298, 5476
14283, 397, 4797, 4171, 5506
14284, 515, 1234, 513, 4691
14285, 4327, 6028, 4668, 6154
14286, 2995, 4412, 2428, 4803
14287, 3967, 4372, 4957, 5636
14288, 5023, 5949, 2157, 6164
14289, 3999, 4392, 4924, 5295
14290, 2814, 4888, 4358, 4919
14291, 1285, 4622, 445, 5342
14292, 2948, 2301, 2402, 5621
14293, 3964, 4505, 4912, 5161
14294, 2604, 5479, 4156, 5848
14295, 2766, 5334, 2585, 5630
14296, 4007, 6030, 4437, 6118
14297, 4513, 5058, 783, 5591
14298, 2473, 5318, 4881, 5854
14299, 2236, 2205, 4342, 5648
14300, 2968, 2535, 2796, 6205
14301, 4295, 4598, 5033, 5804
14302, 4079, 4220, 5256, 5739
14303, 4519, 5445, 4363, 5521
14304, 2958, 2370, 2448, 5868
14305, 4445, 5725, 885, 5732
14306, 4264, 4001, 4999, 5020
14307, 4019, 4525, 4777, 5341
14308, 4691, 4894, 4136, 5519
14309, 4135, 4849, 3933, 5301
14310, 3717, 1120, 4515, 5711
14311, 3942, 4833, 4777, 6099
14312, 2301, 4935, 2402, 5621
14313, 4711, 5140, 4080, 6125
14314, 4307, 4742, 3958, 5511
14315, 3416, 3431, 3315, 4488
14316, 3377, 3374, 3373, 4641
14317, 852, 851, 5031, 5881
14318, 4650, 4938, 2861, 5737
14319, 4307, 4742, 537, 5349
14320, 3928, 4895, 4185, 4921
14321, 4309, 5020, 4001, 5952
14322, 3944, 4155, 4951, 5000
14323, 5217, 5471, 3918, 6215
14324, 2428, 2159, 4803, 5512
14325, 3730, 4349, 3845, 5452
14326, 4745, 5095, 4362, 5536
14327, 974, 4446, 4779, 5461
14328, 4183, 5681, 5662, 5868
14329, 4937, 5754, 5106, 6002
14330, 5030, 5909, 4560, 6140
14331, 4146, 5539, 4286, 5657
14332, 3993, 5090, 5145, 5979
14333, 3972, 4251, 4703, 5729
14334, 951, 932, 4694, 5143
14335, 3079, 4729, 5469, 5933
14336, 3976, 4985, 4532, 5225
14337, 5101, 5135, 4619, 6092
14338, 1113, 503, 480, 6050
14339, 4259, 3962, 5488, 5533
14340, 4415, 4905, 3357, 5770
14341, 4212, 5584, 4714, 6196
14342, 3528, 4316, 4885, 5308
14343, 4180, 4777, 4833, 6099
14344, 3912, 4227, 4783, 5200
14345, 1407, 833, 323, 4939
14346, 3981, 4824, 4460, 5783
14347, 3611, 3605, 4928, 5310
14348, 4344, 5531, 3899, 5875
14349, 740, 746, 747, 5634
14350, 3866, 5094, 3776, 6123
14351, 3936, 4837, 4590, 5315
14352, 2179, 4481, 3092, 5316
14353, 4937, 5106, 4205, 6002
14354, 3492, 4539, 3498, 4796
14355, 4916, 5193, 4245, 5717
14356, 325, 3324, 3412, 5131
14357, 3536, 5248, 4219, 5291
14358, 4036, 5024, 4467, 5245
14359, 2550, 4753, 2445, 5509
14360, 3909, 4538, 4450, 4826
14361, 4016, 4435, 5297, 5878
14362, 3755, 3754, 5043, 5827
14363, 3447, 3324, 4529, 5131
14364, 3813, 3799, 4296, 5711
14365, 2355, 2356, 2354, 5227
14366, 2480, 2482, 2562, 4666
14367, 1264, 4687, 1059, 5412
14368, 3942, 4777, 4357, 5210
14369, 2925, 2172, 2306, 5175
14370, 3772, 4790, 3773, 5236
14371, 4129, 5480, 4639, 5649
14372, 2668, 3048, 4190, 5297
14373, 3793, 3791, 3705, 4534
14374, 4006, 4560, 5030, 5909
14375, 5251, 5445, 4519, 5521
14376, 1101, 1104, 1112, 4953
14377, 2826, 2824, 4519, 5521
14378, 4011, 4648, 4386, 5549
14379, 5237, 5588, 4313, 5934
14380, 4223, 3979, 4825, 4963
14381, 4252, 4834, 2279, 5992
14382, 4032, 5139, 4260, 5229
14383, 424, 543, 1204, 4549
14384, 4413, 5186, 3983, 5777
14385, 3494, 5598, 3490, 6159
14386, 3023, 2907, 4627, 6198
14387, 4881, 5419, 4021, 5962
14388, 4300, 3929, 4841, 5224
14389, 2945, 2271, 4693, 5833
14390, 2447, 4748, 4358, 5142
14391, 3936, 4240, 4541, 5019
14392, 3963, 4352, 4784, 5137
14393, 730, 732, 4869, 5710
14394, 506, 4176, 5892, 6096
14395, 829, 828, 4385, 5424
14396, 4428, 4858, 865, 5360
14397, 4450, 4883, 4009, 5010
14398, 3904, 4857, 5614, 6101
14399, 4253, 5145, 5090, 5979
14400, 1320, 4305, 878, 6110
14401, 4311, 4892, 3926, 5473
14402, 731, 4869, 4354, 5850
14403, 369, 4622, 370, 5864
14404, 4020, 4968, 4628, 6148
14405, 3223, 3281, 3278, 4445
14406, 4347, 4643, 3986, 5052
14407, 2296, 4330, 2295, 4955
14408, 2596, 4881, 4455, 5854
14409, 3983, 4203, 4972, 5811
14410, 4086, 4877, 4363, 5767
14411, 2108, 3274, 3230, 6038
14412, 4327, 4378, 5054, 6154
14413, 4203, 4996, 4528, 5688
14414, 4096, 4908, 4406, 5566
14415, 2819, 5298, 4655, 5483
14416, 4694, 5328, 5143, 5641
14417, 2813, 2364, 5142, 5846
14418, 4072, 4959, 4676, 5126
14419, 4106, 5523, 5342, 6072
14420, 3996, 5110, 5039, 5994
14421, 1275, 4215, 5359, 5794
14422, 2996, 4177, 4926, 4973
14423, 4117, 5906, 5201, 6079
14424, 2711, 2713, 4490, 5176
14425, 295, 4454, 1355, 5131
14426, 2160, 3068, 4283, 5468
14427, 4351, 4615, 4010, 5388
14428, 4037, 5055, 4255, 5415
14429, 4279, 4755, 3967, 4847
14430, 4628, 4968, 4020, 5133
14431, 552, 4610, 5440, 6225
14432, 4006, 5121, 4355, 5350
14433, 573, 4325, 1190, 5823
14434, 2236, 4342, 5085, 5648
14435, 4185, 3928, 4694, 4895
14436, 4292, 3952, 4664, 6022
14437, 2114, 3318, 3411, 4522
14438, 4708, 5191, 4353, 5982
14439, 4149, 5011, 4914, 5348
14440, 4900, 5797, 4206, 5814
14441, 4459, 4816, 1004, 5502
14442, 4164, 3912, 4896, 5081
14443, 3950, 4872, 4194, 5083
14444, 4655, 5298, 3932, 5574
14445, 3931, 4713, 4411, 5374
14446, 3944, 4959, 4217, 5761
14447, 3975, 4680, 4317, 5399
14448, 1368, 4195, 5257, 6043
14449, 3443, 5141, 3431, 5213
14450, 877, 4956, 4394, 5015
14451, 3021, 4645, 3001, 4989
14452, 4409, 4707, 4640, 5639
14453, 3136, 4462, 3147, 4804
14454, 4276, 5110, 4406, 5913
14455, 446, 4212, 388, 5496
14456, 3300, 4931, 3238, 5780
14457, 4962, 5370, 4047, 5550
14458, 2797, 2753, 2164, 4512
14459, 3981, 4202, 4535, 4864
14460, 3862, 5260, 3792, 5388
14461, 1372, 3583, 1301, 4539
14462, 4648, 5014, 4641, 5266
14463, 3906, 4161, 4645, 4763
14464, 664, 662, 663, 4741
14465, 4364, 4159, 4778, 6041
14466, 3513, 4976, 4193, 5385
14467, 5006, 5278, 4321, 6109
14468, 1258, 4712, 5504, 5537
14469, 4302, 4736, 4501, 6105
14470, 3913, 4176, 4836, 5068
14471, 4248, 4757, 4544, 5265
14472, 4218, 5042, 3917, 5405
14473, 4663, 4769, 2451, 5551
14474, 604, 4680, 561, 4829
14475, 4692, 4726, 4284, 5892
14476, 576, 4197, 5195, 6019
14477, 4078, 5764, 4809, 5825
14478, 3900, 4657, 4269, 4785
14479, 3947, 4166, 5080, 5088
14480, 3361, 4940, 4242, 5272
14481, 4188, 801, 5276, 5633
14482, 4226, 5177, 3911, 5652
14483, 3984, 4732, 4266, 5482
14484, 3954, 5034, 5688, 6138
14485, 2498, 4591, 4907, 5601
14486, 1290, 5293, 4233, 6122
14487, 3921, 4632, 5124, 6200
14488, 4172, 3978, 4925, 5301
14489, 4149, 5516, 789, 6068
14490, 4565, 5448, 4913, 5856
14491, 4303, 4637, 3905, 4949
14492, 1101, 4953, 1112, 5981
14493, 4054, 4189, 5522, 5590
14494, 4525, 2232, 5729, 6112
14495, 4106, 5132, 4292, 5322
14496, 723, 4614, 5268, 5343
14497, 4437, 4370, 4884, 6117
14498, 4159, 4778, 4170, 4844
14499, 2971, 2538, 2251, 5255
14500, 4434, 4866, 4282, 4922
14501, 2437, 4826, 5318, 6054
14502, 3021, 3001, 4645, 6206
14503, 572, 4958, 4744, 5645
14504, 326, 5569, 4897, 5714
14505, 3902, 4191, 4581, 4981
14506, 3923, 4608, 4524, 5019
14507, 5006, 5080, 4321, 5278
14508, 3263, 4848, 3262, 5194
14509, 4166, 3944, 4720, 4951
14510, 1058, 4710, 4364, 5327
14511, 4373, 4584, 4091, 5489
14512, 4559, 4908, 2928, 5822
14513, 3933, 4419, 4845, 5290
14514, 791, 5381, 1106, 5964
14515, 2472, 4160, 4881, 5318
14516, 806, 1070, 4728, 5459
14517, 452, 5307, 4211, 5828
14518, 4273, 4156, 5479, 6044
14519, 3937, 4760, 4301, 5274
14520, 434, 1262, 4992, 6009
14521, 2118, 3189, 2739, 5669
14522, 3949, 5109, 4661, 5390
14523, 4976, 5556, 4065, 5637
14524, 1368, 1309, 4195, 6043
14525, 2385, 5579, 3011, 6119
14526, 2801, 4774, 4543, 5778
14527, 4183, 5688, 5034, 6138
14528, 2892, 2615, 2617, 5474
14529, 3937, 4451, 5312, 5690
14530, 3779, 3783, 3834, 5715
14531, 4109, 5200, 4758, 5745
14532, 4015, 4201, 4828, 5770
14533, 3953, 5532, 4587, 6169
14534, 4163, 5216, 4628, 5589
14535, 2849, 5240, 4547, 5497
14536, 4425, 4091, 5246, 5462
14537, 1333, 974, 4446, 4779
14538, 4140, 3936, 5299, 6228
14539, 3382, 3384, 3319, 4490
14540, 3585, 4473, 3549, 6004
14541, 4379, 6051, 4077, 6059
14542, 3565, 4781, 5111, 5577
14543, 3928, 5328, 4694, 5641
14544, 3903, 5036, 4551, 6114
14545, 4222, 4922, 4917, 5212
14546, 4101, 4916, 5002, 6079
14547, 4494, 5557, 4059, 5897
14548, 4792, 5142, 4748, 6178
14549, 4013, 4492, 4387, 4675
14550, 4131, 5179, 3986, 5422
14551, 4292, 3952, 5214, 6008
14552, 4236, 5208, 4722, 5410
14553, 3826, 4435, 3856, 5114
14554, 3611, 3609, 4928, 6209
14555, 3934, 4980, 4610, 5084
14556, 4364, 4778, 4587, 6041
14557, 3776, 5094, 3772, 5236
14558, 1397, 1253, 4771, 5556
14559, 2484, 2593, 2513, 4754
14560, 674, 1141, 4229, 5313
14561, 4568, 4314, 5169, 6017
14562, 3950, 4559, 4908, 5871
14563, 3900, 4242, 4940, 5643
14564, 2801, 2800, 4774, 5778
14565, 2423, 4998, 4161, 5627
14566, 3911, 4625, 4327, 4668
14567, 3970, 4526, 4888, 6032
14568, 2347, 4561, 2341, 4743
14569, 5474, 5624, 4059, 5704
14570, 1186, 4602, 605, 5547
14571, 3382, 4490, 2708, 5368
14572, 2220, 3070, 3045, 4991
14573, 4156, 5238, 2604, 5848
14574, 3931, 5374, 4216, 6161
14575, 5400, 5739, 3990, 6081
14576, 4409, 5053, 4617, 5226
14577, 4815, 4356, 5457, 5943
14578, 3922, 4143, 4795, 5403
14579, 3120, 4646, 2440, 5428
14580, 1284, 1282, 4250, 6104
14581, 3943, 5121, 4518, 5350
14582, 3964, 4406, 4918, 5913
14583, 737, 1188, 414, 5525
14584, 2908, 2259, 4516, 5382
14585, 4423, 5665, 3207, 5684
14586, 4100, 4718, 4311, 4892
14587, 699, 5686, 4801, 5908
14588, 2257, 2267, 2268, 5822
14589, 4271, 4743, 3965, 4945
14590, 4077, 4709, 4379, 6223
14591, 715, 5686, 699, 5908
14592, 4112, 4600, 4419, 5621
14593, 4092, 4713, 5281, 6220
14594, 2548, 3027, 2589, 4463
14595, 4043, 4825, 4336, 5064
14596, 2941, 4335, 2646, 5361
14597, 4446, 4924, 4296, 5461
14598, 3513, 4193, 5125, 5385
14599, 4130, 3995, 4797, 5174
14600, 4461, 5098, 4031, 5232
14601, 4170, 5086, 4633, 5748
14602, 3925, 5703, 4678, 5730
14603, 4129, 5250, 5480, 5649
14604, 4699, 5042, 4270, 5289
14605, 4339, 4877, 3941, 5101
14606, 3209, 4228, 3194, 5987
14607, 3083, 4543, 2801, 5944
14608, 2409, 5858, 4822, 6011
14609, 2473, 2987, 5318, 5854
14610, 3499, 4796, 4138, 5426
14611, 2993, 3032, 2956, 4798
14612, 4390, 4916, 4101, 5108
14613, 723, 5268, 4350, 5343
14614, 4619, 5101, 4086, 5674
14615, 1239, 5730, 641, 6071
14616, 4306, 5170, 4872, 6219
14617, 4369, 4180, 5386, 5752
14618, 3515, 4976, 3514, 5078
14619, 4197, 5250, 4745, 5649
14620, 3963, 4784, 4354, 5376
14621, 4587, 5532, 4288, 6169
14622, 4200, 4928, 3612, 6121
14623, 4824, 4317, 5753, 5878
14624, 2116, 3658, 4562, 6091
14625, 1074, 1075, 1086, 4296
14626, 1259, 4202, 4842, 5723
14627, 2899, 4704, 4462, 5667
14628, 4008, 4483, 4902, 6232
14629, 3911, 4869, 4354, 6234
14630, 4228, 3992, 4617, 6055
14631, 4525, 2232, 5663, 5729
14632, 4740, 5064, 4336, 5634
14633, 4138, 4640, 4409, 4707
14634, 3744, 3743, 3745, 4846
14635, 2451, 5551, 4769, 5629
14636, 886, 5293, 4583, 5417
14637, 3036, 4416, 2334, 5188
14638, 4393, 4990, 5853, 6135
14639, 5334, 5397, 2585, 5630
14640, 767, 4689, 825, 5837
14641, 1407, 823, 4939, 5338
14642, 3902, 4761, 4161, 5005
14643, 3175, 2727, 4576, 4999
14644, 4297, 6023, 4842, 6035
14645, 4621, 5391, 4233, 5417
14646, 4086, 5101, 4619, 6092
14647, 3676, 5638, 5104, 6194
14648, 2455, 2395, 2397, 4988
14649, 405, 1262, 4357, 4992
14650, 4307, 3958, 4945, 5511
14651, 4001, 5020, 5243, 5952
14652, 4632, 4260, 5124, 5507
14653, 4347, 4655, 4451, 5980
14654, 4339, 4564, 3941, 4977
14655, 4252, 5463, 2989, 6089
14656, 3634, 4939, 4701, 5430
14657, 3946, 4273, 5093, 5126
14658, 431, 5730, 4151, 6071
14659, 4666, 4872, 4264, 5356
14660, 730, 4869, 4698, 5710
14661, 3779, 5186, 3783, 5715
14662, 4708, 4841, 4140, 5224
14663, 4207, 4946, 4878, 6187
14664, 4341, 5220, 4772, 6103
14665, 3961, 4850, 5214, 5316
14666, 3996, 4401, 5039, 5833
14667, 4568, 3904, 5208, 5409
14668, 1382, 807, 5257, 5495
14669, 2621, 4902, 4281, 6048
14670, 2169, 4205, 5106, 5800
14671, 3983, 4704, 4462, 5811
14672, 4321, 5552, 2237, 6001
14673, 4298, 5267, 3936, 6063
14674, 3071, 5648, 4919, 6024
14675, 4084, 5909, 5030, 6140
14676, 4676, 5126, 4959, 5622
14677, 4127, 4741, 4555, 6070
14678, 4437, 4604, 4370, 6117
14679, 1411, 4651, 632, 5358
14680, 3930, 5006, 4267, 5439
14681, 1332, 5844, 4482, 5976
14682, 4276, 4693, 4119, 4912
14683, 953, 701, 4856, 5257
14684, 4282, 5150, 4689, 5836
14685, 537, 4742, 4307, 5790
14686, 768, 987, 940, 5592
14687, 3914, 5089, 4447, 6208
14688, 1032, 4961, 4373, 5462
14689, 4186, 4489, 5396, 6184
14690, 642, 649, 648, 5547
14691, 4181, 5341, 4525, 6112
14692, 990, 4286, 5367, 5539
14693, 427, 5439, 425, 5969
14694, 4111, 4933, 4373, 5690
14695, 4604, 4960, 4370, 6117
14696, 4746, 4181, 5609, 6112
14697, 4410, 5550, 5508, 5966
14698, 4237, 4635, 3923, 4838
14699, 1220, 5496, 4773, 5872
14700, 4124, 4624, 4328, 4856
14701, 3793, 4534, 3795, 5388
14702, 1026, 1172, 1041, 5333
14703, 3942, 4992, 4357, 5429
14704, 857, 1346, 1137, 5337
14705, 4007, 4437, 4370, 6118
14706, 4267, 5080, 5006, 5278
14707, 794, 4427, 1185, 5373
14708, 3237, 5021, 4448, 5452
14709, 4676, 5193, 5126, 5717
14710, 3464, 3409, 5339, 5839
14711, 4672, 4320, 4915, 5447
14712, 4400, 5245, 4821, 5810
14713, 3903, 5096, 4879, 5311
14714, 4467, 4784, 4352, 5137
14715, 726, 1304, 4487, 5149
14716, 3528, 3527, 3529, 4885
14717, 3914, 4552, 5806, 5810
14718, 3937, 5312, 5274, 5690
14719, 4491, 4905, 3470, 5339
14720, 2807, 4293, 2873, 5898
14721, 4020, 4628, 4294, 6148
14722, 3554, 4772, 3555, 5112
14723, 4010, 4893, 4296, 5038
14724, 657, 4766, 4651, 6042
14725, 4276, 5039, 4192, 5192
14726, 4683, 5243, 4527, 5682
14727, 3992, 5430, 4291, 6055
14728, 4589, 4696, 3958, 5456
14729, 5131, 5776, 4454, 6030
14730, 4176, 3927, 4726, 5068
14731, 3935, 5113, 4572, 6125
14732, 4043, 5546, 4361, 5796
14733, 3506, 4139, 5077, 5111
14734, 3927, 5068, 4176, 5128
14735, 4043, 4609, 4361, 5546
14736, 4680, 4829, 4326, 5735
14737, 4315, 5070, 4121, 5449
14738, 4123, 4661, 5109, 5390
14739, 4328, 4879, 3903, 5096
14740, 4161, 4465, 4761, 4998
14741, 3521, 4389, 5001, 5220
14742, 537, 538, 4307, 5349
14743, 4153, 5159, 5076, 5931
14744, 4414, 3922, 5744, 5828
14745, 536, 4742, 4644, 5349
14746, 2260, 2537, 2975, 4682
14747, 3545, 5220, 3586, 6004
14748, 460, 5167, 4523, 6016
14749, 3975, 4829, 4792, 5813
14750, 4451, 4655, 4347, 4933
14751, 3210, 5155, 4281, 5464
14752, 4832, 4867, 4118, 5877
14753, 4139, 5596, 5204, 5666
14754, 2213, 2212, 2210, 4594
14755, 4728, 5291, 4542, 5766
14756, 4689, 4715, 4282, 5836
14757, 849, 5045, 4469, 6231
14758, 460, 4523, 5575, 6016
14759, 4891, 5262, 3024, 5955
14760, 5009, 5488, 4044, 5515
14761, 4042, 5303, 4566, 5876
14762, 3401, 4986, 5776, 5921
14763, 4731, 4987, 4132, 6176
14764, 3882, 3718, 3823, 4469
14765, 2787, 3024, 5262, 5955
14766, 3967, 4847, 4702, 5073
14767, 4563, 5106, 4012, 5855
14768, 4193, 4065, 5264, 5835
14769, 2338, 4589, 4696, 5463
14770, 4688, 5361, 4928, 5902
14771, 4516, 5382, 4754, 6056
14772, 4225, 3900, 4985, 5602
14773, 3724, 4846, 3744, 5310
14774, 4270, 5369, 4808, 6026
14775, 3863, 4870, 3803, 5197
14776, 3914, 5806, 5245, 5810
14777, 542, 1258, 5504, 5658
14778, 4213, 5190, 5123, 5689
14779, 2526, 2527, 2525, 4854
14780, 2343, 5356, 4959, 6133
14781, 503, 1216, 4718, 5849
14782, 4609, 5546, 5384, 5930
14783, 2159, 5287, 4803, 5512
14784, 3036, 2334, 4982, 5188
14785, 4373, 4933, 4053, 5302
14786, 4037, 5077, 4684, 5437
14787, 3955, 4745, 5250, 5649
14788, 3397, 4378, 3394, 4986
14789, 2510, 4902, 2621, 6048
14790, 4042, 5265, 4566, 5303
14791, 3991, 4484, 5102, 5492
14792, 3071, 2817, 2816, 4919
14793, 3440, 3442, 3426, 4911
14794, 4516, 4813, 2265, 5148
14795, 4256, 4852, 4220, 5431
14796, 3926, 4586, 4275, 4891
14797, 2873, 4293, 2807, 5663
14798, 4181, 4594, 3938, 4833
14799, 4678, 4901, 4151, 5703
14800, 1387, 316, 937, 5340
14801, 4059, 4675, 4387, 6074
14802, 4009, 4883, 4450, 4907
14803, 951, 585, 932, 5143
14804, 2212, 2210, 4594, 5877
14805, 3834, 4331, 3832, 6040
14806, 446, 4714, 386, 5584
14807, 3991, 5187, 5191, 5885
14808, 3459, 3342, 3418, 5713
14809, 3977, 4609, 4926, 4973
14810, 3975, 4168, 4734, 4792
14811, 2405, 2365, 5221, 6178
14812, 2357, 4708, 5191, 6105
14813, 4753, 5416, 4361, 5796
14814, 791, 1107, 4851, 5381
14815, 3547, 3474, 3548, 4389
14816, 2476, 2491, 5379, 6235
14817, 725, 723, 948, 5268
14818, 3768, 4675, 3764, 5447
14819, 3934, 4608, 4302, 6093
14820, 4266, 4093, 5482, 5660
14821, 3401, 5776, 4604, 5921
14822, 4180, 3938, 4833, 4867
14823, 1419, 5782, 4219, 6045
14824, 3978, 4135, 4700, 5096
14825, 3338, 4942, 4820, 5147
14826, 4236, 4115, 5890, 5998
14827, 4663, 4769, 4220, 6057
14828, 2200, 4359, 2198, 5585
14829, 4300, 5053, 3929, 5224
14830, 2284, 5300, 4711, 5721
14831, 3913, 4613, 5042, 5631
14832, 4180, 5210, 407, 5752
14833, 4556, 4874, 4393, 5853
14834, 4753, 5089, 4400, 5509
14835, 2150, 2676, 3118, 4928
14836, 1153, 410, 418, 4369
14837, 1214, 1167, 5338, 5845
14838, 3968, 4421, 5035, 5455
14839, 1006, 4241, 5051, 6009
14840, 3612, 4200, 3625, 5133
14841, 3432, 4449, 3313, 5714
14842, 1013, 4329, 1089, 5144
14843, 3705, 4534, 3791, 4880
14844, 1000, 4362, 998, 5794
14845, 578, 4899, 4261, 5195
14846, 3981, 5783, 4528, 5990
14847, 4091, 5489, 5157, 6073
14848, 2213, 4832, 4594, 5983
14849, 2526, 4854, 2525, 5879
14850, 2801, 4543, 4774, 5944
14851, 4072, 4872, 4666, 5356
14852, 1177, 4735, 590, 5673
14853, 4077, 4379, 6059, 6223
14854, 4310, 5325, 5032, 6046
14855, 4624, 5875, 4328, 6114
14856, 3904, 5420, 4857, 6101
14857, 563, 4179, 4829, 5545
14858, 3918, 4263, 4979, 6215
14859, 3767, 4492, 3870, 6082
14860, 4030, 4754, 5011, 5348
14861, 4024, 4328, 5875, 6114
14862, 3949, 4661, 5109, 5718
14863, 563, 4179, 5545, 5757
14864, 3945, 5163, 4374, 5401
14865, 1086, 1075, 1312, 4296
14866, 4083, 4365, 4683, 5243
14867, 4999, 5020, 4356, 5871
14868, 2111, 5486, 4684, 6201
14869, 4268, 5073, 4279, 5830
14870, 4678, 5703, 4151, 5730
14871, 4287, 4895, 4686, 5750
14872, 4481, 4560, 4207, 6090
14873, 2394, 2395, 5025, 5851
14874, 3906, 4645, 4563, 5866
14875, 3967, 4957, 4702, 5636
14876, 3910, 5379, 5012, 5419
14877, 3916, 4511, 5075, 5387
14878, 4377, 4901, 4158, 5184
14879, 3974, 4768, 4987, 5657
14880, 760, 4390, 784, 5108
14881, 3984, 4954, 4383, 5273
14882, 4441, 4592, 4081, 5784
14883, 3963, 4397, 5137, 5561
14884, 550, 4879, 4530, 5741
14885, 1339, 4859, 4254, 5819
14886, 2934, 2306, 2170, 5800
14887, 3440, 3442, 4911, 5759
14888, 1192, 738, 4360, 6193
14889, 1160, 621, 1324, 5791
14890, 4031, 4984, 4569, 5698
14891, 3535, 5248, 3533, 5291
14892, 635, 4758, 1185, 5156
14893, 2335, 4153, 5858, 6011
14894, 4383, 4656, 5860, 5939
14895, 4158, 3939, 5006, 5703
14896, 380, 1114, 378, 5072
14897, 2280, 2325, 2307, 4834
14898, 388, 4212, 446, 5584
14899, 3555, 5112, 4772, 5722
14900, 4455, 4721, 4145, 6066
14901, 4727, 5081, 4164, 5743
14902, 4229, 3907, 4771, 5962
14903, 2945, 4693, 4401, 5833
14904, 2780, 3167, 2602, 4480
14905, 3453, 4827, 3421, 5958
14906, 3959, 5720, 4765, 6138
14907, 938, 4700, 948, 5268
14908, 888, 4443, 3311, 4956
14909, 4126, 5277, 4660, 5701
14910, 4632, 5063, 4260, 5507
14911, 4191, 4882, 5296, 5529
14912, 4262, 5549, 4011, 5838
14913, 3793, 3792, 3791, 5260
14914, 3953, 4633, 4251, 5887
14915, 4202, 4842, 3983, 4972
14916, 4052, 5283, 4421, 5455
14917, 4669, 5376, 4032, 5679
14918, 4035, 4385, 4620, 5288
14919, 4528, 5720, 4748, 6178
14920, 417, 423, 415, 5462
14921, 4035, 4898, 4620, 5424
14922, 588, 587, 529, 5120
14923, 4107, 5659, 4401, 5728
14924, 4425, 5246, 4599, 5462
14925, 443, 1290, 886, 5612
14926, 3914, 4564, 5541, 6208
14927, 4065, 5082, 4976, 5385
14928, 3945, 4876, 4514, 5113
14929, 4183, 5720, 5688, 6138
14930, 1117, 5185, 4142, 6060
14931, 3079, 2977, 4729, 5933
14932, 5087, 5581, 4304, 6049
14933, 2831, 4983, 4667, 5521
14934, 2644, 2941, 2646, 5361
14935, 3433, 4206, 4940, 5646
14936, 2801, 4774, 2800, 5944
14937, 4135, 5311, 5096, 5762
14938, 4350, 5268, 4614, 5343
14939, 3799, 3802, 4870, 5711
14940, 4337, 4967, 4213, 6016
14941, 4383, 4812, 4656, 5939
14942, 4744, 4958, 571, 5823
14943, 5504, 5537, 4120, 5658
14944, 2766, 3019, 2585, 5334
14945, 379, 5612, 4621, 5894
14946, 4837, 5558, 4097, 5886
14947, 3926, 5345, 4554, 5500
14948, 3735, 3739, 5166, 5284
14949, 4069, 4811, 4486, 5739
14950, 536, 4644, 475, 5349
