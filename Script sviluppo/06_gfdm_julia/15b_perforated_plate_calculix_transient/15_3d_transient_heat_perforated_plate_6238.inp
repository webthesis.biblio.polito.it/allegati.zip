18310, 676, 672, 1141, 4873
18311, 2830, 2834, 2825, 4451
18312, 3972, 4665, 4577, 5752
18313, 937, 936, 4475, 5340
18314, 4217, 4959, 4559, 5170
18315, 4185, 4895, 4694, 5750
18316, 504, 4649, 4922, 5212
18317, 4442, 5007, 4315, 6213
18318, 4823, 4834, 4252, 5488
18319, 697, 651, 652, 5371
18320, 3595, 4539, 3662, 6159
18321, 4302, 6093, 4608, 6228
18322, 2218, 5374, 2219, 5514
18323, 4154, 4736, 4608, 5548
18324, 2313, 2920, 2311, 4511
18325, 2607, 2750, 4717, 5394
18326, 3868, 5057, 5447, 5897
18327, 4076, 5190, 5123, 5866
18328, 4226, 5465, 5177, 5652
18329, 4015, 4491, 4828, 4997
18330, 3158, 4928, 5361, 6121
18331, 2296, 2301, 4330, 5618
18332, 4231, 5102, 5241, 6078
18333, 436, 5103, 397, 6067
18334, 4331, 3834, 5715, 5758
18335, 4504, 4996, 2743, 5990
18336, 4059, 5474, 5057, 6074
18337, 4897, 5569, 1360, 5650
18338, 4093, 4834, 4823, 5488
18339, 4474, 5367, 4286, 5539
18340, 311, 3423, 934, 4956
18341, 4269, 4785, 4657, 4789
18342, 4687, 5158, 4601, 5271
18343, 3971, 5288, 4385, 5557
18344, 4058, 5127, 5307, 5744
18345, 2667, 5297, 4348, 5620
18346, 2772, 2792, 5071, 6087
18347, 4272, 4982, 2315, 5678
18348, 4644, 5349, 4159, 5805
18349, 665, 664, 663, 4835
18350, 4561, 5119, 4271, 5716
18351, 1344, 654, 1081, 4396
18352, 2847, 4755, 4547, 5681
18353, 2933, 4495, 2491, 6088
18354, 1191, 5454, 496, 5967
18355, 3967, 4372, 5636, 5880
18356, 2453, 4935, 2403, 6176
18357, 4450, 4009, 4907, 5694
18358, 2193, 2191, 2192, 4932
18359, 4104, 5305, 4882, 6008
18360, 3585, 3520, 3569, 4473
18361, 3579, 3504, 3506, 5077
18362, 4009, 4522, 5449, 5839
18363, 4092, 5278, 5269, 6220
18364, 3914, 4822, 4552, 5810
18365, 1357, 874, 840, 4332
18366, 2919, 4517, 2281, 5427
18367, 892, 3304, 1347, 4491
18368, 3449, 3257, 4942, 5147
18369, 2571, 4532, 2570, 5225
18370, 918, 4857, 882, 5614
18371, 4769, 5256, 3990, 6000
18372, 4125, 4919, 4526, 5648
18373, 4993, 5015, 4394, 6197
18374, 4951, 5000, 4155, 5080
18375, 3244, 3225, 5237, 5588
18376, 4205, 4947, 4937, 6002
18377, 4166, 5000, 4951, 5080
18378, 3944, 4995, 4217, 5494
18379, 2823, 5626, 2825, 5980
18380, 3920, 4611, 4943, 5766
18381, 2952, 5227, 4298, 5267
18382, 4697, 4725, 4060, 6007
18383, 3967, 4755, 4290, 5687
18384, 2525, 4717, 2750, 5394
18385, 4991, 5324, 4251, 5466
18386, 2218, 2219, 2221, 5514
18387, 3965, 5538, 5119, 5716
18388, 3510, 4521, 3564, 5577
18389, 4022, 4304, 4923, 6223
18390, 2931, 2331, 5487, 6054
18391, 5139, 5177, 4668, 6173
18392, 735, 4414, 5307, 5828
18393, 4251, 5324, 4991, 5861
18394, 4271, 5119, 4965, 5716
18395, 3958, 4307, 4965, 5349
18396, 3860, 5260, 4433, 5370
18397, 4079, 4383, 5273, 6102
18398, 4251, 5466, 5324, 5861
18399, 4694, 4895, 3928, 5641
18400, 3196, 5155, 2621, 5464
18401, 3802, 4515, 3804, 5197
18402, 4959, 5622, 2344, 6133
18403, 4221, 6118, 5007, 6202
18404, 4035, 4620, 4385, 5424
18405, 4292, 5335, 4477, 6022
18406, 4020, 4200, 5026, 5216
18407, 947, 1383, 5458, 6004
18408, 3717, 3804, 4515, 5451
18409, 4209, 4871, 4078, 5264
18410, 554, 555, 597, 4484
18411, 497, 4836, 4613, 6096
18412, 877, 934, 775, 4394
18413, 787, 5634, 4336, 5872
18414, 3400, 4378, 3394, 5921
18415, 4660, 4992, 4248, 5993
18416, 4241, 4070, 5320, 5502
18417, 2369, 3053, 3058, 4528
18418, 2098, 3829, 3183, 5057
18419, 4579, 4848, 4417, 5326
18420, 2988, 2450, 2407, 6057
18421, 3650, 3588, 330, 4861
18422, 3619, 3617, 4968, 5734
18423, 3120, 4368, 2992, 5811
18424, 3863, 3875, 3800, 4870
18425, 4102, 4807, 5115, 5699
18426, 4470, 795, 5092, 5912
18427, 4007, 4370, 4960, 5118
18428, 4469, 4814, 4025, 5166
18429, 4309, 5544, 4239, 5831
18430, 4416, 4095, 5076, 5938
18431, 1353, 816, 826, 5007
18432, 4907, 5694, 4009, 6144
18433, 3786, 4887, 4462, 5777
18434, 2725, 5199, 3178, 5712
18435, 4020, 5026, 4562, 6204
18436, 4171, 5103, 5254, 6067
18437, 2638, 4423, 3207, 5431
18438, 4085, 4380, 5298, 6203
18439, 3017, 3019, 2398, 5334
18440, 4369, 4601, 4046, 5914
18441, 999, 4362, 5122, 5536
18442, 4919, 5648, 4125, 6024
18443, 4121, 4905, 4415, 6029
18444, 4382, 5487, 2331, 6054
18445, 4537, 5582, 3754, 5827
18446, 4250, 4006, 5030, 5909
18447, 4040, 4218, 4883, 5010
18448, 2390, 2433, 2436, 5487
18449, 401, 434, 403, 5993
18450, 3581, 3348, 3467, 4582
18451, 4231, 4841, 4399, 6078
18452, 4295, 5033, 4794, 5804
18453, 4694, 4895, 4287, 5750
18454, 4012, 5138, 4618, 5754
18455, 2237, 5552, 4321, 5707
18456, 4652, 5294, 3899, 5443
18457, 3506, 3507, 3508, 5111
18458, 4038, 4536, 5109, 5760
18459, 2360, 4393, 2361, 5756
18460, 2621, 4281, 3210, 6048
18461, 4164, 5081, 4749, 5743
18462, 4001, 4247, 5404, 6124
18463, 4259, 4910, 3984, 5610
18464, 4745, 4958, 4268, 5250
18465, 3452, 3349, 3333, 4582
18466, 5186, 5758, 4413, 5941
18467, 5299, 5726, 4841, 6228
18468, 3335, 3352, 3350, 5125
18469, 2237, 5088, 5552, 5707
18470, 4267, 4764, 3947, 5278
18471, 3975, 4680, 4326, 5329
18472, 3768, 3868, 5057, 5447
18473, 531, 5504, 4719, 5658
18474, 5323, 5377, 3968, 6106
18475, 2512, 2588, 2509, 4926
18476, 4698, 4869, 4322, 5710
18477, 3518, 3519, 3517, 5825
18478, 4665, 5520, 4288, 6137
18479, 4404, 4875, 2506, 6181
18480, 2210, 5609, 4594, 5877
18481, 2707, 2128, 3331, 5651
18482, 4364, 4587, 4046, 5768
18483, 4642, 4865, 2299, 6113
18484, 642, 648, 605, 4602
18485, 4144, 4783, 4493, 5373
18486, 3071, 4919, 2816, 6024
18487, 4395, 4858, 4385, 5852
18488, 682, 527, 5146, 5964
18489, 384, 1194, 382, 4458
18490, 2500, 2521, 2454, 5932
18491, 3554, 3555, 3530, 5112
18492, 888, 329, 3417, 5646
18493, 4383, 5273, 5216, 6018
18494, 958, 4554, 4892, 5516
18495, 2829, 4643, 3028, 5626
18496, 4069, 5739, 5400, 6081
18497, 2311, 2313, 4511, 5075
18498, 4512, 4012, 5615, 5855
18499, 4029, 5440, 4610, 6225
18500, 961, 797, 5405, 6202
18501, 2328, 4786, 4426, 5560
18502, 4200, 5048, 3625, 5133
18503, 800, 784, 1341, 5623
18504, 4536, 4258, 4853, 5760
18505, 4028, 4994, 4547, 5497
18506, 3939, 4376, 5672, 6172
18507, 4540, 4756, 5262, 5955
18508, 942, 4535, 1259, 5723
18509, 3276, 3298, 3234, 5780
18510, 2386, 5025, 2395, 5436
18511, 963, 4530, 1228, 5961
18512, 677, 5091, 4446, 5295
18513, 960, 4487, 1304, 5045
18514, 1279, 4431, 387, 5122
18515, 2506, 5433, 4404, 6181
18516, 3909, 5070, 4538, 5970
18517, 4028, 4545, 4994, 5497
18518, 1357, 874, 4332, 5571
18519, 1144, 472, 476, 5501
18520, 4881, 5379, 4110, 6235
18521, 4390, 4861, 4083, 4920
18522, 4040, 4883, 4218, 5042
18523, 3725, 3730, 3845, 5452
18524, 4410, 5370, 3787, 5550
18525, 2461, 5705, 2509, 5799
18526, 1227, 1059, 4687, 5412
18527, 4022, 5581, 4304, 6223
18528, 4521, 5766, 5577, 6182
18529, 1179, 1105, 1103, 5401
18530, 4065, 4976, 4582, 5385
18531, 4526, 5085, 4342, 5648
18532, 2435, 4509, 2461, 5247
18533, 2443, 5692, 2957, 6001
18534, 915, 4422, 5153, 6116
18535, 1093, 625, 4399, 5870
18536, 481, 480, 503, 4718
18537, 4083, 4683, 4365, 6194
18538, 948, 5268, 4700, 5364
18539, 4530, 4879, 4337, 5741
18540, 2420, 5472, 4669, 6028
18541, 4158, 5692, 5568, 6001
18542, 3495, 3494, 3562, 4508
18543, 4702, 4847, 4215, 5794
18544, 4103, 5696, 4516, 6047
18545, 3452, 1370, 3467, 4582
18546, 3494, 4508, 3495, 5598
18547, 941, 868, 4460, 5211
18548, 2466, 6129, 5671, 6181
18549, 688, 685, 5276, 5816
18550, 589, 618, 5063, 5507
18551, 2493, 4489, 3213, 5984
18552, 854, 5398, 4725, 5831
18553, 554, 4484, 597, 5102
18554, 4364, 1053, 5327, 6041
18555, 2939, 2655, 2658, 5457
18556, 821, 4354, 1136, 5850
18557, 4050, 4593, 4506, 5713
18558, 4019, 5183, 4381, 5320
18559, 3146, 3186, 2883, 4646
18560, 2217, 5951, 4440, 5983
18561, 4371, 5737, 3038, 5978
18562, 4416, 4982, 3921, 5188
18563, 3551, 5567, 3575, 5637
18564, 3969, 4262, 4810, 5838
18565, 2282, 2915, 5148, 5911
18566, 3108, 5173, 4316, 5308
18567, 4347, 5626, 4451, 5690
18568, 854, 975, 4725, 5398
18569, 4641, 5014, 4386, 5593
18570, 2793, 3093, 5087, 5956
18571, 4510, 4242, 4940, 5438
18572, 815, 4385, 828, 5852
18573, 4491, 4634, 822, 5478
18574, 4455, 5379, 3910, 5419
18575, 3875, 3798, 3800, 4870
18576, 4618, 5754, 5138, 5832
18577, 4570, 4920, 678, 5108
18578, 3385, 3384, 4906, 5176
18579, 4013, 4254, 5041, 5233
18580, 3768, 5057, 4675, 5447
18581, 2205, 2203, 2204, 5476
18582, 2693, 4510, 5016, 6165
18583, 3989, 4303, 4733, 5904
18584, 3974, 5657, 4731, 5807
18585, 321, 3314, 3456, 4674
18586, 799, 784, 5002, 5108
18587, 3630, 4539, 5117, 6159
18588, 4539, 4796, 1363, 5845
18589, 3949, 4661, 4355, 5030
18590, 4473, 5313, 4209, 5567
18591, 3970, 5050, 4855, 5974
18592, 3648, 4683, 5178, 6194
18593, 426, 398, 4757, 5506
18594, 431, 1155, 641, 6071
18595, 4826, 5200, 4382, 5745
18596, 3985, 4494, 5557, 5624
18597, 3984, 5215, 4732, 6018
18598, 3536, 5291, 4219, 5595
18599, 2238, 3075, 5004, 5497
18600, 3760, 3754, 4537, 5582
18601, 3000, 2403, 2423, 4998
18602, 3913, 4865, 4642, 6113
18603, 2582, 5377, 3141, 5792
18604, 4012, 4563, 4937, 5106
18605, 3990, 4423, 4537, 5582
18606, 4086, 4359, 4969, 5767
18607, 3471, 5510, 4338, 5958
18608, 4815, 5215, 4502, 6013
18609, 2374, 2845, 5034, 5406
18610, 4294, 6007, 5215, 6148
18611, 4378, 4007, 4986, 5798
18612, 3995, 4290, 4963, 5880
18613, 2725, 3644, 5199, 5712
18614, 764, 4282, 5836, 6160
18615, 4515, 4870, 4296, 5461
18616, 4312, 4313, 5934, 5988
18617, 3962, 4324, 5256, 6000
18618, 1347, 4491, 3420, 5339
18619, 3989, 4258, 4853, 5207
18620, 2844, 5951, 2217, 5983
18621, 2461, 5247, 5705, 5799
18622, 4134, 4795, 4813, 5744
18623, 4095, 5435, 5076, 5938
18624, 1275, 1276, 5636, 5794
18625, 4309, 4868, 856, 5831
18626, 3725, 3233, 3728, 5452
18627, 4289, 5441, 5081, 6125
18628, 1390, 4410, 1082, 5228
18629, 5019, 5299, 3936, 6228
18630, 4278, 5427, 4616, 5434
18631, 3717, 4515, 3802, 5711
18632, 2740, 5394, 4340, 6174
18633, 4078, 5695, 5264, 5873
18634, 2952, 5267, 4298, 5886
18635, 2710, 4648, 4285, 5549
18636, 4539, 1363, 5117, 5845
18637, 2571, 2570, 4532, 5602
18638, 4401, 5255, 3996, 6015
18639, 3995, 4969, 4359, 5174
18640, 2165, 5615, 2167, 5855
18641, 3913, 4642, 4896, 5631
18642, 4511, 5075, 2313, 5678
18643, 2754, 4590, 2592, 5267
18644, 4007, 4604, 4437, 5776
18645, 4002, 4490, 5213, 5231
18646, 410, 409, 418, 5386
18647, 2317, 2322, 4982, 5188
18648, 2964, 5629, 2551, 6142
18649, 4100, 4685, 5403, 5973
18650, 735, 5307, 453, 5828
18651, 3941, 4571, 5435, 5445
18652, 3394, 5054, 4378, 5651
18653, 3966, 4863, 4619, 5135
18654, 4052, 4375, 4663, 5283
18655, 360, 362, 361, 5675
18656, 4174, 4747, 5144, 5545
18657, 4481, 4207, 6080, 6090
18658, 3833, 4672, 1381, 4915
18659, 922, 4274, 1399, 5421
18660, 681, 4857, 4568, 6017
18661, 4115, 4445, 4686, 5890
18662, 4190, 5352, 5297, 5878
18663, 756, 4856, 4686, 5725
18664, 4565, 5476, 4085, 5587
18665, 4002, 5231, 4482, 6184
18666, 4704, 4962, 4887, 5667
18667, 2834, 4451, 2830, 5312
18668, 601, 1198, 621, 5027
18669, 3739, 3735, 3740, 5284
18670, 3973, 4916, 4527, 5682
18671, 920, 4319, 1207, 6196
18672, 4140, 5299, 4841, 6228
18673, 4293, 4874, 4556, 5898
18674, 4434, 5203, 4647, 6160
18675, 3953, 4238, 5119, 6169
18676, 4017, 4816, 5279, 6169
18677, 3312, 3454, 3345, 4394
18678, 2453, 6012, 4935, 6176
18679, 4424, 5136, 4257, 5155
18680, 3533, 5248, 3536, 5291
18681, 4455, 4756, 3910, 5379
18682, 2167, 2169, 4563, 5106
18683, 700, 4856, 630, 4879
18684, 4019, 4357, 4777, 5895
18685, 2163, 3116, 4618, 5512
18686, 3946, 4712, 5201, 5717
18687, 2933, 5056, 4495, 6088
18688, 4846, 5062, 4332, 5571
18689, 3940, 4757, 5174, 5506
18690, 4684, 5486, 4199, 6201
18691, 3787, 3697, 3789, 4410
18692, 4201, 5097, 4612, 6237
18693, 4172, 5301, 4600, 6212
18694, 1109, 4544, 1172, 5333
18695, 4315, 4529, 4009, 5444
18696, 2963, 2800, 4774, 5944
18697, 552, 4610, 1176, 6238
18698, 4435, 5236, 4348, 5620
18699, 1321, 1386, 346, 5780
18700, 4430, 4817, 4173, 5842
18701, 3965, 4430, 5032, 5578
18702, 4472, 5304, 4630, 5952
18703, 4335, 5026, 2646, 5361
18704, 3839, 4915, 4395, 5447
18705, 4388, 5138, 5100, 5935
18706, 2828, 2831, 2827, 5521
18707, 3803, 3800, 3802, 4870
18708, 2239, 2191, 4498, 5778
18709, 3964, 4918, 4550, 5913
18710, 4245, 4676, 4666, 6128
18711, 765, 1343, 4689, 4715
18712, 4155, 4764, 4267, 5475
18713, 4773, 5496, 4336, 5872
18714, 3979, 4653, 4498, 4932
18715, 3932, 5298, 4519, 5876
18716, 3903, 4624, 4328, 6114
18717, 3977, 4714, 4603, 6196
18718, 2143, 3255, 3293, 5375
18719, 2664, 5226, 4409, 5639
18720, 2199, 4545, 5499, 6024
18721, 3575, 3551, 3522, 5567
18722, 3740, 3888, 3741, 4391
18723, 4049, 4986, 4378, 6152
18724, 1047, 1045, 4957, 5636
18725, 4831, 5407, 3170, 5647
18726, 4111, 4961, 4456, 5690
18727, 3907, 4871, 4209, 5264
18728, 2248, 2188, 3104, 4609
18729, 5007, 6118, 4529, 6202
18730, 3384, 4490, 3382, 5368
18731, 462, 461, 5003, 5967
18732, 2483, 4579, 2683, 5023
18733, 3698, 1099, 5632, 5758
18734, 480, 4718, 481, 5973
18735, 2830, 4451, 2825, 5626
18736, 2909, 4516, 2265, 5148
18737, 4455, 4227, 4783, 5854
18738, 4074, 5409, 4283, 5936
18739, 1032, 1157, 1042, 5462
18740, 1085, 3704, 3824, 4752
18741, 845, 1416, 5383, 5939
18742, 4402, 5942, 4839, 6143
18743, 581, 4392, 667, 4904
18744, 3636, 4701, 3634, 4939
18745, 679, 4570, 611, 5083
18746, 4462, 4887, 3786, 5667
18747, 989, 310, 5061, 6190
18748, 4113, 4701, 4182, 6108
18749, 3860, 4962, 3859, 5370
18750, 4020, 5048, 5026, 5133
18751, 3286, 3242, 5021, 5934
18752, 4643, 5469, 4068, 6006
18753, 1041, 4544, 426, 5265
18754, 3799, 3802, 3800, 4870
18755, 3978, 4830, 4531, 5608
18756, 4536, 2970, 5362, 5882
18757, 3306, 2701, 3399, 4604
18758, 3951, 4650, 4938, 5324
18759, 2639, 5431, 4256, 5945
18760, 4500, 5632, 5508, 6035
18761, 2760, 5242, 4429, 5619
18762, 3967, 5636, 4702, 5880
18763, 4012, 5106, 4937, 5754
18764, 3871, 3766, 3870, 5041
18765, 3520, 3569, 4473, 5402
18766, 3704, 1085, 334, 4752
18767, 4799, 5349, 1121, 6041
18768, 3738, 3882, 4469, 5572
18769, 4023, 4948, 4341, 6020
18770, 1252, 688, 801, 5276
18771, 2994, 2540, 4353, 5982
18772, 3923, 5019, 4524, 5146
18773, 3304, 3470, 3420, 4491
18774, 2682, 5535, 4527, 5883
18775, 4103, 5127, 4567, 5517
18776, 650, 981, 4739, 5718
18777, 4288, 5425, 4816, 5520
18778, 2275, 2273, 2274, 6089
18779, 3997, 4730, 4809, 5825
18780, 4361, 5546, 3977, 5590
18781, 4195, 4700, 4328, 5608
18782, 4803, 4966, 4283, 5889
18783, 373, 5342, 445, 6122
18784, 523, 1140, 4697, 4954
18785, 4039, 4916, 4527, 5028
18786, 317, 944, 1383, 4473
18787, 4979, 5471, 4144, 6215
18788, 3964, 4505, 5161, 5847
18789, 1287, 5293, 5305, 6131
18790, 1120, 4515, 968, 5451
18791, 4163, 5216, 5589, 5939
18792, 3036, 2334, 2317, 4982
18793, 3025, 2398, 2766, 5630
18794, 4013, 5058, 4513, 5591
18795, 2500, 3010, 2522, 4483
18796, 1272, 4534, 303, 5821
18797, 4416, 4095, 5052, 5751
18798, 3816, 3722, 3153, 6052
18799, 3920, 4611, 4457, 5975
18800, 628, 685, 599, 5492
18801, 370, 5212, 368, 5864
18802, 3862, 3861, 5260, 5765
18803, 3953, 5532, 4251, 5861
18804, 3553, 1163, 3475, 5595
18805, 2611, 5862, 4590, 6201
18806, 346, 875, 4349, 5656
18807, 4222, 4985, 4225, 5150
18808, 3509, 3565, 4781, 5111
18809, 3219, 5411, 4762, 5712
18810, 4029, 6093, 4302, 6228
18811, 3250, 4830, 5375, 5934
18812, 2691, 3366, 4510, 5995
18813, 3935, 4263, 5081, 6125
18814, 3910, 4540, 4756, 5812
18815, 4392, 4853, 5380, 6059
18816, 1342, 676, 1412, 4507
18817, 4453, 5469, 4643, 6006
18818, 750, 1206, 752, 5035
18819, 4107, 4991, 4650, 5324
18820, 691, 1332, 4482, 5976
18821, 2613, 5397, 4387, 5630
18822, 4058, 5182, 4659, 6145
18823, 2305, 5262, 4232, 5911
18824, 4075, 4498, 5384, 5389
18825, 3471, 4338, 3453, 5958
18826, 2801, 4543, 3083, 5107
18827, 3351, 3354, 3461, 4828
18828, 4600, 5301, 3933, 6212
18829, 2203, 4565, 2204, 5476
18830, 1053, 4364, 1055, 5768
18831, 4888, 4919, 4526, 6115
18832, 4355, 4739, 3949, 5918
18833, 3948, 5404, 4309, 5544
18834, 2729, 4435, 2669, 5620
18835, 4075, 4466, 4973, 6034
18836, 2906, 2914, 2222, 5514
18837, 4108, 4885, 4316, 4909
18838, 4266, 4093, 5660, 5847
18839, 459, 995, 526, 6016
18840, 3988, 4314, 5169, 5889
18841, 4414, 4724, 4143, 5903
18842, 4040, 4642, 4382, 5487
18843, 2851, 2422, 2346, 4607
18844, 2974, 4983, 2843, 5857
18845, 4029, 4610, 4524, 6225
18846, 2181, 2183, 3086, 4560
18847, 4100, 5403, 4718, 5973
18848, 3664, 2151, 4508, 5834
18849, 4204, 5180, 5253, 6073
18850, 2572, 3128, 2578, 5074
18851, 3993, 5145, 4323, 5580
18852, 4717, 4854, 4312, 5154
18853, 460, 4523, 1219, 5575
18854, 3698, 5632, 4413, 5758
18855, 2303, 5621, 2758, 6174
18856, 4008, 4464, 4814, 6232
18857, 4300, 5189, 2425, 5982
18858, 752, 751, 750, 4421
18859, 615, 617, 1152, 4432
18860, 724, 723, 4350, 5343
18861, 354, 881, 6017, 6086
18862, 1365, 922, 818, 4716
18863, 4266, 5215, 3984, 6007
18864, 3974, 4230, 4768, 5344
18865, 5300, 5542, 4627, 6125
18866, 1376, 818, 5421, 6150
18867, 4067, 5940, 4253, 6107
18868, 4066, 5423, 5235, 5578
18869, 556, 4787, 4459, 5502
18870, 830, 4858, 4428, 5286
18871, 2590, 3089, 3091, 5296
18872, 1297, 3279, 3231, 4942
18873, 5264, 5695, 4612, 5873
18874, 4250, 5033, 4794, 5909
18875, 2488, 2994, 3069, 5527
18876, 330, 4861, 3588, 5623
18877, 4355, 5121, 4583, 5350
18878, 4276, 4912, 4119, 5192
18879, 3870, 4492, 3722, 6052
18880, 4368, 4677, 4203, 4972
18881, 3684, 3617, 3619, 5734
18882, 1242, 1174, 1126, 4662
18883, 2938, 4668, 2868, 5472
18884, 2364, 4734, 5142, 5756
18885, 4515, 5461, 4296, 5711
18886, 5281, 5513, 4092, 6109
18887, 4019, 5085, 4381, 5183
18888, 4362, 5095, 3998, 5122
18889, 3562, 3487, 3495, 5639
18890, 4202, 4418, 4791, 6175
18891, 2685, 4926, 2996, 5942
18892, 3909, 4227, 5200, 5219
18893, 4261, 4853, 3989, 5760
18894, 4301, 5218, 5353, 5655
18895, 4360, 5187, 5102, 5492
18896, 4209, 4078, 4871, 5402
18897, 3678, 3600, 4562, 5048
18898, 2866, 2852, 2851, 4607
18899, 4398, 4873, 4021, 5156
18900, 4257, 5418, 2771, 6087
18901, 4372, 3995, 5254, 6067
18902, 4265, 4808, 4511, 4970
18903, 5113, 5140, 4572, 6125
18904, 1240, 4550, 502, 5347
18905, 1153, 4369, 418, 5914
18906, 4042, 4877, 4571, 5333
18907, 4173, 5853, 4990, 6135
18908, 4502, 5943, 2653, 6091
18909, 4108, 4927, 4772, 5722
18910, 2671, 2669, 2729, 4435
18911, 1179, 1173, 4724, 5903
18912, 445, 5342, 4452, 6122
18913, 1166, 586, 994, 4699
18914, 4634, 5449, 4315, 6213
18915, 3730, 5046, 4349, 5452
18916, 3965, 4945, 4307, 5716
18917, 4613, 4836, 3913, 6096
18918, 4797, 5254, 3995, 6067
18919, 2670, 2743, 3048, 5221
18920, 4510, 3367, 5016, 5814
18921, 4595, 4939, 739, 5338
18922, 716, 1170, 986, 4780
18923, 4651, 4766, 4308, 6042
18924, 640, 5163, 1101, 6145
18925, 2142, 4521, 2872, 5261
18926, 2415, 4627, 3034, 5218
18927, 4499, 4668, 4032, 5472
18928, 4033, 5111, 4199, 5315
18929, 4193, 5078, 4612, 5264
18930, 4325, 4958, 4744, 5823
18931, 4129, 5505, 5250, 5830
18932, 4316, 4885, 4004, 4909
18933, 4234, 5095, 4123, 5390
18934, 4078, 4871, 4730, 5873
18935, 4172, 5154, 5301, 5628
18936, 4251, 5532, 3953, 5887
18937, 626, 359, 1314, 5675
18938, 3905, 4818, 4646, 5708
18939, 2906, 2222, 4497, 5514
18940, 716, 690, 675, 4780
18941, 960, 4487, 5045, 5343
18942, 2682, 4365, 3208, 5535
18943, 470, 469, 5066, 5347
18944, 4580, 5334, 2790, 5795
18945, 2760, 4429, 2591, 5619
18946, 4113, 4182, 4751, 6108
18947, 4378, 5798, 4986, 5921
18948, 3715, 4433, 3861, 5765
18949, 3353, 4828, 5082, 5770
18950, 4313, 5154, 4350, 5364
18951, 537, 518, 538, 5349
18952, 2128, 3391, 3331, 5651
18953, 3969, 4253, 4723, 5090
18954, 4062, 4820, 4246, 5420
18955, 877, 5015, 873, 5477
18956, 1219, 1160, 1248, 5292
18957, 4479, 4224, 5062, 5484
18958, 4657, 4789, 4785, 5438
18959, 4575, 5161, 4060, 5306
18960, 5066, 5347, 469, 6179
18961, 3699, 3856, 4435, 5620
18962, 3992, 4595, 5241, 6053
18963, 4269, 3900, 4785, 5150
18964, 4095, 5445, 5251, 5521
18965, 4504, 2743, 5221, 5990
18966, 4067, 4253, 5145, 6107
18967, 812, 4320, 5058, 5325
18968, 2681, 6177, 3108, 6233
18969, 3260, 3259, 4848, 5147
18970, 4028, 4765, 4547, 4994
18971, 4624, 4856, 4185, 4879
18972, 4435, 5079, 4016, 5236
18973, 4343, 4712, 4120, 5504
18974, 2952, 2324, 2323, 5040
18975, 3420, 1347, 3304, 4491
18976, 4566, 4860, 4660, 5701
18977, 3499, 3480, 4796, 5426
18978, 4285, 5231, 4063, 6061
18979, 617, 4766, 4432, 5358
18980, 3616, 5133, 4968, 5383
18981, 4001, 4309, 4630, 5404
18982, 3082, 4543, 2801, 5107
18983, 4320, 5447, 4675, 5927
18984, 3907, 4871, 5873, 5962
18985, 3937, 4760, 5275, 5302
18986, 884, 759, 5614, 5772
18987, 4431, 4773, 3979, 5359
18988, 761, 705, 704, 5733
18989, 3128, 2578, 5074, 5627
18990, 4730, 4871, 4078, 5825
18991, 485, 5217, 483, 5471
18992, 572, 571, 4744, 4958
18993, 3536, 3533, 3552, 5248
18994, 500, 4679, 600, 4975
18995, 4372, 4670, 3995, 6067
18996, 3091, 5316, 4664, 6022
18997, 792, 4927, 957, 5702
18998, 2606, 3170, 5407, 5647
18999, 4630, 5104, 4472, 5952
19000, 3926, 4311, 5473, 5481
19001, 4099, 5142, 4358, 5974
19002, 3943, 4709, 4304, 5581
19003, 4231, 5241, 4841, 6078
19004, 3470, 4491, 3358, 4905
19005, 2991, 5427, 4616, 5433
19006, 346, 4349, 3727, 5656
19007, 4387, 5397, 2614, 6074
19008, 2610, 2964, 2495, 4769
19009, 1132, 1133, 4388, 5592
19010, 4190, 5221, 4504, 5297
19011, 992, 4980, 5454, 6021
19012, 1102, 1101, 5163, 5401
19013, 4385, 4035, 5018, 5288
19014, 4589, 5463, 2342, 5795
19015, 1313, 4997, 1418, 5478
19016, 4125, 5098, 4919, 6115
19017, 3728, 3729, 3725, 4448
19018, 4606, 4004, 5173, 5308
19019, 1397, 1327, 5556, 5637
19020, 2935, 2163, 3116, 4618
19021, 4385, 4320, 5557, 5852
19022, 3777, 3772, 5094, 5286
19023, 4564, 5089, 4082, 6208
19024, 1395, 923, 3682, 4939
19025, 4218, 4883, 3917, 5042
19026, 4729, 5731, 4152, 5933
19027, 4239, 5306, 4060, 5498
19028, 4796, 5680, 5605, 5845
19029, 4680, 5018, 3975, 5753
19030, 4310, 3971, 5325, 5470
19031, 772, 1131, 1305, 5458
19032, 2238, 3075, 2197, 5004
19033, 4266, 5215, 4815, 6013
19034, 4513, 5235, 3968, 5423
19035, 3966, 4863, 5135, 6162
19036, 3115, 5134, 3220, 5524
19037, 2531, 2321, 2868, 6173
19038, 718, 1016, 411, 5809
19039, 4194, 5020, 4868, 5304
19040, 3911, 4668, 4327, 5229
19041, 4233, 5612, 1290, 6122
19042, 3372, 3371, 4641, 5266
19043, 2297, 2329, 2323, 4838
19044, 4032, 4668, 5229, 6028
19045, 4272, 3986, 5179, 6006
19046, 4245, 4916, 3973, 5193
19047, 595, 602, 5091, 5367
19048, 593, 5354, 4379, 6051
19049, 2855, 2960, 4633, 5086
19050, 975, 524, 4697, 5460
19051, 3306, 4604, 3402, 4884
19052, 950, 1266, 4568, 5697
19053, 3950, 4868, 4662, 5083
19054, 4861, 5178, 4683, 6194
19055, 4876, 5924, 4497, 6158
19056, 478, 523, 524, 5460
19057, 4386, 3993, 4641, 5593
19058, 4282, 4785, 3900, 5150
19059, 495, 4533, 461, 5967
19060, 4468, 4851, 4685, 6050
19061, 3641, 5834, 4228, 5987
19062, 4142, 5185, 5029, 5322
19063, 4258, 5207, 3989, 5579
19064, 4285, 4063, 4886, 6061
19065, 3849, 5582, 3890, 5684
19066, 416, 419, 417, 4425
19067, 4366, 5234, 4966, 6094
19068, 3904, 5169, 4283, 5409
19069, 406, 4660, 5210, 5277
19070, 3987, 4446, 4779, 4923
19071, 4444, 4291, 5338, 5845
19072, 3915, 4987, 4975, 5963
19073, 4665, 5532, 4288, 5617
19074, 4105, 5376, 4669, 5679
19075, 1219, 494, 1160, 4523
19076, 4029, 5019, 4541, 6225
19077, 4342, 4746, 3942, 6203
19078, 1227, 1059, 1061, 4687
19079, 4764, 5366, 1063, 5642
19080, 1114, 5185, 5072, 5874
19081, 732, 4322, 733, 5650
19082, 3612, 3610, 3611, 4928
19083, 2627, 4242, 2690, 5995
19084, 5022, 5032, 4073, 5538
19085, 4413, 5723, 1334, 6035
19086, 1390, 1328, 1082, 4410
19087, 4668, 4032, 5472, 6028
19088, 4441, 1063, 5366, 5642
19089, 3990, 4486, 5400, 5582
19090, 3311, 3434, 4443, 5646
19091, 3965, 4596, 5160, 5578
19092, 2799, 2786, 3083, 5490
19093, 2200, 2911, 4802, 5585
19094, 4246, 4820, 4050, 5420
19095, 4623, 5235, 4148, 5792
19096, 2961, 2332, 2945, 5833
19097, 4930, 5274, 4301, 5655
19098, 4301, 4760, 3937, 4930
19099, 4296, 5038, 4893, 5972
19100, 2582, 4623, 5377, 5792
19101, 5070, 5449, 4634, 6213
19102, 4042, 4544, 4877, 5333
19103, 4522, 4009, 5694, 6144
19104, 3904, 4417, 4579, 6101
19105, 4838, 5239, 4237, 5363
19106, 3977, 5546, 4714, 6196
19107, 1000, 5794, 998, 5923
19108, 1137, 4309, 856, 5831
19109, 2223, 2221, 2224, 4411
19110, 2286, 2288, 2287, 5300
19111, 786, 4714, 1302, 6196
19112, 5275, 5951, 2844, 5983
19113, 4215, 4847, 4702, 5687
19114, 679, 678, 611, 4570
19115, 936, 937, 4475, 5614
19116, 718, 411, 4584, 5809
19117, 3998, 5033, 4598, 5926
19118, 3915, 4761, 4465, 4987
19119, 3611, 4928, 3610, 6209
19120, 3922, 4813, 4795, 5744
19121, 4231, 5241, 4595, 6053
19122, 990, 5196, 969, 5625
19123, 3962, 4259, 5488, 6149
19124, 349, 3606, 4539, 5117
19125, 3989, 4733, 4303, 4949
19126, 4808, 5202, 3916, 5465
19127, 3973, 4390, 4920, 5108
19128, 311, 934, 877, 4956
19129, 2134, 4391, 2762, 5685
19130, 4098, 5067, 5269, 6220
19131, 1066, 519, 729, 5850
19132, 2498, 2867, 2795, 4591
19133, 2588, 3020, 3104, 4926
19134, 4025, 4350, 5343, 5628
19135, 2405, 5221, 5990, 6178
19136, 4421, 5092, 4045, 5283
19137, 3040, 2633, 2751, 4843
19138, 3220, 2624, 4415, 5905
19139, 4955, 5330, 4426, 5689
19140, 2775, 4439, 5071, 5151
19141, 435, 4267, 5475, 6071
19142, 2217, 4440, 5374, 5950
19143, 4233, 5214, 4452, 6130
19144, 495, 4533, 5146, 5964
19145, 4101, 5717, 4245, 6079
19146, 4865, 4941, 4280, 5068
19147, 4477, 5132, 4626, 5335
19148, 4083, 5104, 4472, 5638
19149, 700, 630, 627, 4879
19150, 1110, 5540, 396, 5787
19151, 3242, 4312, 5021, 5934
19152, 2963, 2449, 2800, 5944
19153, 832, 4390, 4861, 5623
19154, 4320, 814, 4915, 5852
19155, 3285, 4475, 5528, 6192
19156, 667, 4924, 1078, 5597
19157, 4183, 5662, 5688, 5720
19158, 4470, 4742, 4644, 6097
19159, 3963, 4354, 5683, 6234
19160, 4058, 5307, 4414, 5744
19161, 4296, 5461, 4870, 5972
19162, 4417, 4236, 5194, 5208
19163, 2853, 4633, 2960, 5748
19164, 4343, 4120, 5126, 5504
19165, 3193, 2733, 2714, 4384
19166, 2502, 2503, 2755, 5407
19167, 4217, 5110, 4995, 5170
19168, 4287, 4895, 4694, 5641
19169, 4421, 5035, 4045, 5092
19170, 3958, 4742, 5009, 5786
19171, 3119, 4579, 2684, 5326
19172, 4604, 4007, 5798, 5921
19173, 1152, 4432, 617, 5244
19174, 4584, 4833, 3938, 5489
19175, 4543, 5164, 4498, 5778
19176, 2253, 5346, 4567, 5517
19177, 2826, 5521, 4519, 5587
19178, 1153, 5693, 4369, 5914
19179, 2314, 2315, 2313, 5075
19180, 4328, 4856, 4624, 4879
19181, 4926, 5799, 5309, 5942
19182, 4213, 4840, 4520, 5575
19183, 3550, 4890, 3548, 5220
19184, 3976, 4618, 5225, 6094
19185, 2313, 5075, 2315, 5678
19186, 744, 5153, 4345, 5826
19187, 4045, 5092, 4470, 5283
19188, 848, 4294, 5589, 5881
19189, 4158, 4376, 4798, 5692
19190, 1418, 892, 822, 4491
19191, 4483, 5932, 3933, 6212
19192, 4200, 5048, 5026, 6121
19193, 941, 1251, 942, 4791
19194, 3993, 4345, 5580, 5593
19195, 3103, 4508, 3165, 5639
19196, 4202, 4791, 4418, 5808
19197, 4527, 5526, 2634, 5883
19198, 4677, 5505, 4129, 5830
19199, 3969, 4345, 5826, 5979
19200, 4634, 5070, 4315, 5449
19201, 4435, 5297, 4504, 5668
19202, 3082, 4543, 5107, 5351
19203, 4039, 4527, 4916, 5682
19204, 4995, 5110, 4055, 5170
19205, 444, 432, 4678, 5307
19206, 1245, 5530, 4343, 5633
19207, 4008, 4464, 5049, 5781
19208, 4504, 5297, 4435, 5878
19209, 2360, 4874, 4393, 5756
19210, 706, 1189, 4647, 5733
19211, 4303, 4646, 4637, 6222
19212, 3903, 5036, 4340, 5762
19213, 4013, 4672, 4320, 5058
19214, 3904, 5208, 4722, 6101
19215, 809, 1413, 1315, 5204
19216, 1195, 4470, 5092, 5533
19217, 2382, 2452, 4536, 5378
19218, 4981, 4581, 5676, 6049
19219, 4209, 4871, 4771, 5313
19220, 1069, 683, 639, 5459
19221, 1287, 4452, 445, 5305
19222, 703, 693, 4806, 5547
19223, 3904, 4579, 5420, 6101
19224, 792, 743, 957, 4927
19225, 3936, 6063, 5019, 6228
19226, 4634, 5606, 5070, 6213
19227, 4351, 5198, 4403, 5332
19228, 4074, 5060, 4895, 5641
19229, 4446, 4893, 4296, 4924
19230, 1185, 635, 1129, 6126
19231, 3797, 3795, 4752, 5038
19232, 3964, 4550, 4918, 5306
19233, 3073, 4919, 5240, 6024
19234, 4705, 6044, 4676, 6128
19235, 3511, 3481, 3348, 5385
19236, 4174, 4855, 5050, 5974
19237, 4058, 4374, 5152, 5559
19238, 3550, 5112, 4890, 5220
19239, 4441, 4687, 4098, 5366
19240, 2314, 5075, 2312, 5933
19241, 2623, 2533, 6028, 6154
19242, 4141, 4780, 4311, 5481
19243, 4021, 4427, 4783, 6156
19244, 957, 958, 789, 4554
19245, 3701, 3889, 5685, 6100
19246, 2392, 2337, 2979, 5810
19247, 4046, 5532, 4587, 5861
19248, 4327, 4405, 5651, 5683
19249, 963, 5167, 4530, 5317
19250, 4030, 5168, 4429, 5348
19251, 4384, 5016, 3368, 6120
19252, 4022, 4629, 4379, 5091
19253, 4620, 4035, 5288, 5842
19254, 4441, 5366, 4764, 5642
19255, 3930, 4377, 4901, 5152
19256, 912, 304, 931, 4436
19257, 3539, 3564, 4521, 5261
19258, 2215, 2217, 4440, 5983
19259, 2886, 2884, 3192, 4433
19260, 1066, 4260, 5840, 5850
19261, 4140, 4841, 5726, 6228
19262, 4232, 4971, 4030, 5242
19263, 4578, 5072, 1115, 6070
19264, 4381, 5320, 5183, 5960
19265, 4070, 4241, 5051, 5502
19266, 3238, 3276, 4349, 5452
19267, 2202, 4565, 2201, 5499
19268, 4360, 5492, 1192, 6193
19269, 1171, 4728, 1070, 4781
19270, 4612, 5097, 4201, 5835
19271, 4501, 5162, 4705, 5848
19272, 845, 5383, 4628, 5939
19273, 4865, 4941, 4165, 5991
19274, 1022, 1229, 5573, 5789
19275, 4184, 4744, 5181, 6138
19276, 4180, 4867, 4369, 5386
19277, 4440, 5253, 5489, 6161
19278, 3969, 4555, 4741, 5826
19279, 2776, 3135, 4546, 5071
19280, 3166, 5792, 4492, 6074
19281, 4109, 4896, 4613, 5259
19282, 4331, 5079, 4790, 5211
19283, 4365, 4576, 4001, 5104
19284, 4627, 5300, 3023, 6198
19285, 1072, 4467, 904, 5844
19286, 4151, 5439, 5182, 6071
19287, 3892, 3871, 6052, 6216
19288, 3950, 4662, 4918, 5170
19289, 1339, 864, 338, 5233
19290, 4331, 5211, 869, 6210
19291, 4391, 5166, 5284, 6157
19292, 4336, 787, 5496, 5634
19293, 3964, 5161, 5306, 5847
19294, 3887, 5171, 5062, 5571
19295, 3970, 4984, 4526, 6032
19296, 4632, 5931, 4178, 6200
19297, 4121, 4905, 4315, 5839
19298, 3975, 4326, 4829, 5813
19299, 680, 612, 678, 5108
19300, 1111, 5333, 4339, 5787
19301, 1250, 4868, 856, 5304
19302, 2722, 2248, 3020, 4609
19303, 5066, 469, 5968, 6179
19304, 4245, 5717, 5201, 6079
19305, 1059, 4687, 1056, 5271
19306, 2579, 4409, 5053, 6064
19307, 3636, 4939, 3651, 6150
19308, 3665, 3648, 5178, 6194
19309, 3867, 3866, 3818, 4494
19310, 4351, 5332, 4403, 5965
19311, 2337, 4822, 4552, 6011
19312, 4192, 4276, 5192, 5913
19313, 1197, 4727, 5373, 6126
19314, 4458, 4946, 4750, 5724
19315, 3394, 3331, 3393, 5054
19316, 3969, 4555, 4810, 5522
19317, 3746, 3747, 4479, 5062
19318, 2250, 2967, 4720, 5803
19319, 3050, 4645, 3021, 4989
19320, 4040, 4382, 5631, 5745
19321, 876, 1309, 861, 5237
19322, 1120, 973, 968, 4515
19323, 2421, 2314, 2312, 5933
19324, 4342, 3942, 4913, 6203
19325, 3029, 3038, 4371, 5737
19326, 3691, 4701, 3637, 6108
19327, 3029, 4371, 3038, 5747
19328, 4316, 3527, 5112, 6177
19329, 3989, 5198, 4303, 5904
19330, 4134, 5559, 4795, 5744
19331, 1332, 1072, 5844, 5976
19332, 4275, 3926, 4891, 5481
19333, 4239, 4868, 4309, 5831
19334, 941, 870, 868, 5211
19335, 3859, 3788, 5370, 5550
19336, 2840, 5218, 3076, 5731
19337, 4367, 5327, 4710, 5968
19338, 887, 4583, 5354, 5896
19339, 2382, 2970, 2380, 4536
19340, 4276, 3964, 5192, 5913
19341, 3996, 4862, 4407, 5255
19342, 4620, 4898, 4073, 5865
19343, 3863, 3800, 3803, 4870
19344, 1260, 1007, 5051, 6009
19345, 1166, 4699, 994, 5710
19346, 3997, 4871, 4730, 5825
19347, 884, 5614, 5732, 5772
19348, 3990, 4811, 4806, 5547
19349, 3134, 2493, 4489, 4934
19350, 4701, 5430, 4762, 5987
19351, 4262, 4788, 4285, 5549
19352, 5142, 5756, 4099, 5846
19353, 4677, 5688, 4203, 5808
19354, 3980, 4295, 4750, 6034
19355, 803, 5131, 4221, 6202
19356, 423, 4961, 4599, 6065
19357, 4511, 4808, 3916, 5465
19358, 1206, 750, 1196, 5092
19359, 2768, 2135, 3720, 5136
19360, 4556, 5022, 4990, 6014
19361, 2496, 5189, 4762, 5411
19362, 4391, 5685, 5166, 6157
19363, 2970, 2380, 4536, 5362
19364, 4311, 4718, 4100, 5473
19365, 4836, 5068, 4176, 5892
19366, 1241, 563, 603, 5399
19367, 4215, 4702, 5636, 5880
19368, 3972, 4777, 4577, 5895
19369, 3954, 5073, 4268, 5830
19370, 2826, 4519, 2984, 5587
19371, 1138, 793, 508, 5289
19372, 4266, 3984, 5610, 6007
19373, 1332, 5771, 4482, 5844
19374, 5157, 5253, 4204, 5525
19375, 4017, 5270, 5119, 5887
19376, 4178, 4735, 4632, 5507
19377, 563, 5545, 565, 5757
19378, 2601, 4588, 2780, 5920
19379, 4248, 5303, 4860, 5876
19380, 4208, 5378, 4258, 5918
19381, 859, 5149, 4313, 5588
19382, 3358, 3355, 3357, 4905
19383, 2846, 2803, 3078, 4755
19384, 4211, 5307, 5127, 5744
19385, 2981, 4514, 2907, 6198
19386, 3963, 4327, 5229, 5683
19387, 4010, 5223, 4403, 6167
19388, 2610, 4769, 2495, 5431
19389, 3689, 349, 3606, 4539
19390, 2667, 5620, 4348, 6123
19391, 4349, 875, 5149, 5656
19392, 2867, 4591, 2498, 5601
19393, 4144, 4979, 4263, 5471
19394, 3905, 4646, 4818, 5534
19395, 3921, 5124, 4691, 6200
19396, 4342, 4019, 4984, 5429
19397, 1033, 4961, 423, 6065
19398, 4394, 5510, 3988, 5802
19399, 4158, 4798, 4376, 5703
19400, 1193, 4993, 355, 6197
19401, 4050, 5420, 4314, 5889
19402, 4146, 4768, 5539, 5657
19403, 4701, 4939, 4291, 5430
19404, 2469, 5579, 4403, 6119
19405, 4641, 5222, 4384, 5654
19406, 4794, 5033, 3980, 5909
19407, 4221, 5405, 5576, 6202
19408, 4174, 5050, 4792, 5974
19409, 3089, 2247, 3091, 4664
19410, 4400, 5209, 4753, 6207
19411, 4959, 5170, 4217, 5761
19412, 4465, 4935, 4132, 6012
19413, 2474, 4881, 2472, 4950
19414, 4284, 5068, 4836, 5892
19415, 1052, 4587, 1053, 5768
19416, 4590, 5862, 4684, 6201
19417, 945, 946, 1397, 5567
19418, 2905, 5115, 2842, 5719
19419, 2178, 4850, 4517, 6080
19420, 4368, 4704, 3983, 5811
19421, 4460, 3981, 4952, 5878
19422, 3439, 3443, 3427, 4886
19423, 2246, 2253, 4567, 5517
19424, 3520, 4473, 3585, 5001
19425, 973, 4515, 1120, 5711
19426, 4551, 5443, 5407, 6199
19427, 4459, 4816, 4070, 5319
19428, 3911, 5139, 4260, 5925
19429, 3244, 4830, 3243, 5934
19430, 2469, 3011, 5579, 6119
19431, 4005, 5117, 5105, 6055
19432, 4404, 5222, 4026, 5491
19433, 1357, 4332, 840, 6027
19434, 3956, 6098, 4990, 6185
19435, 2397, 5087, 4304, 5851
19436, 800, 4274, 5002, 5623
19437, 1088, 4454, 4897, 5650
19438, 4053, 4655, 4451, 4933
19439, 2202, 2203, 2201, 4565
19440, 4029, 4524, 4610, 6093
19441, 933, 302, 3310, 4681
19442, 3743, 3887, 5062, 5571
19443, 4336, 4773, 4212, 5496
19444, 2741, 4225, 5755, 5959
19445, 4497, 4216, 5514, 5863
19446, 504, 4649, 1123, 4922
19447, 4252, 5009, 3958, 5515
19448, 4380, 4833, 4594, 5609
19449, 1179, 735, 1173, 5903
19450, 4324, 5092, 4421, 5283
19451, 4156, 5848, 5479, 6044
19452, 4010, 4924, 4893, 6167
19453, 5165, 5450, 4131, 5779
19454, 1200, 819, 4768, 5049
19455, 4027, 4985, 4558, 5643
19456, 3250, 5375, 4312, 5934
19457, 3457, 2124, 3321, 5357
19458, 4335, 5026, 4200, 5216
19459, 2579, 2664, 4409, 6064
19460, 2837, 4301, 5353, 5863
19461, 4696, 5463, 4252, 6089
19462, 4435, 5114, 2671, 5668
19463, 4366, 5015, 4558, 5100
19464, 4086, 4363, 4983, 5857
19465, 456, 5072, 4458, 5635
19466, 3860, 3790, 5260, 5370
19467, 4699, 5289, 793, 5405
19468, 1115, 4578, 1114, 5072
19469, 4257, 5136, 4424, 6221
19470, 2585, 5334, 4623, 5397
19471, 4493, 4783, 3910, 5419
19472, 2357, 5191, 5996, 6105
19473, 1244, 5257, 807, 5495
19474, 3925, 4678, 4901, 5127
19475, 1108, 4468, 1107, 5381
19476, 3292, 3275, 4831, 6170
19477, 543, 4673, 1188, 5412
19478, 3924, 5433, 4616, 6107
19479, 931, 4436, 304, 5365
19480, 3924, 4404, 5433, 6107
19481, 4291, 6053, 3992, 6055
19482, 1066, 5124, 520, 5840
19483, 2830, 5312, 4451, 5626
19484, 4107, 5158, 4650, 5728
19485, 4350, 4614, 4025, 5343
19486, 2266, 5148, 4438, 5911
19487, 4098, 5067, 4673, 5412
19488, 2849, 3073, 2850, 5240
19489, 3923, 4533, 4695, 5553
19490, 897, 896, 895, 5556
19491, 2738, 2739, 4417, 5669
19492, 3736, 3738, 3882, 4469
19493, 1174, 502, 4662, 5446
19494, 2583, 4623, 2585, 5334
19495, 1001, 1000, 998, 5923
19496, 2604, 4737, 3041, 5238
19497, 4676, 2344, 5622, 6133
19498, 2840, 2415, 3034, 5218
19499, 3306, 3403, 2127, 4884
19500, 3908, 4716, 4360, 4936
19501, 3021, 4645, 2296, 6206
19502, 416, 4425, 417, 5525
19503, 5047, 5279, 4293, 5319
19504, 2429, 4786, 2328, 5560
19505, 4460, 4824, 3981, 5878
19506, 4694, 5143, 4287, 5641
19507, 2825, 2834, 2959, 4451
19508, 2299, 4865, 2293, 6113
19509, 4089, 6173, 5678, 6205
19510, 4025, 4614, 5301, 6212
19511, 4546, 5071, 3135, 5851
19512, 4291, 5105, 5117, 6055
19513, 2251, 2538, 2243, 5957
19514, 3130, 3192, 2884, 5763
19515, 4600, 5932, 5013, 6212
19516, 1254, 430, 4577, 5752
19517, 730, 733, 732, 5710
19518, 2252, 5707, 4737, 5803
19519, 2717, 4648, 4386, 5266
19520, 3394, 3331, 5054, 5651
19521, 1067, 5063, 4784, 6229
19522, 5577, 5766, 4033, 6182
19523, 871, 4956, 877, 5477
19524, 4059, 5624, 4494, 5704
19525, 4541, 5440, 977, 5686
19526, 2420, 2869, 4669, 5679
19527, 3993, 4835, 5145, 5580
19528, 3718, 3882, 3842, 4775
19529, 3065, 2232, 4703, 5729
19530, 4600, 5621, 4112, 6174
19531, 3876, 2768, 3720, 5136
19532, 3953, 5425, 4799, 6169
19533, 3832, 3834, 3837, 5715
19534, 2435, 2982, 2461, 5705
19535, 1167, 623, 694, 5338
19536, 2935, 5106, 2168, 5615
19537, 495, 5146, 527, 5964
19538, 4868, 5020, 4309, 5304
19539, 2201, 5499, 4565, 5648
19540, 3091, 4664, 2247, 6022
19541, 363, 362, 4967, 5935
19542, 4122, 5615, 5512, 5928
19543, 4542, 4219, 5291, 5595
19544, 1391, 5580, 5843, 6224
19545, 707, 660, 1116, 6070
19546, 4087, 5202, 4808, 5465
19547, 4890, 5112, 3527, 6177
19548, 751, 4421, 752, 5564
19549, 349, 1372, 1301, 4539
19550, 2270, 2272, 2271, 5640
19551, 4064, 5164, 4543, 5778
19552, 2294, 2352, 2328, 4426
19553, 1145, 975, 524, 4697
19554, 3477, 4548, 1335, 5426
19555, 2179, 4481, 4850, 6080
19556, 4209, 4473, 4871, 5313
19557, 4127, 5072, 4578, 6070
19558, 4056, 5186, 5114, 6039
19559, 1038, 4692, 1232, 5997
19560, 4003, 5749, 4876, 5924
19561, 4056, 4462, 5186, 6039
19562, 4860, 5303, 4085, 5876
19563, 377, 5185, 376, 5612
19564, 4465, 4987, 4731, 6176
19565, 3970, 4903, 4855, 6032
19566, 4246, 4848, 4062, 5420
19567, 1147, 735, 5163, 5307
19568, 3921, 4982, 4416, 5555
19569, 4036, 4447, 5024, 5245
19570, 4170, 4271, 4965, 5456
19571, 4781, 4793, 4033, 5459
19572, 3534, 4606, 3532, 5248
19573, 3411, 4522, 3408, 5336
19574, 2108, 2687, 5294, 6038
19575, 2244, 2253, 2956, 4798
19576, 3940, 5174, 4757, 5448
19577, 2492, 2544, 2543, 6147
19578, 3985, 4317, 4858, 5352
19579, 4178, 5124, 4632, 6200
19580, 2217, 5374, 2216, 5950
19581, 4307, 4945, 3958, 4965
19582, 1251, 603, 565, 5757
19583, 2828, 2843, 4983, 5521
19584, 2931, 5487, 2390, 6054
19585, 473, 4644, 475, 5501
19586, 4511, 4970, 4808, 5465
19587, 4830, 5608, 3978, 5988
19588, 1157, 4805, 1019, 5809
19589, 3401, 3402, 3306, 4604
19590, 5432, 5788, 2419, 6207
19591, 1291, 770, 1348, 4474
19592, 3027, 3098, 4619, 5135
19593, 2125, 3194, 5834, 5987
19594, 4045, 5009, 4742, 5786
19595, 333, 3703, 3827, 5061
19596, 3908, 4480, 4588, 5793
19597, 3222, 4831, 5375, 5869
19598, 399, 4757, 398, 5506
19599, 3949, 5030, 4355, 5918
19600, 3096, 4788, 4285, 5984
19601, 3836, 3717, 3802, 5711
19602, 5671, 6129, 4253, 6181
19603, 2964, 4537, 5937, 6142
19604, 376, 5185, 4690, 5612
19605, 2299, 4642, 2389, 5487
19606, 3384, 4490, 5368, 6061
19607, 2882, 2883, 4303, 6222
19608, 3909, 4758, 4398, 6156
19609, 3874, 4615, 2136, 6146
19610, 3445, 3377, 5654, 5843
19611, 4243, 5288, 5018, 6135
19612, 4532, 4985, 4027, 5643
19613, 3332, 4820, 3337, 5147
19614, 4090, 5261, 4521, 5577
19615, 740, 614, 643, 5673
19616, 4148, 5377, 4420, 6106
19617, 2433, 2497, 2436, 4450
19618, 4006, 4878, 4621, 5391
19619, 4538, 5694, 2926, 5905
19620, 4081, 4710, 5271, 6134
19621, 2369, 4528, 3058, 5688
19622, 4552, 5159, 4153, 5931
19623, 3963, 5229, 4669, 5376
19624, 4666, 6128, 4676, 6133
19625, 4097, 5239, 4838, 5363
19626, 2443, 2244, 4798, 5568
19627, 4529, 4221, 5131, 6202
19628, 3964, 4575, 4550, 5306
19629, 3056, 5663, 2232, 5729
19630, 4458, 5072, 4127, 5635
19631, 4019, 4342, 4984, 5085
19632, 3633, 5105, 4291, 5430
19633, 3649, 4929, 3647, 5526
19634, 2884, 4433, 2886, 5332
19635, 4159, 5805, 5349, 6041
19636, 1128, 1114, 1115, 4578
19637, 3244, 5237, 4830, 5934
19638, 802, 734, 992, 6021
19639, 2256, 4959, 4720, 5622
19640, 3984, 4910, 4574, 6149
19641, 2316, 2530, 2920, 5678
19642, 3738, 3842, 3882, 5572
19643, 808, 1135, 4486, 5043
19644, 4323, 5145, 4835, 5580
19645, 4515, 4779, 3987, 5461
19646, 4341, 4948, 4557, 5503
19647, 4113, 4751, 4274, 5421
19648, 3131, 5173, 3200, 5308
19649, 2740, 5036, 3030, 6174
19650, 823, 739, 4939, 5338
19651, 4592, 4710, 4192, 5039
19652, 1233, 4977, 1029, 5519
19653, 4148, 5235, 4623, 6106
19654, 1024, 5265, 1182, 5493
19655, 3254, 3299, 5116, 5531
19656, 5325, 5470, 3971, 5927
19657, 4170, 4271, 5456, 5748
19658, 2203, 2201, 4565, 5648
19659, 4101, 4585, 5201, 6079
19660, 3495, 5598, 4508, 5639
19661, 445, 1287, 1289, 4452
19662, 807, 1244, 1211, 5257
19663, 2580, 2470, 2579, 5053
19664, 4422, 5580, 4345, 5593
19665, 4194, 5020, 5304, 5952
19666, 3103, 3487, 3562, 5639
19667, 4685, 5828, 4414, 5903
19668, 4239, 4060, 5306, 5398
19669, 4656, 4811, 837, 6217
19670, 1241, 4829, 563, 5399
19671, 3047, 5622, 4273, 6044
19672, 5013, 5685, 2651, 5879
19673, 5397, 5792, 2612, 6074
19674, 3899, 4686, 4445, 5890
19675, 3166, 2612, 5792, 6074
19676, 2342, 4589, 2338, 5463
19677, 2173, 2171, 2172, 5230
19678, 3759, 3758, 3892, 5583
19679, 4044, 4644, 4367, 5501
19680, 389, 4431, 1279, 5359
19681, 4303, 3989, 4949, 5198
19682, 2647, 3218, 2645, 5026
19683, 4666, 4676, 4245, 5193
19684, 897, 895, 4997, 5556
19685, 3050, 3021, 3001, 4989
19686, 4036, 5372, 5396, 6184
19687, 3039, 5853, 5249, 5977
19688, 668, 4801, 4444, 5605
19689, 4025, 5166, 4814, 6157
19690, 3076, 5218, 4729, 5731
19691, 2755, 4344, 5407, 6170
19692, 4098, 5278, 4549, 5281
19693, 4295, 5033, 3998, 6034
19694, 2403, 4935, 4465, 6176
19695, 302, 3419, 4681, 5141
19696, 4561, 4743, 4271, 5817
19697, 977, 5440, 4541, 6225
19698, 2763, 4907, 4370, 6117
19699, 4529, 5007, 4009, 6118
19700, 2173, 5230, 4477, 6022
19701, 2209, 4746, 2208, 5609
19702, 419, 4425, 416, 5709
19703, 4596, 5032, 3965, 5538
19704, 3362, 4940, 4510, 5995
19705, 761, 5365, 4323, 6224
19706, 2231, 4377, 5184, 5699
19707, 1185, 1197, 4427, 6126
19708, 901, 904, 903, 5844
19709, 4162, 5027, 4761, 5963
19710, 4398, 5219, 4021, 5280
19711, 3393, 5054, 3331, 5651
19712, 4470, 4644, 4044, 6097
19713, 4588, 5028, 4916, 5920
19714, 2459, 2875, 3096, 4788
19715, 4507, 4771, 3907, 5280
19716, 4722, 5208, 4417, 6101
19717, 4306, 5170, 4995, 5446
19718, 578, 1168, 580, 5718
19719, 642, 1196, 649, 5092
19720, 642, 4602, 605, 5533
19721, 4452, 445, 5305, 5342
19722, 4249, 4938, 4832, 5180
19723, 4078, 4209, 5264, 5402
19724, 2808, 5846, 4381, 5960
19725, 4237, 5239, 3923, 5553
19726, 892, 1418, 1313, 4491
19727, 4155, 4343, 5530, 6211
19728, 738, 818, 739, 4595
19729, 4071, 4649, 4622, 5864
19730, 947, 1383, 944, 5458
19731, 4284, 4941, 4836, 5068
19732, 2124, 3321, 5357, 5524
19733, 3904, 4722, 4417, 6101
19734, 3871, 5041, 3870, 6052
19735, 4750, 4946, 4177, 5724
19736, 2219, 5863, 5514, 5951
19737, 2241, 4466, 2187, 5351
19738, 399, 398, 397, 5506
19739, 4816, 5279, 4070, 5319
19740, 462, 495, 461, 5967
19741, 4023, 5112, 5345, 6020
19742, 2250, 5803, 4720, 6168
19743, 2157, 5023, 2156, 5949
19744, 3360, 2113, 3330, 4827
19745, 4753, 5209, 4186, 6207
19746, 2754, 2756, 4837, 5267
19747, 1259, 1350, 4842, 5823
19748, 1347, 822, 4491, 5339
19749, 4164, 4941, 4836, 6062
19750, 4757, 5174, 4171, 5448
19751, 2297, 2264, 2263, 4635
19752, 2264, 2263, 4635, 5346
19753, 789, 5516, 1201, 6068
19754, 4011, 4681, 4886, 5565
19755, 4019, 5085, 4984, 6032
19756, 4018, 4277, 5037, 5317
19757, 2960, 2853, 2855, 4633
19758, 2292, 2889, 2289, 5785
19759, 4482, 5771, 4488, 5844
19760, 3974, 4768, 5807, 5922
19761, 583, 4392, 581, 5380
19762, 4248, 4913, 4085, 5303
19763, 3939, 5703, 4376, 6172
19764, 808, 4806, 4486, 4811
19765, 3926, 4892, 4554, 5168
19766, 2274, 4912, 4823, 6089
19767, 2333, 4959, 2256, 5622
19768, 2450, 2505, 4769, 5431
19769, 4549, 4673, 4098, 5281
19770, 2682, 4527, 2634, 5883
19771, 3980, 5033, 4295, 6034
19772, 2972, 4455, 2475, 5379
19773, 5130, 6014, 4459, 6031
19774, 497, 491, 4836, 6096
19775, 3832, 3837, 5079, 5715
19776, 645, 4747, 564, 5545
19777, 865, 299, 930, 4428
19778, 4239, 4918, 5306, 5544
19779, 4277, 4018, 5037, 5290
19780, 3409, 5653, 4315, 5839
19781, 534, 1066, 618, 5063
19782, 1291, 4474, 1348, 5367
19783, 4881, 5318, 4227, 5854
19784, 3385, 5176, 4906, 6095
19785, 2606, 3170, 2609, 5407
19786, 4832, 4938, 4118, 5180
19787, 3948, 5215, 4266, 5498
19788, 3226, 5732, 5340, 5998
19789, 4027, 4558, 5477, 5643
19790, 3914, 4735, 5931, 6208
19791, 4725, 5031, 852, 5831
19792, 4058, 4901, 4678, 5127
19793, 2749, 4809, 4389, 6088
19794, 1154, 5003, 5730, 6033
19795, 2992, 4368, 3120, 5428
19796, 4057, 4616, 5427, 5434
19797, 5196, 5807, 4768, 5922
19798, 1259, 629, 5823, 6175
19799, 554, 552, 4484, 5440
19800, 3033, 4280, 5731, 5991
19801, 4790, 5079, 4016, 5211
19802, 3910, 4780, 4493, 6180
19803, 1197, 5373, 4427, 6126
19804, 4342, 4913, 4565, 5476
19805, 1280, 4598, 5122, 5804
19806, 2553, 4420, 3113, 5377
19807, 3014, 2788, 5691, 6066
19808, 3027, 3098, 2235, 4619
19809, 4394, 4956, 4027, 5015
19810, 4487, 5046, 4349, 5656
19811, 3365, 3434, 3363, 5272
19812, 3943, 4988, 4518, 5529
19813, 3934, 5084, 4610, 6093
19814, 4265, 4152, 5017, 6113
19815, 4046, 5466, 4665, 5532
19816, 905, 3309, 3422, 4897
19817, 3923, 4608, 5040, 6005
19818, 4439, 3987, 4870, 5197
19819, 3755, 5818, 3756, 5827
19820, 2760, 3003, 5242, 5619
19821, 3170, 4831, 2609, 5407
19822, 707, 883, 5635, 6070
19823, 4009, 4450, 5010, 5449
19824, 4293, 5047, 4496, 5279
19825, 3511, 4582, 3512, 5385
19826, 5169, 5697, 4568, 6017
19827, 450, 4738, 1151, 5475
19828, 1369, 5171, 5571, 6027
19829, 4127, 4458, 5724, 6143
19830, 2394, 3011, 2479, 5025
19831, 4366, 4966, 4034, 5841
19832, 4052, 4663, 4375, 5551
19833, 340, 3475, 1163, 5595
19834, 487, 4727, 1087, 5259
19835, 790, 5204, 4541, 5686
19836, 2174, 5335, 2175, 6022
19837, 3839, 5447, 4395, 5897
19838, 4678, 5127, 4211, 5307
19839, 4483, 5932, 5915, 6012
19840, 2580, 2969, 2470, 5053
19841, 3120, 2900, 4704, 5811
19842, 4020, 4732, 4502, 5215
19843, 2516, 2895, 2779, 6155
19844, 4943, 5766, 4611, 6182
19845, 4253, 4067, 5145, 5979
19846, 4019, 4342, 5085, 5341
19847, 3287, 316, 3270, 5340
19848, 355, 356, 4782, 6017
19849, 1145, 1140, 847, 4697
19850, 3447, 4437, 3428, 5776
19851, 4520, 1199, 5292, 5575
19852, 355, 4993, 4782, 6197
19853, 4052, 4769, 4663, 5551
19854, 4893, 4923, 4446, 5972
19855, 902, 4449, 5759, 5989
19856, 3959, 4358, 5050, 5953
19857, 4017, 4238, 5119, 5538
19858, 4399, 5726, 4029, 6078
19859, 3047, 4273, 5622, 5803
19860, 2807, 5898, 2806, 5960
19861, 3968, 5423, 4580, 5455
19862, 728, 4698, 4553, 6139
19863, 4434, 4142, 5322, 5523
19864, 677, 1312, 1209, 4924
19865, 4375, 5009, 4252, 5992
19866, 4058, 5127, 4678, 5307
19867, 1366, 825, 767, 4689
19868, 2352, 2328, 4426, 5560
19869, 1326, 5027, 4776, 5791
19870, 4432, 4974, 5372, 6075
19871, 2653, 4815, 4502, 6013
19872, 2316, 2530, 5678, 6173
19873, 3311, 888, 3417, 5646
19874, 494, 1219, 460, 4523
19875, 371, 4622, 1285, 5342
19876, 3970, 4984, 4569, 5098
19877, 4131, 5422, 4706, 5779
19878, 4172, 4600, 4925, 5394
19879, 3991, 4841, 4300, 5241
19880, 634, 4758, 636, 5606
19881, 2883, 2884, 2882, 5332
19882, 4029, 4302, 5726, 6228
19883, 3194, 5226, 3190, 5834
19884, 1390, 1084, 4880, 5228
19885, 3128, 4581, 3150, 4998
19886, 3279, 3302, 3231, 4942
19887, 4089, 5177, 6173, 6205
19888, 4017, 5119, 4238, 6169
19889, 5018, 5288, 4035, 6135
19890, 4199, 5315, 5558, 6182
19891, 4600, 3933, 5932, 6212
19892, 4065, 4193, 5082, 5835
19893, 4769, 5551, 4052, 5629
19894, 3922, 4795, 4414, 5744
19895, 5026, 5048, 4562, 6204
19896, 4206, 5365, 891, 5797
19897, 2215, 2844, 2217, 5983
19898, 964, 4310, 5664, 6046
19899, 3889, 3737, 4318, 5572
19900, 3983, 5777, 4887, 5966
19901, 3262, 4417, 3265, 5194
19902, 299, 865, 867, 4790
19903, 4101, 4245, 4916, 6079
19904, 2956, 2264, 4798, 5346
19905, 688, 798, 685, 5816
19906, 463, 4851, 4685, 5828
19907, 4442, 3909, 5070, 5449
19908, 2453, 2402, 2403, 4935
19909, 2885, 2884, 2883, 4646
19910, 4040, 4591, 4883, 5042
19911, 4059, 5447, 4320, 5927
19912, 4304, 5581, 4709, 6223
19913, 5225, 5512, 4412, 6094
19914, 774, 5478, 4634, 5606
19915, 2106, 2693, 2691, 5016
19916, 3914, 4447, 4735, 6208
19917, 2880, 5904, 3161, 5965
19918, 3842, 5408, 4775, 5572
19919, 4743, 4945, 4271, 5817
19920, 4351, 5388, 4010, 6153
19921, 3160, 4669, 5561, 6028
19922, 642, 605, 505, 5533
19923, 3853, 3862, 5388, 6146
19924, 4699, 4808, 4087, 6026
19925, 4020, 5215, 4294, 6018
19926, 2223, 4411, 2224, 5859
19927, 743, 4554, 4927, 5500
19928, 3931, 5067, 4249, 5253
19929, 4331, 5079, 4952, 5715
19930, 4681, 5153, 1354, 5565
19931, 4231, 5102, 4360, 5241
19932, 5277, 5701, 4126, 5809
19933, 4470, 4742, 4045, 5009
19934, 4521, 5577, 4033, 6182
19935, 4017, 4556, 5270, 5898
19936, 2604, 3051, 4737, 5479
19937, 2471, 4538, 2576, 5905
19938, 3449, 3332, 3232, 5147
19939, 2988, 2639, 2505, 5431
19940, 1139, 5860, 842, 5939
19941, 1195, 1187, 795, 4470
19942, 2241, 5107, 4466, 5351
19943, 4071, 4622, 4649, 5205
19944, 4304, 4988, 3943, 5581
19945, 2219, 5514, 5374, 5951
19946, 5542, 5607, 5065, 5769
19947, 2320, 2319, 4696, 5456
19948, 4204, 5067, 4249, 5180
19949, 4306, 5761, 5170, 6219
19950, 4249, 5067, 4204, 5253
19951, 3691, 5712, 4701, 6108
19952, 4420, 5377, 5323, 6106
19953, 595, 1291, 602, 5367
19954, 2234, 4377, 5699, 5867
19955, 700, 701, 630, 4856
19956, 2553, 4420, 5377, 5629
19957, 4011, 4886, 4285, 5172
19958, 3574, 3524, 3500, 4707
19959, 4297, 4818, 4047, 5534
19960, 4392, 4924, 4471, 6167
19961, 3908, 4353, 5527, 6189
19962, 3139, 2716, 4386, 4875
19963, 4055, 4918, 4662, 5170
19964, 2993, 4736, 2794, 5238
19965, 987, 4558, 873, 5015
19966, 3967, 4290, 4994, 5687
19967, 2519, 4875, 2506, 5491
19968, 409, 408, 407, 5752
19969, 3408, 5336, 4522, 5839
19970, 4055, 4995, 5170, 5446
19971, 4865, 5068, 4280, 5731
19972, 4045, 4742, 5511, 5786
19973, 3152, 3120, 2992, 5811
19974, 2780, 4588, 2488, 5527
19975, 1240, 1125, 4550, 5398
19976, 435, 5439, 427, 5985
19977, 3079, 2421, 2977, 5933
19978, 3366, 3362, 3367, 4510
19979, 4652, 4895, 4074, 5060
19980, 2895, 2400, 4708, 5224
19981, 3036, 4416, 4982, 5774
19982, 4293, 5319, 3956, 5320
19983, 4422, 5014, 4681, 6116
19984, 853, 852, 5031, 5831
19985, 3994, 4946, 5029, 5874
19986, 4152, 5068, 4865, 5731
19987, 4124, 4856, 4328, 5257
19988, 3108, 5308, 4316, 6177
19989, 4615, 5038, 4116, 5223
19990, 2701, 4604, 3306, 4884
19991, 4273, 4156, 5093, 5479
19992, 3182, 4562, 5048, 6204
19993, 3638, 3636, 3674, 6108
19994, 5025, 4258, 5579, 6119
19995, 3990, 5256, 4811, 5547
19996, 3804, 5197, 4515, 5451
19997, 3958, 5511, 4742, 5786
19998, 3991, 5187, 4360, 5241
19999, 4554, 4909, 4108, 5345
20000, 4201, 5082, 4828, 5770
20001, 3498, 4539, 3496, 5598
20002, 3161, 5904, 5332, 5965
20003, 4227, 5318, 4826, 6054
20004, 4173, 4990, 4556, 5022
20005, 2714, 2106, 3323, 5016
20006, 3259, 5147, 3277, 5413
20007, 376, 5185, 479, 5523
20008, 4787, 5735, 4898, 6098
20009, 4744, 4958, 4268, 5645
20010, 4117, 5906, 5191, 5996
20011, 4120, 4570, 5193, 6219
20012, 4063, 5172, 4886, 5565
20013, 2938, 4668, 5472, 6028
20014, 3123, 3202, 2148, 4448
20015, 3970, 4358, 4888, 6115
20016, 2443, 5568, 4798, 5692
20017, 3044, 4559, 5356, 5871
20018, 4681, 5014, 3430, 6116
20019, 2984, 4519, 2822, 5298
20020, 3862, 4351, 5388, 6146
20021, 3292, 3228, 3275, 6170
20022, 588, 4758, 5120, 6126
20023, 4103, 5553, 5696, 6047
20024, 1031, 1229, 4894, 5573
20025, 3949, 4853, 4536, 5918
20026, 4398, 4873, 4507, 5280
20027, 3335, 2696, 3457, 5357
20028, 2182, 2258, 2184, 4800
20029, 2976, 4559, 2928, 5822
20030, 4285, 4886, 4063, 5172
20031, 4096, 5306, 4918, 5544
20032, 5275, 5302, 4760, 5951
20033, 2579, 2664, 2580, 4409
20034, 4801, 5686, 4255, 5908
20035, 4162, 4523, 4679, 4763
20036, 4176, 4270, 5017, 6096
20037, 869, 6040, 4331, 6210
20038, 4327, 5683, 4049, 6234
20039, 4351, 5332, 3074, 5765
20040, 4001, 4999, 4356, 5404
20041, 4070, 5051, 4241, 5320
20042, 3290, 3225, 341, 5237
20043, 4295, 3998, 5543, 6034
20044, 4178, 4632, 5124, 5507
20045, 4870, 5461, 4515, 5972
20046, 3983, 4500, 5777, 5966
20047, 4383, 5589, 5216, 5939
20048, 4566, 5265, 4042, 5493
20049, 3833, 3764, 4672, 4915
20050, 5183, 5320, 4293, 5960
20051, 4524, 5967, 4147, 6005
20052, 4252, 5488, 5009, 5515
20053, 4580, 5455, 4375, 5551
20054, 3905, 4818, 4297, 5534
20055, 3951, 4650, 5158, 5728
20056, 3963, 5683, 5229, 6234
20057, 3390, 4911, 4405, 5947
20058, 485, 486, 484, 5743
20059, 412, 737, 5157, 5693
20060, 731, 821, 1136, 5850
20061, 2669, 4435, 2671, 5297
20062, 4615, 5223, 2878, 5965
20063, 1292, 1293, 1030, 4977
20064, 1001, 5794, 1000, 5923
20065, 1162, 1311, 5043, 5820
20066, 3786, 3851, 3781, 5186
20067, 2495, 2551, 2451, 4769
20068, 4179, 4824, 4460, 5399
20069, 4009, 4884, 4522, 5444
20070, 3859, 3785, 3788, 5550
20071, 4635, 4695, 4154, 5346
20072, 4493, 4783, 4427, 5373
20073, 851, 853, 852, 5031
20074, 3320, 3418, 2123, 5044
20075, 4106, 5205, 4649, 5342
20076, 4236, 5998, 5116, 6038
20077, 567, 4791, 5181, 6175
20078, 1098, 1318, 1385, 6023
20079, 3921, 4982, 4499, 5188
20080, 2372, 2373, 2374, 5034
20081, 2749, 3163, 3107, 4389
20082, 4177, 5309, 4926, 5724
20083, 3944, 4346, 4719, 4995
20084, 3855, 3811, 3876, 5331
20085, 4618, 5512, 5225, 6094
20086, 3808, 4334, 3810, 5888
20087, 3104, 4926, 4609, 4973
20088, 3737, 5166, 4318, 5572
20089, 545, 4596, 596, 5160
20090, 4002, 4467, 5137, 5396
20091, 2132, 3649, 3596, 5526
20092, 796, 733, 5576, 5650
20093, 634, 635, 636, 4758
20094, 2534, 5798, 5999, 6154
20095, 3008, 2554, 4580, 5551
20096, 2707, 4378, 3162, 5651
20097, 2364, 2363, 4734, 5756
20098, 3023, 3034, 4627, 5719
20099, 710, 4603, 1218, 6196
20100, 4155, 4267, 5080, 5475
20101, 4071, 4917, 4649, 5212
20102, 2404, 2793, 5087, 5418
20103, 1139, 4383, 5860, 5939
20104, 4294, 5215, 4020, 6148
20105, 3980, 5033, 4466, 5909
20106, 4725, 3948, 5498, 6007
20107, 4466, 5033, 4084, 5909
20108, 413, 4584, 411, 5157
20109, 4750, 4973, 4466, 6034
20110, 390, 1298, 1220, 5872
20111, 4224, 5484, 4688, 5902
20112, 2711, 4490, 2129, 5176
20113, 4434, 4647, 6060, 6160
20114, 3984, 5610, 4910, 6149
20115, 4554, 5345, 4927, 5500
20116, 4321, 5552, 5088, 5707
20117, 4278, 5252, 3994, 5940
20118, 3995, 4670, 4372, 5880
20119, 4418, 5808, 5720, 6138
20120, 2404, 4408, 2792, 5418
20121, 4546, 5223, 3114, 5929
20122, 2385, 2469, 3011, 5579
20123, 1260, 4357, 1262, 6009
20124, 4148, 4420, 4819, 6106
20125, 4926, 5309, 3977, 5724
20126, 3998, 5122, 4431, 5164
20127, 1066, 534, 520, 5124
20128, 4262, 4810, 4509, 5247
20129, 3974, 4987, 4230, 5344
20130, 2364, 4734, 2365, 5142
20131, 4025, 5343, 4487, 5628
20132, 2215, 4440, 2217, 5950
20133, 952, 1315, 4793, 5204
20134, 4303, 5904, 2882, 6222
20135, 3625, 5048, 4200, 6121
20136, 3943, 4709, 5581, 6223
20137, 4360, 4936, 4595, 5241
20138, 2733, 5016, 4384, 5491
20139, 2366, 4748, 2447, 5142
20140, 4757, 4031, 5232, 5993
20141, 4533, 5146, 4524, 5967
20142, 4659, 5152, 4058, 6145
20143, 4174, 5050, 4855, 5144
20144, 4028, 5953, 5050, 6115
20145, 4572, 5113, 4143, 5140
20146, 2607, 4531, 3111, 5647
20147, 2777, 5467, 4266, 5660
20148, 2649, 5026, 4732, 6204
20149, 3909, 5200, 4826, 5745
20150, 4029, 4524, 5019, 6225
20151, 3755, 3756, 3754, 5827
20152, 4628, 5589, 845, 5939
20153, 4166, 5803, 5707, 6168
20154, 4623, 5397, 5235, 5792
20155, 4372, 5254, 4994, 6188
20156, 1061, 4441, 1063, 5366
20157, 604, 559, 4680, 5735
20158, 2452, 2782, 2783, 4631
20159, 2402, 4935, 2453, 6012
20160, 4331, 4016, 5079, 5211
20161, 952, 954, 790, 5204
20162, 4514, 4080, 5113, 5542
20163, 3224, 4417, 3262, 5326
20164, 2964, 3113, 5629, 5937
20165, 4505, 5306, 4096, 5847
20166, 4150, 5029, 4946, 5874
20167, 2817, 2814, 2816, 4919
20168, 4564, 4735, 4178, 6163
20169, 1142, 1143, 5327, 5968
20170, 4089, 5177, 5139, 6173
20171, 2629, 5474, 2767, 5704
20172, 1078, 4924, 1077, 5597
20173, 2947, 5482, 2777, 6013
20174, 4535, 4952, 4331, 5211
20175, 3976, 4366, 5841, 6094
20176, 4001, 4264, 4999, 5243
20177, 4333, 5251, 5611, 5938
20178, 4052, 4375, 5455, 5551
20179, 2752, 5410, 4722, 5468
20180, 3680, 3655, 4576, 6077
20181, 1344, 5195, 4767, 6019
20182, 3001, 2167, 2169, 4563
20183, 4071, 4937, 4520, 4947
20184, 3796, 3795, 5038, 5388
20185, 2492, 2491, 2933, 6147
20186, 4411, 5281, 5206, 5513
20187, 4232, 4971, 4438, 5403
20188, 684, 546, 1049, 4816
20189, 3867, 4494, 3818, 5704
20190, 973, 5461, 970, 5625
20191, 1200, 5049, 4768, 6236
20192, 4198, 4310, 5578, 5664
20193, 3941, 4667, 4983, 5445
20194, 2720, 4722, 2752, 5410
20195, 1388, 4539, 1363, 5117
20196, 430, 407, 1260, 5752
20197, 3120, 2900, 3187, 4704
20198, 2953, 4737, 2252, 5707
20199, 5093, 5672, 4188, 6211
20200, 808, 1405, 836, 4486
20201, 4275, 4948, 4495, 5056
20202, 4050, 4820, 4246, 5044
20203, 1297, 4942, 3231, 5528
20204, 2390, 2931, 2331, 5487
20205, 3023, 2907, 3034, 5719
20206, 382, 1194, 456, 4458
20207, 966, 3703, 333, 5061
20208, 3969, 4810, 4308, 5838
20209, 5059, 5571, 348, 6183
20210, 4628, 5383, 4163, 5939
20211, 2789, 4532, 2571, 5225
20212, 419, 4953, 4425, 5709
20213, 3993, 5222, 4641, 5654
20214, 1020, 1022, 1024, 5493
20215, 2547, 4676, 2344, 5622
20216, 924, 4472, 3591, 5638
20217, 4204, 5180, 4249, 5253
20218, 4255, 5055, 4037, 5596
20219, 5508, 5550, 4500, 5966
20220, 3665, 5178, 4861, 6194
20221, 4302, 4029, 5726, 6093
20222, 3870, 5041, 4492, 6052
20223, 4489, 4788, 3901, 5788
20224, 4038, 4639, 5910, 6141
20225, 4061, 4998, 4465, 5956
20226, 4512, 5328, 4597, 6166
20227, 3578, 4640, 3542, 5263
20228, 4893, 5038, 4116, 5972
20229, 3300, 3240, 3238, 4931
20230, 4656, 4811, 4079, 5860
20231, 2331, 2299, 2389, 5487
20232, 3917, 4883, 4591, 5042
20233, 4187, 5507, 5024, 6229
20234, 4688, 4928, 4224, 5902
20235, 3075, 2848, 3077, 5497
20236, 3701, 3889, 3737, 5685
20237, 4000, 4854, 5321, 5628
20238, 662, 4741, 664, 6076
20239, 4573, 4667, 3941, 5541
20240, 3999, 4893, 4546, 4923
20241, 4620, 5032, 4073, 5842
20242, 4029, 4608, 6093, 6228
20243, 4467, 5024, 4036, 5976
20244, 4369, 4046, 4665, 5914
20245, 612, 4570, 5537, 5658
20246, 4386, 4875, 3993, 5090
20247, 2928, 4908, 3044, 5871
20248, 3171, 5665, 3191, 5945
20249, 4416, 5069, 4272, 5774
20250, 2972, 2596, 2475, 4455
20251, 3671, 5834, 3641, 5987
20252, 2651, 5685, 4318, 6100
20253, 755, 4583, 886, 5293
20254, 3251, 4944, 3288, 6043
20255, 3680, 4576, 5104, 6124
20256, 4466, 4084, 5884, 5909
20257, 509, 4658, 510, 5369
20258, 4618, 5512, 4122, 5615
20259, 3988, 4412, 4803, 4966
20260, 4356, 4999, 2658, 5457
20261, 2640, 2639, 2641, 5945
20262, 2274, 2946, 2278, 4823
20263, 4017, 4496, 5270, 5887
20264, 1241, 604, 561, 4829
20265, 4421, 4324, 5518, 5820
20266, 4554, 4149, 5168, 5516
20267, 4710, 5327, 1143, 5968
20268, 567, 5181, 4791, 5757
20269, 1135, 3880, 3695, 5043
20270, 1173, 4724, 5903, 6171
20271, 4046, 5532, 4665, 5617
20272, 3077, 2193, 2195, 4932
20273, 1293, 747, 1296, 5285
20274, 874, 1356, 841, 4812
20275, 865, 4428, 930, 5286
20276, 4092, 5269, 4638, 6220
20277, 1247, 1126, 855, 4868
20278, 4249, 5374, 4440, 5950
20279, 3972, 5047, 4777, 5895
20280, 4039, 5178, 4683, 5682
20281, 4118, 4867, 4703, 5877
20282, 4017, 5319, 4556, 5898
20283, 3280, 3236, 3303, 4448
20284, 4322, 5414, 5118, 6030
20285, 2667, 2669, 5297, 5620
20286, 973, 4515, 5461, 5625
20287, 1105, 1040, 1103, 5401
20288, 4071, 4840, 4388, 5212
20289, 4334, 3808, 5061, 5888
20290, 4607, 5119, 4561, 5270
20291, 2252, 4737, 3051, 5803
20292, 888, 4443, 1401, 5646
20293, 400, 426, 398, 4757
20294, 3175, 3127, 2727, 4999
20295, 372, 370, 371, 5342
20296, 4767, 4818, 4396, 6003
20297, 4038, 5480, 4639, 6141
20298, 3691, 3670, 3637, 4701
20299, 4106, 4434, 5322, 5523
20300, 5299, 5440, 4541, 5686
20301, 4243, 4393, 5329, 5977
20302, 4076, 5123, 5855, 5866
20303, 928, 5049, 4775, 6190
20304, 387, 4431, 389, 5584
20305, 4227, 4826, 4382, 6054
20306, 3262, 4848, 3261, 5326
20307, 4823, 5515, 4252, 6089
20308, 2907, 2905, 2842, 5719
20309, 4168, 4528, 5720, 5783
20310, 3178, 2725, 2115, 5199
20311, 3929, 5053, 4617, 5680
20312, 3936, 5055, 4255, 5596
20313, 474, 475, 4644, 5501
20314, 3996, 5110, 4995, 5494
20315, 385, 5584, 4295, 5804
20316, 3588, 5178, 3683, 5623
20317, 3929, 4617, 4444, 5680
20318, 3128, 2572, 3150, 4581
20319, 4780, 5812, 5481, 6180
20320, 3940, 5174, 4359, 5767
20321, 1194, 456, 4458, 5635
20322, 2725, 3644, 2115, 5199
20323, 3105, 5252, 2508, 5671
20324, 3962, 4602, 4910, 5256
20325, 986, 716, 4780, 5849
20326, 4266, 5467, 2777, 6013
20327, 4320, 5470, 5325, 5927
20328, 4422, 4641, 3993, 5593
20329, 2588, 2685, 2509, 4926
20330, 3460, 3424, 3354, 4828
20331, 3993, 4323, 5145, 5222
20332, 612, 4570, 5108, 5537
20333, 4007, 5118, 5414, 6030
20334, 4160, 4538, 5134, 6029
20335, 3044, 4559, 2343, 5356
20336, 4477, 5175, 4235, 5800
20337, 4804, 4864, 4203, 4996
20338, 3853, 5388, 4615, 6146
20339, 3811, 3855, 3807, 4424
20340, 3938, 4833, 4594, 5489
20341, 4609, 4043, 5416, 6227
20342, 2515, 2575, 4457, 5619
20343, 4318, 2651, 5013, 5685
20344, 2707, 2890, 4378, 5921
20345, 4785, 5916, 4715, 6132
20346, 3393, 4405, 5054, 5651
20347, 4782, 5697, 5169, 6017
20348, 3987, 4515, 5197, 5948
20349, 4007, 4378, 4625, 5798
20350, 4026, 5222, 4404, 5916
20351, 4189, 5705, 5247, 5799
20352, 4188, 6172, 6021, 6211
20353, 3592, 3621, 3620, 5670
20354, 4062, 4848, 4246, 5147
20355, 4040, 4450, 5487, 5745
20356, 2554, 5377, 4580, 5629
20357, 4438, 4711, 4080, 5721
20358, 1280, 4598, 1281, 5122
20359, 4253, 5940, 4067, 5979
20360, 3987, 4779, 4515, 5948
20361, 4938, 4991, 4118, 5324
20362, 2819, 4655, 2959, 5483
20363, 4047, 4297, 5534, 5966
20364, 4411, 5513, 4654, 5859
20365, 2497, 4450, 2433, 5601
20366, 3948, 5031, 4725, 5831
20367, 4330, 4112, 5290, 5621
20368, 4356, 4999, 4001, 5020
20369, 4316, 4885, 4108, 5112
20370, 1132, 4388, 5212, 5592
20371, 474, 473, 475, 5501
20372, 4271, 5456, 2340, 5817
20373, 4507, 4873, 4771, 5280
20374, 4818, 5534, 4646, 5708
20375, 4151, 4901, 4678, 5182
20376, 2231, 2227, 4654, 5184
20377, 3991, 4841, 5241, 6078
20378, 4070, 5279, 5047, 5319
20379, 4119, 5515, 4823, 6089
20380, 4561, 4017, 5119, 5538
20381, 1302, 4714, 786, 5635
20382, 5629, 5937, 4420, 6142
20383, 5158, 5271, 4687, 5604
20384, 4416, 4272, 5069, 5555
20385, 4305, 5005, 4947, 5292
20386, 1246, 941, 868, 4460
20387, 4151, 4267, 5006, 5439
20388, 4270, 4808, 4699, 6026
20389, 4074, 4283, 5468, 5936
20390, 4409, 4707, 4005, 5680
20391, 2344, 4959, 2333, 5622
20392, 4038, 4536, 5362, 5882
20393, 3032, 2956, 4798, 5692
20394, 4210, 5769, 4572, 5997
20395, 4597, 5328, 3928, 5641
20396, 3676, 5104, 3659, 6194
20397, 4876, 5113, 4210, 5542
20398, 4294, 4725, 4697, 6007
20399, 2528, 2661, 2527, 4854
20400, 4147, 4533, 4695, 6005
20401, 3866, 4494, 3867, 5897
20402, 5291, 5577, 4090, 5766
20403, 4583, 5350, 3943, 5354
20404, 3135, 2772, 2792, 5071
20405, 2390, 5487, 4826, 6054
20406, 4246, 4820, 4062, 5147
20407, 4114, 4945, 4743, 5817
20408, 1133, 5100, 4388, 5592
20409, 3565, 4728, 4781, 5577
20410, 4013, 5058, 4320, 5470
20411, 2847, 5681, 4547, 5868
20412, 2530, 6173, 5177, 6205
20413, 4283, 4966, 5169, 5889
20414, 3923, 4695, 4533, 6005
20415, 4691, 4894, 4196, 5069
20416, 2638, 4423, 5431, 5945
20417, 4869, 5650, 4897, 6152
20418, 3244, 3245, 4830, 5237
20419, 5383, 5393, 4163, 5939
20420, 4079, 4954, 4910, 5273
20421, 4001, 4576, 4999, 5457
20422, 3970, 4888, 4358, 5974
20423, 3261, 3260, 3259, 4848
20424, 4093, 5610, 4574, 6149
20425, 2978, 4501, 2430, 5848
20426, 3038, 5747, 4371, 5978
20427, 2811, 5846, 2808, 5960
20428, 3103, 2151, 3165, 4508
20429, 3766, 3870, 5041, 6082
20430, 4011, 4386, 5593, 5838
20431, 3348, 3581, 3511, 4582
20432, 2283, 5721, 4711, 5911
20433, 4003, 5924, 4876, 6158
20434, 4330, 4935, 4419, 5290
20435, 2935, 2163, 4618, 5615
20436, 973, 1120, 307, 5711
20437, 2190, 2189, 2188, 5389
20438, 4100, 4718, 5403, 5473
20439, 1298, 5634, 787, 5872
20440, 2181, 4560, 3086, 6090
20441, 4572, 5769, 4749, 5997
20442, 2330, 2208, 2206, 4746
20443, 1219, 5292, 1248, 5575
20444, 1043, 4268, 5645, 5923
20445, 3810, 4334, 3808, 6190
20446, 3371, 5654, 4384, 6120
20447, 4016, 5211, 4460, 5360
20448, 4081, 5271, 5158, 5604
20449, 3513, 3515, 3493, 5125
20450, 4353, 5191, 2994, 5982
20451, 2645, 5361, 4200, 6121
20452, 471, 473, 472, 5501
20453, 3113, 4420, 2636, 5377
20454, 3954, 5073, 5034, 6138
20455, 4278, 4616, 5433, 6107
20456, 4172, 4600, 5013, 6212
20457, 884, 5614, 5340, 5732
20458, 1329, 4636, 1398, 4889
20459, 2718, 3391, 2128, 5651
20460, 1091, 3705, 3819, 4880
20461, 4092, 5552, 4654, 5859
20462, 2599, 5706, 4960, 6117
20463, 3150, 4581, 3093, 5956
20464, 3951, 4938, 5180, 5324
20465, 3931, 4713, 5067, 6220
20466, 4014, 4433, 5370, 5708
20467, 4397, 3389, 5947, 6095
20468, 1360, 5569, 820, 5650
20469, 2519, 2733, 3193, 5491
20470, 340, 4728, 3475, 5595
20471, 3760, 4537, 3754, 5827
20472, 2683, 2156, 5023, 5949
20473, 4119, 4844, 4696, 5742
20474, 4318, 4814, 5166, 6157
20475, 4098, 5278, 5281, 6220
20476, 2974, 2828, 2843, 4983
20477, 1280, 439, 4598, 5804
20478, 4099, 4792, 5142, 5974
20479, 371, 1285, 445, 5342
20480, 5123, 4214, 5328, 6166
20481, 4270, 508, 5369, 6026
20482, 2155, 2157, 2156, 5949
20483, 2443, 2244, 2956, 4798
20484, 2218, 2223, 4713, 5374
20485, 2996, 4926, 3104, 4973
20486, 500, 499, 600, 4679
20487, 4528, 5720, 4418, 5808
20488, 4937, 5754, 4840, 5891
20489, 4136, 4894, 4691, 5069
20490, 2356, 2895, 2400, 4708
20491, 3008, 2552, 2554, 5551
20492, 780, 1339, 834, 4859
20493, 2357, 2356, 2399, 4708
20494, 813, 5325, 815, 5852
20495, 4768, 5049, 4334, 5344
20496, 3901, 5172, 4788, 5231
20497, 3723, 5665, 4423, 5684
20498, 3937, 4599, 4930, 5246
20499, 3171, 2147, 2921, 5613
20500, 4032, 5229, 4669, 6028
20501, 653, 593, 1183, 5354
20502, 4605, 5055, 4590, 5862
20503, 5110, 5640, 4862, 5833
20504, 3729, 5046, 3725, 5452
20505, 2359, 5853, 3039, 5977
20506, 4772, 5112, 4108, 5722
20507, 4780, 5355, 4493, 6180
20508, 1289, 373, 445, 6122
20509, 4887, 5777, 4500, 5966
20510, 567, 1256, 4791, 6175
20511, 4002, 4490, 4906, 5213
20512, 2254, 5346, 2253, 5517
20513, 2280, 2278, 2932, 5660
20514, 3644, 3667, 2115, 5199
20515, 667, 1078, 1079, 4471
20516, 2209, 2207, 2208, 4746
20517, 4234, 5109, 5362, 5882
20518, 4216, 5246, 5206, 6161
20519, 5481, 5812, 3910, 6180
20520, 4325, 4972, 4842, 5823
20521, 3741, 3739, 3740, 4391
20522, 3990, 4486, 4806, 4811
20523, 4081, 4687, 5271, 5604
20524, 2328, 4426, 4786, 6069
20525, 2612, 2614, 5397, 6074
20526, 2998, 3008, 2597, 5551
20527, 695, 5007, 4442, 6213
20528, 4499, 5139, 4668, 6173
20529, 3673, 3611, 3605, 4928
20530, 4772, 5220, 4341, 6020
20531, 598, 622, 623, 5870
20532, 975, 5398, 1130, 5460
20533, 4552, 4822, 4153, 6011
20534, 426, 4544, 1109, 5506
20535, 5499, 5648, 2201, 6024
20536, 4014, 4351, 5198, 6153
20537, 2202, 4802, 4565, 5499
20538, 4262, 5090, 4386, 5838
20539, 4635, 4695, 3923, 6005
20540, 4526, 4919, 4125, 5098
20541, 2775, 5151, 5071, 5929
20542, 3999, 4446, 4893, 4923
20543, 4573, 5101, 5135, 6186
20544, 800, 5002, 784, 5623
20545, 4554, 5168, 4892, 5516
20546, 515, 514, 5840, 5917
20547, 4816, 5319, 4459, 6014
20548, 2836, 3079, 4729, 5469
20549, 4082, 5135, 5101, 6186
20550, 3062, 4525, 2810, 5183
20551, 4145, 4756, 4455, 6066
20552, 1143, 6134, 5968, 6179
20553, 4341, 3997, 5001, 5458
20554, 4315, 4009, 5449, 5839
20555, 4467, 4784, 4187, 6229
20556, 1379, 4781, 1315, 6151
20557, 4618, 5106, 4235, 5959
20558, 1088, 4897, 1360, 5650
20559, 3627, 3626, 3623, 5104
20560, 2741, 5755, 5175, 5959
20561, 532, 1234, 4691, 5519
20562, 2709, 4285, 2710, 5368
20563, 4349, 4000, 4931, 5452
20564, 4757, 5232, 4031, 5448
20565, 3171, 4479, 5665, 5945
20566, 296, 1364, 4672, 5233
20567, 4023, 4341, 5220, 6020
20568, 1130, 1144, 476, 4575
20569, 2155, 5949, 4593, 6164
20570, 2886, 4433, 3192, 5765
20571, 5175, 5755, 4225, 5959
20572, 4017, 4293, 5319, 5898
20573, 3980, 4560, 4878, 5909
20574, 4580, 5334, 4114, 5423
20575, 879, 4772, 872, 4927
20576, 1166, 6026, 5710, 6139
20577, 4881, 5219, 4227, 5318
20578, 2352, 5036, 4426, 5775
20579, 5034, 5662, 2370, 5688
20580, 3974, 5344, 4768, 5922
20581, 4311, 4141, 5481, 5500
20582, 4654, 5552, 4092, 6109
20583, 4718, 5403, 4143, 5973
20584, 4348, 4843, 3985, 5352
20585, 3384, 3386, 4906, 5213
20586, 1317, 882, 4857, 5528
20587, 4843, 5129, 4243, 5753
20588, 3464, 3470, 4905, 5339
20589, 4485, 5146, 4240, 5239
20590, 3216, 5437, 4640, 5862
20591, 2231, 5184, 4654, 5699
20592, 1094, 806, 1336, 4542
20593, 4710, 5968, 1143, 6134
20594, 4107, 5324, 5158, 5861
20595, 4031, 4569, 4984, 5098
20596, 3527, 4890, 3550, 5112
20597, 747, 1225, 4759, 5634
20598, 3900, 4657, 4785, 5438
20599, 795, 4742, 536, 5912
20600, 4255, 4399, 5299, 5686
20601, 2310, 5387, 4265, 6113
20602, 538, 539, 537, 5738
20603, 953, 807, 701, 5257
20604, 3992, 4595, 4936, 5241
20605, 2149, 3335, 5125, 5357
20606, 4432, 4766, 4054, 6075
20607, 3849, 4423, 5582, 5684
20608, 2294, 4426, 2328, 6069
20609, 4045, 5009, 4375, 5283
20610, 1208, 4469, 929, 5781
20611, 3164, 5418, 4731, 5956
20612, 3353, 4828, 3351, 5082
20613, 4340, 5608, 5647, 6114
20614, 696, 5405, 5007, 6202
20615, 4045, 4421, 5283, 5455
20616, 2455, 2985, 2395, 4988
20617, 4544, 5265, 4042, 5303
20618, 478, 5282, 4259, 5460
20619, 4015, 4997, 4507, 5478
20620, 1019, 4805, 1017, 5809
20621, 3050, 4989, 3122, 5627
20622, 4022, 4379, 4629, 5581
20623, 1034, 4456, 1278, 5954
20624, 4978, 5347, 466, 5446
20625, 4291, 4444, 5338, 6055
20626, 4531, 5375, 4831, 5869
20627, 3419, 3439, 4681, 5141
20628, 687, 4520, 5292, 6110
20629, 4073, 5032, 4596, 5538
20630, 3110, 2587, 4626, 5755
20631, 4897, 5569, 4869, 6152
20632, 3969, 5826, 4741, 5979
20633, 4152, 4265, 5387, 6113
20634, 4410, 4818, 4297, 6003
20635, 1018, 4566, 1092, 5701
20636, 3000, 2458, 2403, 4465
20637, 1156, 1045, 646, 4957
20638, 3148, 2727, 4576, 5457
20639, 4152, 4265, 5017, 5387
20640, 1229, 4706, 516, 4894
20641, 4121, 5070, 4905, 6029
20642, 3936, 5019, 4541, 5299
20643, 4444, 4231, 5338, 6053
20644, 4094, 4421, 5518, 5820
20645, 4599, 4961, 423, 5462
20646, 4286, 5539, 5196, 5657
20647, 4817, 5249, 4173, 5288
20648, 4399, 4841, 5726, 6078
20649, 4284, 5065, 4941, 5068
20650, 4221, 4529, 6118, 6202
20651, 2898, 4704, 2899, 5667
20652, 3984, 4294, 6007, 6018
20653, 3390, 4911, 5947, 6095
20654, 4174, 4903, 4326, 5644
20655, 792, 879, 872, 4927
20656, 552, 522, 4610, 6225
20657, 3049, 2928, 3044, 5871
20658, 4375, 4045, 5283, 5455
20659, 5968, 6134, 4710, 6179
20660, 1289, 445, 4452, 6122
20661, 4855, 4903, 4241, 6032
20662, 3972, 4525, 4777, 5047
20663, 4941, 5065, 4280, 5068
20664, 3244, 3245, 3243, 4830
20665, 2608, 2514, 5736, 5975
20666, 2507, 4789, 2563, 5491
20667, 4023, 4316, 4890, 6233
20668, 3978, 4340, 4925, 5096
20669, 4399, 5440, 5299, 5686
20670, 664, 4835, 666, 6076
20671, 2873, 5663, 4496, 5898
20672, 4110, 5419, 4881, 5962
20673, 4267, 4151, 5006, 6071
20674, 4368, 4972, 4203, 5811
20675, 719, 720, 698, 4464
20676, 396, 394, 4797, 5540
20677, 3472, 5272, 3370, 5442
20678, 4768, 5344, 4334, 5922
20679, 2466, 2465, 5671, 6129
20680, 4183, 5073, 4765, 6138
20681, 3978, 4340, 5096, 5608
20682, 2711, 2708, 4490, 5368
20683, 1181, 4796, 3480, 5426
20684, 3964, 5161, 4575, 5306
20685, 3225, 341, 5237, 5588
20686, 4066, 5397, 5334, 5630
20687, 4335, 5661, 4732, 6018
20688, 1398, 4889, 4636, 5702
20689, 2604, 2536, 2603, 5848
20690, 1109, 1110, 396, 5787
20691, 3013, 4831, 3275, 6170
20692, 3190, 3194, 2665, 5226
20693, 3530, 3555, 3529, 5112
20694, 3591, 4472, 924, 5919
20695, 4104, 5305, 5293, 6131
20696, 395, 4797, 4670, 6067
20697, 4273, 5479, 3047, 6044
20698, 2880, 2879, 4403, 5965
20699, 2149, 2696, 3335, 5357
20700, 446, 1302, 4714, 6196
20701, 2559, 2511, 4652, 5060
20702, 3442, 4449, 4911, 5759
20703, 4340, 4925, 5762, 6174
20704, 4168, 5990, 5221, 6178
20705, 3706, 3732, 3733, 5656
20706, 2522, 2521, 2500, 5932
20707, 510, 4658, 511, 5165
20708, 3973, 4920, 4390, 5682
20709, 808, 703, 4806, 4811
20710, 1357, 5571, 4332, 6027
20711, 2753, 2797, 3005, 4786
20712, 3963, 4354, 4784, 5989
20713, 2125, 3209, 3194, 5987
20714, 2651, 4318, 3010, 6100
20715, 2774, 4731, 3164, 5418
20716, 4308, 5153, 1073, 5826
20717, 2238, 4545, 2199, 6024
20718, 5119, 5270, 4607, 5887
20719, 1308, 939, 504, 4922
20720, 861, 876, 5237, 5364
20721, 2310, 2388, 2595, 4970
20722, 1328, 1390, 335, 4410
20723, 1097, 1334, 5723, 6035
20724, 1170, 673, 4493, 5355
20725, 4542, 4770, 3920, 4914
20726, 3542, 5263, 4640, 5437
20727, 4111, 4805, 4373, 4933
20728, 3988, 4993, 4394, 6197
20729, 3560, 3490, 3496, 4539
20730, 4270, 4176, 5017, 5369
20731, 4573, 4082, 5101, 6186
20732, 808, 4486, 836, 4811
20733, 640, 1101, 5981, 6145
20734, 3658, 3600, 2728, 4562
20735, 1316, 3652, 324, 5393
20736, 2877, 3114, 5223, 5929
20737, 526, 492, 459, 6016
20738, 4142, 4690, 5185, 5322
20739, 452, 453, 5307, 5828
20740, 1305, 5458, 4341, 6103
20741, 595, 655, 1291, 4629
20742, 3968, 4623, 5235, 6106
20743, 2763, 5706, 2599, 6117
20744, 3993, 4323, 5222, 5580
20745, 528, 406, 1016, 5277
20746, 939, 4922, 1308, 5836
20747, 3641, 4228, 5430, 5987
20748, 662, 4741, 660, 5826
20749, 2807, 2873, 2806, 5898
20750, 3959, 5720, 4418, 5783
20751, 4276, 5640, 5110, 5833
20752, 2760, 2591, 3003, 5619
20753, 4366, 4034, 5675, 5841
20754, 3516, 3514, 3522, 5402
20755, 2237, 5088, 2240, 5552
20756, 3074, 5332, 4351, 5965
20757, 1088, 1355, 295, 4454
20758, 4054, 5244, 4603, 5900
20759, 648, 605, 4602, 5547
20760, 4765, 5720, 4183, 6138
20761, 685, 4585, 599, 5492
20762, 2880, 4403, 5904, 5965
20763, 2724, 4929, 4480, 5199
20764, 3388, 3385, 3389, 5176
20765, 1076, 1085, 1272, 5597
20766, 2870, 4669, 3160, 6028
20767, 3036, 4982, 2315, 5774
20768, 4744, 5181, 568, 5645
20769, 4388, 5100, 1133, 5935
20770, 914, 5580, 4422, 5843
20771, 2231, 4654, 2227, 5699
20772, 3997, 4730, 4871, 5873
20773, 4183, 5720, 4765, 5953
20774, 3090, 4416, 3036, 5751
20775, 2553, 3113, 2636, 5377
20776, 4130, 5506, 4797, 5540
20777, 3340, 4820, 4674, 5713
20778, 4158, 5006, 4901, 5703
20779, 4547, 4765, 3967, 4994
20780, 3927, 4280, 5065, 5068
20781, 4981, 5529, 4191, 5581
20782, 4421, 5323, 4094, 5518
20783, 3958, 4945, 5511, 5786
20784, 3882, 3823, 3736, 4469
20785, 1240, 1125, 502, 4550
20786, 3404, 3395, 5054, 5714
20787, 3062, 4525, 5183, 5341
20788, 2429, 3005, 2328, 4786
20789, 4037, 4590, 5055, 5862
20790, 5227, 5726, 4302, 6228
20791, 4151, 4267, 5439, 6071
20792, 3103, 2146, 3487, 5639
20793, 5008, 5269, 4441, 5604
20794, 4677, 5034, 2373, 5688
20795, 3985, 4858, 4317, 5018
20796, 4512, 4786, 4076, 6069
20797, 4476, 5672, 4376, 6172
20798, 3020, 2512, 3009, 5705
20799, 1296, 1111, 1293, 5787
20800, 4015, 4491, 4997, 5478
20801, 869, 5211, 4331, 6040
20802, 588, 635, 4758, 6126
20803, 3834, 5758, 4331, 6040
20804, 2238, 3073, 2849, 5497
20805, 594, 5091, 677, 5295
20806, 2246, 2254, 2253, 5517
20807, 4440, 5951, 5275, 5983
20808, 4018, 5190, 5167, 5689
20809, 4593, 5889, 5023, 5949
20810, 4719, 4995, 4978, 5446
20811, 4063, 4285, 5172, 5231
20812, 4301, 5353, 4930, 6158
20813, 3927, 5065, 4284, 5068
20814, 4304, 4408, 4923, 5851
20815, 3937, 4301, 4930, 5274
20816, 4455, 4881, 4227, 5854
20817, 4357, 4777, 3942, 5429
20818, 2271, 5640, 4276, 5833
20819, 2307, 2444, 5992, 6057
20820, 568, 570, 4744, 5645
20821, 2277, 2320, 2319, 4696
20822, 3947, 5080, 4267, 5278
20823, 1170, 4493, 794, 5373
20824, 4030, 4754, 5348, 5619
20825, 4362, 5794, 4847, 5923
20826, 4312, 5934, 4830, 5988
20827, 2506, 2468, 5433, 6181
20828, 4508, 4005, 4707, 5598
20829, 995, 1203, 526, 5741
20830, 1251, 567, 1256, 4791
20831, 4554, 4108, 4927, 5345
20832, 4621, 5417, 1284, 6104
20833, 4134, 5127, 4567, 5867
20834, 4324, 4806, 3990, 5518
20835, 4051, 5121, 4518, 5529
20836, 4314, 6017, 4857, 6086
20837, 1138, 4613, 587, 5289
20838, 633, 5900, 4766, 6042
20839, 4085, 4363, 5587, 5876
20840, 3616, 5383, 4968, 5563
20841, 4761, 4987, 3915, 5963
20842, 4803, 4966, 4412, 5287
20843, 4459, 4898, 4073, 4990
20844, 2612, 2614, 2613, 5397
20845, 4475, 4848, 4062, 6192
20846, 4004, 4914, 4457, 5348
20847, 3874, 2136, 3719, 6146
20848, 4610, 4980, 1176, 6238
20849, 4560, 5099, 4006, 6140
20850, 1357, 1369, 5571, 6027
20851, 2416, 5509, 2445, 6207
20852, 3393, 3391, 3390, 4405
20853, 3311, 3417, 3434, 5646
20854, 1337, 4422, 914, 5580
20855, 714, 625, 699, 4801
20856, 5127, 5696, 4211, 5744
20857, 4043, 4653, 4825, 4863
20858, 3517, 3516, 3518, 5402
20859, 3116, 2742, 4618, 5225
20860, 3951, 5158, 4687, 5604
20861, 4370, 4591, 4883, 4907
20862, 1332, 1072, 904, 5844
20863, 1047, 1046, 1045, 5636
20864, 4679, 4763, 3915, 5963
20865, 732, 4869, 4322, 5650
20866, 1405, 4486, 1135, 5746
20867, 4004, 4316, 4909, 5173
20868, 4100, 4892, 4311, 5473
20869, 2481, 5356, 4264, 5871
20870, 3322, 2102, 3388, 5947
20871, 4270, 5369, 508, 6096
20872, 4052, 4375, 5283, 5455
20873, 3047, 5479, 4273, 5803
20874, 4028, 4547, 4765, 5953
20875, 3909, 4398, 5070, 5970
20876, 1137, 5031, 4309, 5831
20877, 3988, 4966, 4803, 5889
20878, 4054, 4766, 4432, 5244
20879, 950, 4568, 918, 5772
20880, 4270, 4176, 5369, 6096
20881, 4425, 4003, 4953, 5603
20882, 626, 987, 873, 5015
20883, 3921, 4416, 5069, 5555
20884, 4077, 5380, 4853, 6059
20885, 3565, 4728, 3523, 4781
20886, 862, 4796, 5426, 5605
20887, 4089, 5202, 5139, 5925
20888, 1388, 5117, 1363, 5845
20889, 582, 580, 650, 4739
20890, 1391, 5580, 717, 5843
20891, 3956, 4990, 4459, 5319
20892, 3976, 5100, 4366, 5234
20893, 2704, 4405, 3160, 5561
20894, 2441, 4838, 5363, 5886
20895, 2359, 3037, 3039, 5853
20896, 581, 667, 1403, 4904
20897, 3784, 5632, 4500, 5777
20898, 649, 750, 749, 5820
20899, 2629, 2616, 2767, 5474
20900, 4050, 5889, 4593, 5949
20901, 5332, 5904, 4403, 5965
20902, 4340, 5608, 4531, 5647
20903, 3908, 5793, 4588, 6079
20904, 2849, 4547, 2847, 5497
20905, 731, 4698, 730, 4869
20906, 2773, 3176, 2774, 4731
20907, 4037, 4684, 4590, 5862
20908, 2108, 3230, 2687, 6038
20909, 435, 5475, 4267, 5985
20910, 4001, 4999, 5404, 5457
20911, 4765, 5073, 4184, 6138
20912, 752, 4421, 5035, 5564
20913, 2522, 2500, 4483, 5932
20914, 5019, 5824, 4541, 6225
20915, 4103, 4516, 5382, 6047
20916, 2301, 2302, 4935, 5618
20917, 4636, 5248, 4219, 6045
20918, 3079, 2838, 2836, 4729
20919, 4719, 4306, 4995, 5446
20920, 4143, 4724, 4572, 6171
20921, 526, 550, 492, 5741
20922, 1394, 1200, 819, 4768
20923, 4754, 5382, 4516, 6047
20924, 3190, 3165, 4508, 5226
20925, 4519, 2822, 5298, 5980
20926, 4757, 4171, 5174, 5506
20927, 2111, 4684, 3215, 6201
20928, 4580, 4623, 3968, 5377
20929, 4069, 5062, 4332, 5484
20930, 3932, 4333, 5251, 5611
20931, 4805, 5701, 1017, 5809
20932, 4779, 4923, 4446, 5091
20933, 943, 4535, 942, 5723
20934, 1213, 5311, 938, 5961
20935, 1173, 1179, 4724, 6171
20936, 4165, 5081, 4289, 5441
20937, 4412, 5287, 4966, 6094
20938, 1019, 4805, 1018, 5701
20939, 3190, 4508, 2151, 5834
20940, 4175, 5064, 4740, 5634
20941, 1199, 1248, 5292, 5575
20942, 4101, 5201, 5717, 6079
20943, 2314, 2318, 2315, 5774
20944, 3356, 3465, 4415, 5524
20945, 4147, 5967, 5454, 6033
20946, 4609, 5389, 4043, 6227
20947, 4477, 3982, 5132, 5205
20948, 4416, 4982, 4272, 5555
20949, 2607, 2750, 2678, 4717
20950, 2399, 2400, 2424, 4708
20951, 4048, 4514, 4876, 5542
20952, 588, 4758, 634, 5120
20953, 2797, 4512, 2166, 5855
20954, 3049, 4908, 2928, 5871
20955, 4148, 4819, 4420, 5583
20956, 1354, 5153, 1294, 5565
20957, 3035, 4667, 2831, 5858
20958, 4988, 5296, 4518, 5529
20959, 415, 416, 417, 5525
20960, 4016, 5236, 4428, 5352
20961, 4187, 5063, 4784, 5376
20962, 1280, 439, 1281, 4598
20963, 4492, 5792, 5397, 6074
20964, 2352, 4426, 2294, 5775
20965, 4457, 5348, 4754, 5619
20966, 1410, 3718, 1393, 4775
20967, 3942, 4342, 4913, 5429
20968, 4249, 5067, 4713, 5978
20969, 4836, 4941, 4284, 6062
20970, 4446, 3987, 4779, 5461
20971, 4253, 5090, 3969, 5979
20972, 2506, 2468, 2507, 5433
20973, 2416, 4400, 5509, 6207
20974, 4978, 4995, 4346, 5994
20975, 1385, 5508, 4297, 6003
20976, 4174, 4326, 4903, 5813
20977, 4359, 5174, 4969, 5767
20978, 4533, 4147, 4695, 5003
20979, 4280, 4941, 4865, 5991
20980, 3868, 5704, 5057, 5897
20981, 3522, 3514, 3575, 4976
20982, 4995, 5110, 3996, 5994
20983, 4429, 4909, 4586, 5173
20984, 3903, 4426, 5036, 5330
20985, 4192, 4710, 4592, 6179
20986, 4608, 5227, 4302, 6228
20987, 4627, 5441, 4280, 5991
20988, 2410, 5300, 2284, 5721
20989, 1022, 5493, 4333, 5573
20990, 1047, 5636, 4372, 6067
20991, 5054, 5651, 4405, 5683
20992, 2097, 3399, 2701, 4604
20993, 4409, 5053, 3929, 5680
20994, 905, 3422, 326, 4897
20995, 4363, 4085, 5303, 5876
20996, 5885, 5996, 5191, 6105
20997, 3146, 4646, 2883, 6222
20998, 2263, 2951, 4635, 5382
20999, 4731, 5155, 3176, 5464
21000, 4574, 5482, 4093, 5660
21001, 2348, 2346, 4561, 5270
21002, 5110, 5913, 4192, 5994
21003, 4190, 5129, 4843, 5753
21004, 4676, 5622, 4959, 6133
21005, 4228, 4762, 5430, 5987
21006, 4613, 4896, 4109, 5631
21007, 3921, 5069, 4416, 5076
21008, 3266, 5194, 4236, 5998
21009, 4111, 5611, 4933, 5690
21010, 4267, 4764, 5278, 5985
21011, 5037, 5290, 4018, 5330
21012, 4211, 4414, 5744, 5828
21013, 4278, 3994, 5258, 5940
21014, 4627, 3935, 5441, 6125
21015, 4349, 5046, 4000, 5452
21016, 4038, 5362, 5109, 5882
21017, 4423, 3761, 5400, 5665
21018, 4348, 5094, 4494, 6123
21019, 4901, 5006, 4151, 5703
21020, 3901, 4788, 4509, 5788
21021, 3973, 4920, 4570, 5108
21022, 4131, 5422, 4456, 5600
21023, 3518, 5402, 3520, 5825
21024, 3384, 5368, 3381, 6061
21025, 1275, 437, 1276, 5794
21026, 2826, 2843, 5521, 5587
21027, 1312, 4446, 974, 5461
21028, 376, 4690, 5185, 5523
21029, 1215, 5790, 5664, 6226
21030, 2890, 3162, 2707, 4378
21031, 3096, 4285, 2709, 5984
21032, 975, 852, 854, 4725
21033, 4789, 5438, 4657, 6165
21034, 790, 715, 5204, 5686
21035, 3810, 4334, 5408, 5888
21036, 3037, 5249, 3039, 5853
21037, 3784, 3780, 5632, 5777
21038, 4502, 4732, 4020, 6204
21039, 3621, 4247, 5670, 6124
21040, 3010, 4318, 4902, 6100
21041, 4070, 5047, 4293, 5319
21042, 4590, 5055, 4605, 6155
21043, 617, 4432, 615, 5677
21044, 2300, 2299, 2293, 6113
21045, 4851, 5314, 3922, 5696
21046, 869, 1322, 6040, 6210
21047, 4151, 6071, 5730, 6172
21048, 4512, 4597, 5928, 6166
21049, 778, 668, 1167, 4444
21050, 4401, 4693, 4276, 5833
21051, 3370, 5272, 4827, 5442
21052, 871, 888, 4956, 5477
21053, 4747, 5181, 566, 5757
21054, 2674, 3107, 2107, 4890
21055, 722, 4614, 723, 5343
21056, 2234, 5699, 2442, 5867
21057, 4047, 4818, 4410, 5370
21058, 922, 1376, 818, 5421
21059, 4272, 5179, 5069, 5555
21060, 3914, 4735, 4632, 5931
21061, 617, 5358, 4432, 5677
21062, 1406, 4472, 924, 5638
21063, 4033, 5111, 4781, 5577
21064, 2887, 3719, 2136, 6146
21065, 3427, 3443, 3392, 6061
21066, 4799, 4965, 4307, 5349
21067, 4286, 5657, 5196, 5807
21068, 4345, 3993, 5090, 5593
21069, 3908, 4588, 4480, 5527
21070, 2284, 4711, 2283, 5721
21071, 4190, 5753, 5352, 5878
21072, 2418, 2419, 5788, 6207
21073, 2823, 4347, 5626, 5980
21074, 739, 4939, 4595, 6150
21075, 3270, 3285, 4475, 5528
21076, 889, 5646, 890, 5797
21077, 3752, 5043, 3754, 5582
21078, 3890, 5582, 4537, 5684
21079, 2605, 4960, 5798, 6117
21080, 3171, 4479, 2921, 5665
21081, 3909, 5219, 4398, 5970
21082, 3996, 5039, 4401, 6015
21083, 3999, 4392, 5295, 6059
21084, 3325, 3356, 3465, 4415
21085, 4676, 4959, 4072, 6133
21086, 4644, 5501, 473, 5805
21087, 4983, 5857, 2913, 6092
21088, 3779, 5186, 4413, 5777
21089, 4332, 4224, 4846, 6209
21090, 1104, 4953, 4671, 5603
21091, 983, 982, 4661, 6104
21092, 1019, 1017, 4805, 5701
21093, 2716, 2717, 4386, 5266
21094, 2164, 2166, 2797, 4512
21095, 2581, 5134, 2471, 5905
21096, 1236, 543, 1188, 5412
21097, 3231, 4942, 3302, 6192
21098, 3216, 5862, 4640, 6064
21099, 4136, 5573, 4894, 5938
21100, 1006, 1005, 5051, 5502
21101, 2469, 2879, 3011, 4403
21102, 4323, 4715, 5916, 6132
21103, 4204, 5693, 5180, 6073
21104, 4602, 4259, 4910, 4954
21105, 2843, 4363, 5521, 5587
21106, 4529, 5444, 4315, 5653
21107, 2636, 5377, 4420, 5583
21108, 806, 4542, 1094, 5782
21109, 685, 686, 599, 4585
21110, 3947, 4441, 5008, 5269
21111, 945, 944, 1415, 5313
21112, 4110, 5012, 4495, 5379
21113, 476, 5282, 4575, 5501
21114, 4444, 6053, 5338, 6055
21115, 4356, 5544, 4815, 6214
21116, 3963, 5137, 4784, 5376
21117, 4319, 3977, 5546, 5590
21118, 554, 552, 555, 4484
21119, 4128, 4650, 5604, 5728
21120, 4047, 4962, 4704, 5763
21121, 521, 522, 4524, 5967
21122, 2317, 4982, 2334, 5188
21123, 366, 368, 5212, 5864
21124, 3877, 4281, 5408, 6048
21125, 4835, 5733, 666, 6076
21126, 4369, 5180, 5693, 6073
21127, 3043, 4734, 2363, 5129
21128, 3883, 3723, 2122, 5665
21129, 3737, 4318, 5166, 5685
21130, 3459, 5044, 4820, 5713
21131, 3985, 4843, 4494, 5624
21132, 4605, 5862, 4590, 6155
21133, 839, 4656, 837, 6027
21134, 3104, 2996, 2588, 4926
21135, 2809, 2808, 3067, 5085
21136, 4195, 5608, 4944, 5869
21137, 2953, 3051, 2252, 4737
21138, 450, 1249, 1151, 4738
21139, 4114, 4589, 4945, 5817
21140, 2503, 4551, 2504, 5647
21141, 3367, 4510, 3362, 5814
21142, 3901, 4788, 4489, 5231
21143, 3674, 3636, 3651, 6150
21144, 748, 4740, 1152, 5244
21145, 4645, 4763, 4161, 5618
21146, 4309, 5304, 4630, 5919
21147, 3977, 4603, 4714, 5724
21148, 5407, 5443, 4551, 5875
21149, 4886, 5141, 4063, 5565
21150, 4702, 4847, 3967, 5687
21151, 3485, 2980, 4684, 5437
21152, 3384, 3382, 3381, 5368
21153, 3244, 3241, 3225, 5588
21154, 3863, 3864, 3821, 4439
21155, 4075, 4973, 4750, 6034
21156, 4637, 4038, 4949, 5910
21157, 611, 541, 5083, 5658
21158, 4503, 4332, 5059, 6209
21159, 727, 5268, 4849, 5961
21160, 4039, 4390, 5178, 5682
21161, 2610, 5431, 4423, 5684
21162, 4553, 5840, 514, 5917
21163, 548, 1004, 556, 4459
21164, 2832, 4983, 2974, 5857
21165, 4011, 5593, 4345, 5838
21166, 1050, 4587, 1052, 5617
21167, 4024, 5608, 4328, 6114
21168, 739, 818, 1417, 6150
21169, 4392, 6051, 5295, 6059
21170, 556, 4459, 1004, 5502
21171, 4845, 4987, 4132, 6232
21172, 1355, 4454, 1088, 5650
21173, 4711, 5300, 4080, 5721
21174, 4387, 4675, 4492, 6074
21175, 4486, 4806, 808, 5043
21176, 3746, 3745, 3747, 5062
21177, 2832, 2913, 4983, 5857
21178, 3550, 3559, 5112, 5220
21179, 355, 354, 356, 6017
21180, 1302, 1194, 4714, 5635
21181, 3406, 3402, 3428, 4437
21182, 4930, 5353, 4301, 5863
21183, 1398, 817, 4889, 5702
21184, 1170, 716, 675, 4780
21185, 2811, 2812, 2808, 5846
21186, 3408, 3455, 5336, 5839
21187, 4146, 4975, 4987, 5963
21188, 861, 859, 876, 5364
21189, 4412, 5234, 3988, 5802
21190, 4644, 4742, 3958, 5349
21191, 2762, 4391, 3106, 5879
21192, 4660, 3942, 5210, 6099
21193, 2783, 2786, 2970, 5490
21194, 4366, 5100, 4558, 5234
21195, 993, 4699, 793, 5405
21196, 1070, 1171, 340, 4728
21197, 4330, 4763, 4645, 5618
21198, 4663, 4834, 3962, 5992
21199, 750, 4421, 751, 5820
21200, 4069, 5400, 5062, 6081
21201, 4971, 5403, 4232, 5473
21202, 2421, 3080, 3028, 5469
21203, 3519, 3520, 5001, 5825
21204, 2372, 2373, 5034, 5688
21205, 2832, 4983, 2913, 6092
21206, 3764, 4675, 3768, 6082
21207, 2829, 3031, 3028, 4643
21208, 4597, 5328, 4122, 6166
21209, 915, 1337, 744, 5153
21210, 4165, 4289, 5081, 5616
21211, 4440, 5489, 5302, 6161
21212, 2206, 4746, 2205, 5476
21213, 3090, 2831, 3035, 4667
21214, 4616, 4626, 4269, 4866
21215, 4289, 5616, 2287, 5691
21216, 3762, 1351, 3694, 5233
21217, 2231, 2233, 5184, 5568
21218, 568, 570, 569, 4744
21219, 4289, 4165, 5441, 5616
21220, 569, 568, 4744, 5181
21221, 4345, 5090, 3969, 5838
21222, 3363, 3362, 3361, 4940
21223, 571, 570, 572, 4744
21224, 3783, 5186, 3851, 5715
21225, 5353, 5863, 4930, 6158
21226, 4681, 5141, 4886, 5565
21227, 4355, 5896, 4739, 5918
21228, 747, 1225, 1296, 4759
21229, 463, 457, 4851, 5828
21230, 4581, 4998, 4061, 5956
21231, 3983, 4297, 4842, 5966
21232, 2227, 2224, 4654, 5859
21233, 3956, 4393, 4874, 6185
21234, 608, 4572, 1221, 5997
21235, 4016, 4952, 4460, 5211
21236, 2901, 4462, 2899, 6039
21237, 4403, 6119, 5207, 6167
21238, 4456, 4157, 5274, 6065
21239, 993, 994, 793, 4699
21240, 4321, 5080, 4166, 5088
21241, 1065, 793, 5289, 5405
21242, 1117, 5594, 1307, 6060
21243, 382, 456, 380, 5072
21244, 4299, 4882, 4664, 5074
21245, 2908, 2254, 2259, 5517
21246, 871, 877, 873, 5477
21247, 1238, 4858, 828, 5424
21248, 4356, 5404, 4999, 5457
21249, 4391, 5321, 4854, 5628
21250, 4543, 4234, 5095, 5944
21251, 4497, 5924, 4930, 6158
21252, 4410, 5508, 1328, 6003
21253, 2604, 3051, 3041, 4737
21254, 4190, 4824, 5753, 5878
21255, 1339, 834, 4859, 5819
21256, 4549, 5439, 4267, 5985
21257, 2948, 5621, 4419, 5932
21258, 3906, 4563, 4937, 5866
21259, 2582, 2584, 4623, 5792
21260, 3783, 3851, 3858, 5715
21261, 3029, 4638, 2865, 5737
21262, 2924, 2281, 5335, 5427
21263, 645, 1089, 564, 4747
21264, 2447, 2366, 2891, 4748
21265, 3848, 3728, 3896, 4448
21266, 3987, 4923, 4779, 5586
21267, 4129, 4637, 5480, 5505
21268, 5278, 5366, 4549, 5985
21269, 1156, 566, 1089, 4747
21270, 3995, 4994, 4372, 5254
21271, 1200, 697, 5049, 6236
21272, 4415, 4905, 4015, 6029
21273, 2977, 3076, 4729, 5731
21274, 4519, 5587, 4363, 5876
21275, 5219, 5280, 4398, 5970
21276, 4558, 4985, 4027, 5234
21277, 1022, 5573, 4333, 5789
21278, 2724, 3201, 4480, 4929
21279, 3989, 5579, 4403, 5904
21280, 1293, 1111, 1030, 5333
21281, 647, 574, 1161, 4745
21282, 2832, 2974, 2913, 5857
21283, 761, 4715, 762, 5203
21284, 4301, 5655, 5353, 6158
21285, 4597, 4122, 5928, 6166
21286, 415, 5157, 414, 5525
21287, 4048, 5353, 5218, 5655
21288, 2776, 3135, 2479, 4546
21289, 1270, 397, 436, 5103
21290, 702, 4700, 805, 5311
21291, 751, 4859, 4421, 5564
21292, 3392, 3443, 3431, 5213
21293, 3908, 4936, 4353, 6189
21294, 4134, 4567, 5127, 5517
21295, 2527, 2661, 2678, 4717
21296, 1000, 999, 998, 5536
21297, 4028, 4994, 5254, 6188
21298, 3554, 3530, 3559, 5112
21299, 1236, 1227, 543, 5412
21300, 405, 403, 1262, 4992
21301, 3121, 3184, 2108, 6170
21302, 5197, 5451, 3804, 5773
21303, 3977, 5522, 4603, 5724
21304, 3877, 5331, 4281, 6048
21305, 3766, 3767, 3870, 6082
21306, 2410, 5300, 5721, 6198
21307, 4236, 5194, 3266, 5669
21308, 3971, 4478, 5288, 5557
21309, 347, 1370, 3452, 4582
21310, 4216, 5951, 5302, 6161
21311, 4003, 4930, 5924, 6158
21312, 3995, 4372, 4994, 5880
21313, 4456, 5422, 5274, 5600
21314, 3236, 3237, 3303, 4448
21315, 4669, 5472, 4032, 6028
21316, 3739, 4391, 3741, 5685
21317, 1245, 1165, 5504, 5530
21318, 2894, 5476, 2950, 5587
21319, 3100, 4863, 4653, 6227
21320, 816, 5007, 4529, 6202
21321, 4210, 5607, 5542, 5769
21322, 2649, 2648, 5026, 6204
21323, 2359, 2361, 4393, 5977
21324, 1008, 1260, 1007, 5051
21325, 3867, 4494, 5704, 5897
21326, 3612, 3625, 3614, 5133
21327, 3523, 3565, 3475, 4728
21328, 4971, 5148, 4030, 5242
21329, 1138, 497, 587, 4613
21330, 3869, 4675, 3768, 5057
21331, 1405, 4486, 5746, 6217
21332, 4331, 4016, 4952, 5079
21333, 3192, 4433, 2893, 5765
21334, 3786, 4462, 3872, 6039
21335, 4216, 5374, 4411, 5514
21336, 1337, 663, 744, 4345
21337, 1028, 1034, 1278, 5954
21338, 4354, 4260, 5063, 5850
21339, 4162, 4763, 4679, 5963
21340, 4436, 5222, 4900, 5365
21341, 4936, 5411, 4353, 6189
21342, 3985, 5018, 4317, 5352
21343, 4135, 5268, 4849, 5301
21344, 4058, 5307, 5182, 6145
21345, 4081, 5039, 4592, 6015
21346, 1353, 816, 4529, 6202
21347, 4435, 5297, 2669, 5620
21348, 970, 5461, 4779, 5625
21349, 4000, 5321, 4391, 5628
21350, 4059, 4675, 5447, 5927
21351, 5032, 5865, 4596, 6046
21352, 4239, 4662, 4550, 4918
21353, 4583, 5121, 4233, 5293
21354, 3911, 5414, 4869, 6234
21355, 4395, 4915, 4320, 5447
21356, 723, 4614, 721, 5268
21357, 4331, 5715, 4952, 5941
21358, 2363, 2365, 2364, 4734
21359, 4465, 6012, 4132, 6176
21360, 2631, 5249, 4478, 6083
21361, 4149, 4914, 4889, 5907
21362, 2710, 2709, 3096, 4285
21363, 1297, 3231, 342, 5528
21364, 2955, 4832, 2214, 5950
21365, 812, 4672, 1364, 5058
21366, 4637, 5910, 4949, 6222
21367, 3841, 3762, 3765, 5233
21368, 4156, 5238, 4737, 5479
21369, 3488, 3578, 3524, 4640
21370, 788, 1289, 5293, 6122
21371, 4913, 5476, 4342, 6203
21372, 1252, 4712, 688, 5276
21373, 2876, 3852, 2109, 5151
21374, 3658, 2728, 2116, 4562
21375, 4647, 5733, 4067, 6076
21376, 4038, 4637, 5480, 6141
21377, 960, 1304, 332, 5045
21378, 5309, 5799, 4402, 5942
21379, 1332, 691, 4482, 5771
21380, 5756, 5846, 4874, 6185
21381, 4614, 4849, 721, 5268
21382, 1063, 1061, 736, 4441
21383, 4427, 5373, 4727, 6126
21384, 3567, 3586, 5001, 6004
21385, 3228, 3046, 3013, 6170
21386, 3406, 3402, 4437, 5444
21387, 1407, 823, 833, 4939
21388, 4082, 4822, 4400, 5509
21389, 3979, 4963, 4932, 6084
21390, 4150, 4878, 4621, 5894
21391, 3787, 3789, 3788, 5370
21392, 3738, 4469, 3736, 5166
21393, 4059, 4478, 5557, 5624
21394, 4354, 4869, 4698, 5850
21395, 1403, 1079, 654, 4904
21396, 767, 825, 769, 5837
21397, 785, 1122, 962, 4434
21398, 3135, 2792, 2404, 4408
21399, 2977, 3076, 3079, 4729
21400, 3910, 5481, 4540, 5812
21401, 4069, 5484, 4656, 6102
21402, 2711, 5368, 4490, 5984
21403, 4027, 5015, 4956, 5477
21404, 4169, 4895, 4652, 5060
21405, 470, 1240, 468, 5347
21406, 3071, 2201, 5648, 6024
21407, 3435, 4986, 4454, 5776
21408, 3973, 4390, 4916, 5682
21409, 2682, 4365, 5535, 5883
21410, 4069, 4656, 5739, 6102
21411, 3453, 4827, 4338, 5442
21412, 5006, 5703, 3939, 6172
21413, 2540, 5411, 4353, 5982
21414, 4093, 4823, 5161, 5488
21415, 523, 1140, 524, 4697
21416, 2464, 5671, 4723, 5799
21417, 4520, 4305, 5292, 6110
21418, 485, 484, 483, 5217
21419, 4597, 5287, 2162, 5928
21420, 3734, 3823, 3891, 5045
21421, 2746, 4730, 4809, 6088
21422, 530, 6134, 1143, 6179
21423, 4480, 4751, 5199, 5971
21424, 1289, 1287, 788, 5293
21425, 2233, 5184, 5568, 6001
21426, 3131, 2619, 3200, 5173
21427, 954, 977, 790, 4541
21428, 4483, 4814, 4318, 5013
21429, 4531, 4024, 5608, 5869
21430, 4480, 5199, 4929, 5971
21431, 2307, 5992, 4834, 6057
21432, 2239, 4932, 5599, 5778
21433, 4652, 5060, 4074, 5410
21434, 4944, 5608, 4024, 5869
21435, 1065, 993, 793, 5405
21436, 4444, 5845, 4005, 6055
21437, 4057, 4626, 4616, 4866
21438, 3548, 3474, 3576, 4389
21439, 444, 432, 442, 4678
21440, 4232, 5148, 4971, 5242
21441, 1108, 525, 1107, 4468
21442, 3626, 4630, 4472, 5919
21443, 4865, 5731, 2308, 6113
21444, 3449, 3338, 3332, 5147
21445, 4589, 5786, 5463, 5795
21446, 4023, 4890, 4316, 5112
21447, 4052, 5323, 4580, 5455
21448, 4305, 4947, 4520, 5292
21449, 943, 942, 1259, 5723
21450, 4701, 4762, 5712, 5987
21451, 367, 4840, 4520, 5864
21452, 3378, 3379, 3375, 4648
21453, 4586, 4909, 4316, 5173
21454, 4412, 5512, 5287, 6094
21455, 4255, 4801, 4399, 5686
21456, 2955, 2214, 2539, 5950
21457, 2097, 3399, 4604, 5921
21458, 2969, 2425, 5053, 5189
21459, 3975, 5329, 4326, 5813
21460, 1055, 4364, 5271, 5768
21461, 3299, 5116, 4445, 5998
21462, 3913, 4896, 4613, 5631
21463, 4277, 4845, 4464, 5371
21464, 4293, 5047, 4070, 5320
21465, 4086, 5585, 4802, 5857
21466, 4129, 5428, 4637, 5505
21467, 4090, 5261, 4606, 5736
21468, 1284, 4621, 443, 5417
21469, 4725, 5881, 5031, 6148
21470, 4071, 4388, 4840, 5754
21471, 4459, 4898, 556, 6031
21472, 2848, 2849, 2847, 5497
21473, 2499, 5915, 6012, 6176
21474, 2135, 2770, 2922, 5136
21475, 4515, 4870, 3987, 5197
21476, 3962, 5283, 4324, 6000
21477, 4153, 5541, 4822, 5931
21478, 5160, 5664, 1215, 5790
21479, 3949, 4739, 4661, 5718
21480, 2865, 4638, 2240, 5088
21481, 4069, 4332, 5171, 6027
21482, 4605, 5053, 3929, 5415
21483, 333, 5061, 3827, 5451
21484, 4005, 4796, 4707, 5598
21485, 4287, 4034, 5409, 5641
21486, 1174, 502, 1126, 4662
21487, 2478, 4950, 2472, 6237
21488, 4236, 4115, 5194, 5208
21489, 4696, 5456, 2319, 5742
21490, 4095, 5251, 4519, 5521
21491, 4656, 837, 6027, 6217
21492, 1091, 303, 3705, 4880
21493, 4409, 3929, 5053, 5415
21494, 3985, 5352, 4843, 5753
21495, 1356, 4812, 874, 5059
21496, 2533, 2534, 5999, 6154
21497, 2866, 4496, 2873, 5663
21498, 912, 3326, 4436, 5843
21499, 3951, 4601, 5158, 5324
21500, 4418, 4791, 5757, 5783
21501, 4770, 4149, 4914, 5782
21502, 2109, 3852, 3702, 5151
21503, 3999, 5025, 4546, 6119
21504, 4049, 4869, 5569, 6152
21505, 4024, 5407, 4551, 5875
21506, 2749, 4389, 3107, 6088
21507, 4030, 4971, 4516, 5148
21508, 2139, 4494, 3818, 6123
21509, 2688, 3085, 5099, 6090
21510, 4538, 5905, 5134, 6029
21511, 4465, 4731, 4061, 5956
21512, 5278, 5281, 4092, 6109
21513, 4478, 4059, 5474, 5624
21514, 4050, 5023, 5889, 5949
21515, 1329, 1398, 817, 4889
21516, 4024, 5647, 5608, 6114
21517, 3862, 5765, 4351, 6146
21518, 4070, 4816, 4459, 5502
21519, 4142, 5185, 4690, 5523
21520, 4377, 5559, 4807, 5867
21521, 3971, 4478, 5557, 5927
21522, 4086, 4573, 5101, 6092
21523, 4223, 4825, 4653, 4863
21524, 1107, 4468, 525, 6050
21525, 4183, 5034, 5073, 6138
21526, 4632, 4735, 4178, 5931
21527, 2608, 5736, 4611, 5975
21528, 3053, 4528, 2369, 5990
21529, 435, 428, 427, 5439
21530, 5113, 5542, 4080, 6125
21531, 4303, 4637, 4949, 6222
21532, 4056, 4952, 5715, 5941
21533, 4592, 4978, 4346, 5994
21534, 2752, 4722, 2720, 5468
21535, 3905, 5480, 4637, 5505
21536, 2601, 5028, 4588, 5920
21537, 4409, 5226, 4707, 5639
21538, 4345, 4011, 5153, 5593
21539, 4468, 4100, 5168, 5516
21540, 4070, 5319, 4293, 5320
21541, 4096, 4815, 5544, 6214
21542, 4434, 4922, 4282, 6160
21543, 870, 869, 5211, 6210
21544, 1135, 4486, 3695, 5746
21545, 573, 6019, 638, 6023
21546, 2747, 2748, 3217, 5764
21547, 3821, 3702, 3863, 5151
21548, 1049, 1064, 4816, 5425
21549, 4018, 4763, 4523, 5190
21550, 4016, 5352, 4428, 5360
21551, 311, 3311, 3423, 4956
21552, 3729, 3848, 3721, 4448
21553, 4780, 3910, 5812, 6180
21554, 4159, 4965, 4799, 5349
21555, 4037, 5055, 4605, 5862
21556, 1310, 4529, 325, 5131
21557, 2865, 2240, 4638, 5552
21558, 698, 4464, 720, 5781
21559, 2497, 4907, 4450, 5601
21560, 3976, 5100, 4388, 5138
21561, 668, 4444, 778, 5605
21562, 3892, 3707, 5583, 6052
21563, 443, 5417, 4621, 5612
21564, 3481, 3317, 3348, 5385
21565, 3070, 2858, 2856, 4991
21566, 4436, 4323, 5222, 5365
21567, 4678, 4901, 4058, 5182
21568, 3485, 3541, 2980, 5437
21569, 4799, 5716, 4238, 5738
21570, 4862, 5255, 3996, 5833
21571, 3269, 4445, 3281, 5732
21572, 4817, 5288, 4173, 5842
21573, 3452, 3467, 3348, 4582
21574, 4329, 4461, 5050, 5144
21575, 5603, 6025, 1210, 6065
21576, 4315, 5653, 5444, 5839
21577, 4636, 4889, 1329, 6045
21578, 741, 985, 1222, 5500
21579, 1027, 1226, 4706, 5954
21580, 4011, 5153, 4681, 5565
21581, 1305, 6004, 5458, 6103
21582, 4052, 5455, 4580, 5551
21583, 3106, 4391, 5321, 5879
21584, 2365, 5142, 4734, 6178
21585, 4101, 5717, 5201, 5816
21586, 4816, 5502, 4070, 5520
21587, 4112, 5290, 5037, 5330
21588, 4230, 4987, 4845, 6232
21589, 4590, 5267, 5055, 6155
21590, 2266, 5721, 2283, 5911
21591, 973, 968, 4515, 5625
21592, 4228, 4617, 5226, 6055
21593, 2479, 4546, 3135, 5851
21594, 2953, 3041, 4737, 6001
21595, 4507, 5478, 4398, 5970
21596, 4647, 5594, 706, 6076
21597, 4016, 4460, 4952, 5878
21598, 4436, 5365, 4900, 5797
21599, 4851, 5554, 4211, 5828
21600, 2231, 2234, 2233, 5568
21601, 990, 991, 972, 5539
21602, 4900, 5365, 5222, 6132
21603, 4305, 4520, 4947, 6110
21604, 4550, 5306, 4575, 5398
21605, 4343, 4155, 5000, 6211
21606, 3361, 3370, 3365, 5272
21607, 4524, 5824, 5019, 6225
21608, 4345, 5153, 4011, 5838
21609, 958, 957, 743, 4554
21610, 4005, 4539, 5117, 5845
21611, 2805, 2639, 2988, 4852
21612, 5065, 5542, 4048, 5607
21613, 751, 4421, 4859, 5820
21614, 1233, 1292, 4977, 6163
21615, 4041, 4468, 4851, 5314
21616, 4537, 5518, 4094, 6142
21617, 4308, 4011, 5153, 5838
21618, 4307, 5716, 4799, 5738
21619, 983, 982, 981, 4661
21620, 4923, 5091, 4779, 5586
21621, 968, 5451, 4515, 5625
21622, 418, 4665, 1263, 5914
21623, 4514, 4682, 4080, 6198
21624, 916, 4449, 3313, 5759
21625, 3196, 3176, 5155, 5464
21626, 4555, 4308, 4810, 6042
21627, 321, 3314, 4674, 5392
21628, 5055, 5267, 4140, 6155
21629, 2631, 4478, 2617, 6083
21630, 497, 498, 491, 6096
21631, 4725, 4294, 5881, 6148
21632, 4393, 4243, 5329, 6135
21633, 5145, 5222, 4323, 5916
21634, 3036, 5751, 4416, 5774
21635, 3080, 5469, 5312, 5626
21636, 3934, 4302, 5084, 6093
21637, 3928, 5328, 4512, 6166
21638, 4154, 4695, 4635, 6005
21639, 4025, 5045, 4469, 5166
21640, 4008, 4902, 4318, 5572
21641, 742, 5500, 4927, 5503
21642, 2158, 4803, 2159, 5287
21643, 1276, 4702, 1044, 5636
21644, 4091, 5253, 5157, 5525
21645, 2380, 4536, 5362, 5910
21646, 3903, 4921, 4426, 5330
21647, 5269, 5278, 4098, 6220
21648, 1415, 4473, 944, 5567
21649, 3350, 5125, 5082, 5385
21650, 972, 969, 990, 5196
21651, 4291, 5338, 6053, 6055
21652, 4272, 4453, 4643, 6006
21653, 4149, 4468, 5168, 5516
21654, 3301, 3259, 3277, 5413
21655, 3410, 4529, 3324, 5653
21656, 3773, 4790, 3832, 5079
21657, 4092, 5513, 4654, 6109
21658, 1073, 1294, 1354, 5153
21659, 4039, 4916, 4390, 5682
21660, 3901, 4509, 4810, 6075
21661, 784, 4390, 832, 5623
21662, 825, 5477, 769, 5837
21663, 855, 856, 4868, 5831
21664, 805, 948, 4700, 5364
21665, 4492, 4675, 4013, 6082
21666, 4678, 5182, 4058, 5307
21667, 3098, 6092, 5135, 6186
21668, 4826, 5487, 4450, 5745
21669, 4865, 5785, 2293, 5991
21670, 3499, 3480, 3498, 4796
21671, 2548, 5135, 4463, 5509
21672, 4701, 4762, 4182, 5712
21673, 2685, 2588, 2996, 4926
21674, 4076, 4955, 4426, 5689
