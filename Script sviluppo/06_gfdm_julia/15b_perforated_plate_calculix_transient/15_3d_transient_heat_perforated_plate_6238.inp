3688, 1813, 1909, 1891
3689, 1862, 1915, 1891
3690, 1833, 1901, 1853
3691, 1851, 1903, 1852
3692, 1825, 1865, 1847
3693, 1847, 1922, 1848
3694, 1856, 1862, 1858
3695, 1864, 1918, 1840
3696, 1843, 1845, 1844
3697, 1905, 1908, 1897
3698, 1856, 1858, 1857
3699, 1850, 1905, 1849
3700, 1864, 1914, 1827
3701, 1891, 1915, 1831
3702, 1842, 1911, 1820
3703, 1819, 1919, 1849
3704, 1845, 1846, 1844
3705, 1860, 1907, 1861
3706, 1858, 1859, 1857
3707, 1834, 1835, 1830
3708, 1820, 1912, 1838
3709, 214, 1834, 1830
3710, 1851, 1852, 1821
3711, 1835, 1836, 1830
3712, 1852, 1853, 1821
3713, 1852, 1854, 1853
3714, 1835, 1837, 1836
3715, 237, 1851, 1821
3716, 1854, 1855, 1853
3717, 1854, 1856, 1855
3718, 215, 1834, 214
3719, 214, 1830, 213
3720, 1822, 1913, 1855
3721, 1837, 1838, 1836
3722, 1845, 1847, 1846
3723, 1837, 1839, 1838
3724, 1858, 1909, 1860
3725, 1858, 1860, 1859
3726, 236, 1851, 237
3727, 1871, 1896, 1892
3728, 1818, 1895, 1894
3729, 1893, 1898, 99
3730, 237, 1821, 238
3731, 1854, 1862, 1856
3732, 1837, 1840, 1839
3733, 1840, 1841, 1839
3734, 1841, 1842, 1839
3735, 1860, 1861, 1859
3736, 1847, 1848, 1846
3737, 1841, 1843, 1842
3738, 1848, 1849, 1846
3739, 1848, 1850, 1849
3740, 1824, 1883, 1874
3741, 1874, 1883, 1872
3742, 1883, 1886, 1872
3743, 255, 1887, 254
3744, 1872, 1886, 1868
3745, 1825, 1881, 245
3746, 1868, 1886, 1823
3747, 1819, 1863, 96
3748, 247, 1865, 246
3749, 1867, 1869, 1868
3750, 254, 1887, 1866
3751, 253, 1866, 1823
3752, 1869, 1871, 1868
3753, 104, 1884, 1829
3754, 1873, 1874, 1872
3755, 259, 1822, 258
3756, 102, 1878, 1818
3757, 1867, 1868, 1823
3758, 104, 1829, 105
3759, 256, 1814, 255
3760, 1829, 1889, 105
3761, 1866, 1867, 1823
3762, 97, 1863, 1815
3763, 1816, 1878, 101
3764, 245, 1881, 244
3765, 254, 1866, 253
3766, 253, 1823, 252
3767, 93, 1817, 94
3768, 96, 1863, 97
3769, 246, 1825, 245
3770, 102, 1818, 103
3771, 106, 1889, 1813
3772, 244, 1881, 1828
3773, 248, 1826, 247
3774, 244, 1828, 243
3775, 250, 1824, 249
3776, 105, 1889, 106
3777, 97, 1815, 98
3778, 100, 1816, 101
3779, 246, 1865, 1825
3780, 249, 1879, 248
3781, 1824, 1879, 249
3782, 95, 1819, 96
3783, 242, 1864, 1827
3784, 250, 1883, 1824
3785, 1828, 1864, 243
3786, 248, 1879, 1826
3787, 101, 1878, 102
3788, 242, 1827, 241
3789, 1826, 1865, 247
3790, 91, 1820, 92
3791, 1871, 1872, 1868
3792, 1871, 1873, 1872
3793, 243, 1864, 242
3794, 106, 1813, 107
3795, 251, 1886, 1883
3796, 252, 1886, 251
3797, 251, 1883, 250
3798, 1814, 1887, 255
3799, 1818, 1884, 103
3800, 1823, 1886, 252
3801, 103, 1884, 104
3802, 1874, 1880, 1824
3803, 1824, 1880, 1879
3804, 1873, 1876, 1875
3805, 1887, 1890, 1866
3806, 1866, 1890, 1867
3807, 1873, 1875, 1874
3808, 1867, 1870, 1869
3809, 1875, 1880, 1874
3810, 1867, 1890, 1870
3811, 1884, 1885, 1829
3812, 1814, 1888, 1887
3813, 1888, 1890, 1887
3814, 256, 1877, 1814
3815, 257, 1877, 256
3816, 1881, 1882, 1828
3817, 1844, 1906, 1817
3818, 107, 1891, 108
3819, 1813, 1891, 107
3820, 89, 1832, 90
3821, 108, 1831, 109
3822, 261, 1833, 260
3823, 108, 1891, 1831
3824, 1850, 1908, 1905
3825, 1880, 1908, 1904
3826, 1836, 1900, 1830
3827, 1853, 1901, 1821
3828, 1876, 1898, 1893
3829, 1892, 1896, 1816
3830, 1894, 1895, 1870
3831, 1871, 1892, 1873
3832, 98, 1893, 99
3833, 1818, 1894, 1884
3834, 1876, 1897, 1875
3835, 100, 1898, 1816
3836, 1890, 1899, 1870
3837, 213, 1900, 212
3838, 238, 1901, 239
3839, 1880, 1904, 1879
3840, 241, 1902, 240
3841, 109, 1903, 110
3842, 1862, 1909, 1858
3843, 1857, 1917, 1822
3844, 1817, 1906, 94
3845, 95, 1906, 1819
3846, 1829, 1907, 1889
3847, 1893, 1897, 1876
3848, 1816, 1898, 1892
3849, 1870, 1899, 1894
3850, 1873, 1892, 1876
3851, 1815, 1893, 98
3852, 1884, 1894, 1885
3853, 1904, 1908, 1850
3854, 1895, 1896, 1869
3855, 1869, 1896, 1871
3856, 1878, 1895, 1818
3857, 1878, 1896, 1895
3858, 1816, 1896, 1878
3859, 1870, 1895, 1869
3860, 99, 1898, 100
3861, 1888, 1899, 1890
3862, 1907, 1926, 1861
3863, 11, 1920, 215
3864, 1830, 1900, 213
3865, 1821, 1901, 238
3866, 1827, 1902, 241
3867, 240, 1920, 11
3868, 1888, 1916, 1861
3869, 1831, 1903, 109
3870, 1881, 1910, 1882
3871, 1879, 1904, 1826
3872, 1820, 1911, 92
3873, 93, 1911, 1817
3874, 1815, 1905, 1897
3875, 7, 1921, 236
3876, 1835, 1914, 1837
3877, 110, 1921, 7
3878, 1852, 1915, 1854
3879, 91, 1912, 1820
3880, 259, 1913, 1822
3881, 1832, 1912, 90
3882, 1833, 1913, 260
3883, 1892, 1898, 1876
3884, 1815, 1897, 1893
3885, 1894, 1899, 1885
3886, 1822, 1917, 258
3887, 257, 1917, 1877
3888, 1828, 1918, 1864
3889, 1814, 1916, 1888
3890, 1863, 1905, 1815
3891, 1849, 1919, 1846
3892, 1907, 1925, 1889
3893, 212, 1923, 6
3894, 239, 1924, 12
3895, 6, 1923, 89
3896, 12, 1924, 261
3897, 94, 1906, 95
3898, 1885, 1907, 1829
3899, 1897, 1908, 1875
3900, 1882, 1927, 1841
3901, 1847, 1910, 1825
3902, 1841, 1918, 1882
3903, 1909, 1925, 1860
3904, 1859, 1916, 1877
3905, 1875, 1908, 1880
3906, 1861, 1926, 1888
3907, 1904, 1922, 1826
3908, 1841, 1927, 1843
3909, 1910, 1927, 1882
3910, 1840, 1918, 1841
3911, 1845, 1910, 1847
3912, 1860, 1925, 1907
3913, 1825, 1910, 1881
3914, 92, 1911, 93
3915, 90, 1912, 91
3916, 260, 1913, 259
3917, 1837, 1914, 1840
3918, 1854, 1915, 1862
3919, 1885, 1926, 1907
3920, 1906, 1919, 1819
3921, 1888, 1926, 1899
3922, 1877, 1916, 1814
3923, 1861, 1916, 1859
3924, 1900, 1923, 212
3925, 1901, 1924, 239
3926, 258, 1917, 257
3927, 1882, 1918, 1828
3928, 1889, 1925, 1813
3929, 1846, 1919, 1844
3930, 215, 1920, 1834
3931, 1845, 1927, 1910
3932, 236, 1921, 1851
3933, 1903, 1921, 110
3934, 1902, 1920, 240
3935, 1843, 1927, 1845
3936, 1826, 1922, 1865
3937, 89, 1923, 1832
3938, 261, 1924, 1833
3939, 1832, 1923, 1900
3940, 1833, 1924, 1901
3941, 1844, 1919, 1906
3942, 1851, 1921, 1903
3943, 1834, 1920, 1902
3944, 1813, 1925, 1909
3945, 1899, 1926, 1885
*ELEMENT, type=CPS3, ELSET=Surface6
3946, 1944, 2075, 1960
3947, 1956, 2076, 1972
3948, 1982, 2033, 2032
3949, 2031, 2072, 2035
3950, 1960, 2083, 1944
3951, 1957, 1963, 1961
3952, 1958, 1975, 1973
3953, 1972, 2085, 1956
3954, 2032, 2034, 1982
3955, 2034, 2035, 1932
3956, 2035, 2082, 1932
3957, 1936, 1968, 1967
3958, 1949, 1980, 1979
3959, 1957, 2080, 1963
3960, 1958, 2081, 1975
3961, 2035, 2072, 1948
3962, 2031, 2035, 2032
3963, 1937, 1964, 1963
3964, 1937, 1967, 1964
3965, 1967, 2087, 1936
3966, 1945, 1979, 1976
3967, 1945, 1976, 1975
3968, 1979, 2089, 1949
3969, 1977, 2084, 2049
3970, 1965, 2086, 2043
3971, 1961, 2073, 1957
3972, 2043, 2083, 1965
3973, 1960, 2075, 1959
3974, 1973, 2074, 1958
3975, 2049, 2085, 1977
3976, 1972, 2076, 1971
3977, 1979, 1980, 1978
3978, 1967, 1968, 1966
3979, 1976, 1979, 1978
3980, 1964, 1967, 1966
3981, 1970, 2078, 2055
3982, 1982, 2088, 1981
3983, 2055, 2096, 1970
3984, 1936, 2078, 1968
3985, 2049, 2084, 1928
3986, 2043, 2086, 1951
3987, 1982, 2079, 2033
3988, 1944, 2083, 2043
3989, 1949, 2079, 1980
3990, 2034, 2088, 1982
3991, 1980, 1981, 1978
3992, 1968, 1969, 1966
3993, 1956, 2085, 2049
3994, 1963, 2080, 1937
3995, 1955, 1960, 1959
3996, 2032, 2035, 2034
3997, 1955, 1961, 1960
3998, 1973, 1974, 1972
3999, 1980, 1982, 1981
4000, 1941, 1973, 1972
4001, 1968, 1970, 1969
4002, 1961, 1962, 1960
4003, 1941, 1972, 1971
4004, 1955, 1959, 146
4005, 1973, 1975, 1974
4006, 1975, 1976, 1974
4007, 1975, 2081, 1945
4008, 145, 1955, 146
4009, 1961, 1963, 1962
4010, 1941, 1971, 237
4011, 1963, 1964, 1962
4012, 146, 1959, 147
4013, 1976, 1978, 1977
4014, 238, 1941, 237
4015, 1976, 1977, 1974
4016, 2054, 2065, 1987
4017, 129, 2071, 2053
4018, 237, 1971, 236
4019, 1964, 1965, 1962
4020, 1964, 1966, 1965
4021, 1999, 2002, 2000
4022, 279, 1995, 278
4023, 1989, 1994, 1991
4024, 2022, 2025, 2019
4025, 2003, 2051, 2002
4026, 2005, 2010, 2008
4027, 2027, 2052, 2031
4028, 2015, 2016, 287
4029, 2004, 2005, 2003
4030, 1988, 2050, 1996
4031, 2004, 2010, 2005
4032, 2001, 2002, 1999
4033, 1991, 1994, 1934
4034, 278, 1995, 1943
4035, 1988, 1996, 1984
4036, 2019, 2025, 1953
4037, 2024, 2025, 2022
4038, 2023, 2026, 2022
4039, 2026, 2052, 2027
4040, 2002, 2051, 2000
4041, 2008, 2010, 1931
4042, 1996, 2050, 1997
4043, 2005, 2006, 2003
4044, 1997, 2029, 2018
4045, 2018, 2029, 2020
4046, 1997, 2018, 1998
4047, 1950, 2004, 2003
4048, 2006, 2051, 2003
4049, 2005, 2007, 2006
4050, 1997, 2050, 2029
4051, 2005, 2008, 2007
4052, 2008, 2009, 2007
4053, 1989, 1995, 1994
4054, 1994, 1995, 279
4055, 1946, 1998, 275
4056, 1930, 2028, 270
4057, 1950, 2001, 282
4058, 1986, 1988, 1984
4059, 2020, 2021, 2019
4060, 275, 1998, 274
4061, 272, 2024, 271
4062, 270, 2028, 269
4063, 2021, 2022, 2019
4064, 2021, 2023, 2022
4065, 121, 2038, 1933
4066, 127, 2040, 1939
4067, 1943, 1983, 277
4068, 132, 2044, 1940
4069, 1943, 1984, 1983
4070, 136, 1935, 137
4071, 116, 2045, 1932
4072, 131, 2044, 132
4073, 277, 1983, 276
4074, 132, 1940, 133
4075, 136, 2042, 1935
4076, 125, 2039, 1929
4077, 1944, 2043, 292
4078, 123, 2047, 1938
4079, 127, 1939, 128
4080, 293, 1944, 292
4081, 138, 2048, 1936
4082, 1951, 2046, 290
4083, 1940, 2041, 133
4084, 120, 2038, 121
4085, 1947, 2044, 131
4086, 114, 1928, 115
4087, 278, 1943, 277
4088, 122, 2047, 123
4089, 133, 2041, 134
4090, 124, 2039, 125
4091, 121, 1933, 122
4092, 116, 1932, 117
4093, 134, 2041, 1954
4094, 269, 1942, 268
4095, 271, 1930, 270
4096, 125, 1929, 126
4097, 138, 1936, 139
4098, 140, 1937, 141
4099, 265, 1945, 264
4100, 281, 1934, 280
4101, 119, 2037, 120
4102, 123, 1938, 124
4103, 135, 2042, 136
4104, 267, 1949, 266
4105, 291, 1951, 290
4106, 291, 2043, 1951
4107, 134, 1954, 135
4108, 286, 1931, 285
4109, 292, 2043, 291
4110, 283, 1950, 282
4111, 289, 1952, 288
4112, 276, 1946, 275
4113, 130, 1947, 131
4114, 274, 1953, 273
4115, 118, 1948, 119
4116, 137, 2048, 138
4117, 115, 2045, 116
4118, 290, 2046, 289
4119, 126, 2040, 127
4120, 276, 1983, 1946
4121, 2037, 2038, 120
4122, 1948, 2037, 119
4123, 1929, 2040, 126
4124, 1928, 2045, 115
4125, 1938, 2039, 124
4126, 1954, 2042, 135
4127, 1935, 2048, 137
4128, 289, 2046, 1952
4129, 1933, 2047, 122
4130, 1943, 1985, 1984
4131, 1985, 1986, 1984
4132, 2018, 2020, 2019
4133, 1989, 1990, 1987
4134, 1992, 1993, 1990
4135, 1985, 1989, 1987
4136, 2018, 2019, 1953
4137, 1991, 1992, 1990
4138, 282, 2001, 281
4139, 1985, 1987, 1986
4140, 269, 2028, 1942
4141, 271, 2024, 1930
4142, 274, 1998, 1953
4143, 1989, 1991, 1990
4144, 1998, 2018, 1953
4145, 281, 2001, 1934
4146, 1999, 2000, 1992
4147, 2011, 2013, 2012
4148, 1997, 1998, 1946
4149, 2027, 2028, 1930
4150, 2023, 2052, 2026
4151, 2011, 2012, 2009
4152, 283, 2004, 1950
4153, 272, 2025, 2024
4154, 1943, 1995, 1985
4155, 1934, 1994, 280
4156, 1984, 1996, 1983
4157, 1953, 2025, 273
4158, 2022, 2026, 2024
4159, 1931, 2010, 285
4160, 1996, 1997, 1946
4161, 2026, 2027, 1930
4162, 2013, 2016, 2015
4163, 284, 2004, 283
4164, 280, 1994, 279
4165, 1985, 1995, 1989
4166, 1983, 1996, 1946
4167, 273, 2025, 272
4168, 2024, 2026, 1930
4169, 284, 2010, 2004
4170, 285, 2010, 284
4171, 2027, 2031, 2030
4172, 1952, 2015, 288
4173, 1934, 2001, 1999
4174, 1991, 1999, 1992
4175, 1942, 2036, 268
4176, 268, 2036, 267
4177, 267, 2036, 1949
4178, 2011, 2016, 2013
4179, 2027, 2030, 2028
4180, 287, 2016, 286
4181, 1950, 2003, 2002
4182, 2028, 2030, 1942
4183, 2008, 2011, 2009
4184, 2013, 2014, 2012
4185, 288, 2015, 287
4186, 1950, 2002, 2001
4187, 2015, 2017, 2013
4188, 2031, 2032, 2030
4189, 2033, 2036, 1942
4190, 1934, 1999, 1991
4191, 1931, 2016, 2011
4192, 286, 2016, 1931
4193, 2013, 2017, 2014
4194, 1931, 2011, 2008
4195, 1952, 2017, 2015
4196, 2030, 2033, 1942
4197, 2032, 2033, 2030
4198, 113, 2049, 114
4199, 114, 2049, 1928
4200, 142, 1957, 143
4201, 112, 1956, 113
4202, 263, 1958, 262
4203, 1956, 2049, 113
4204, 2046, 2095, 2077
4205, 1955, 2073, 1961
4206, 1941, 2074, 1973
4207, 2053, 2071, 1993
4208, 1939, 2065, 2054
4209, 1990, 2054, 1987
4210, 129, 2053, 130
4211, 1992, 2060, 1993
4212, 1939, 2071, 128
4213, 1981, 2084, 1978
4214, 1969, 2086, 1966
4215, 144, 2073, 145
4216, 239, 2074, 238
4217, 294, 2075, 293
4218, 111, 2076, 112
4219, 1948, 2082, 2035
4220, 1937, 2087, 1967
4221, 1945, 2089, 1979
4222, 1993, 2060, 2053
4223, 2054, 2071, 1939
4224, 130, 2053, 1947
4225, 1993, 2054, 1990
4226, 1954, 2067, 2057
4227, 2044, 2068, 2058
4228, 1947, 2068, 2044
4229, 1954, 2057, 2042
4230, 2058, 2068, 2051
4231, 2014, 2056, 2012
4232, 1935, 2055, 2048
4233, 2055, 2056, 2014
4234, 2042, 2056, 1935
4235, 2057, 2067, 2009
4236, 1940, 2059, 2041
4237, 2041, 2067, 1954
4238, 2059, 2067, 2041
4239, 2006, 2058, 2051
4240, 1935, 2056, 2055
4241, 2061, 2069, 1938
4242, 2047, 2064, 2061
4243, 1938, 2069, 2039
4244, 2047, 2061, 1938
4245, 2062, 2066, 1988
4246, 2063, 2064, 1933
4247, 2038, 2063, 1933
4248, 1933, 2064, 2047
4249, 1986, 2062, 1988
4250, 2040, 2065, 1939
4251, 1988, 2066, 2050
4252, 2070, 2072, 2052
4253, 2063, 2070, 2023
4254, 2052, 2072, 2031
4255, 2062, 2065, 2040
4256, 1986, 2065, 2062
4257, 2039, 2069, 2066
4258, 2066, 2069, 2050
4259, 2058, 2059, 1940
4260, 2006, 2059, 2058
4261, 2023, 2070, 2052
4262, 2038, 2070, 2063
4263, 2056, 2057, 2012
4264, 2042, 2057, 2056
4265, 2012, 2057, 2009
4266, 2029, 2061, 2020
4267, 2061, 2064, 2020
4268, 2029, 2069, 2061
4269, 2044, 2058, 1940
4270, 2007, 2059, 2006
4271, 2000, 2060, 1992
4272, 2021, 2064, 2063
4273, 2020, 2064, 2021
4274, 1929, 2062, 2040
4275, 2021, 2063, 2023
4276, 1987, 2065, 1986
4277, 1929, 2066, 2062
4278, 2039, 2066, 1929
4279, 2007, 2067, 2059
4280, 2009, 2067, 2007
4281, 2050, 2069, 2029
4282, 2051, 2068, 2000
4283, 2037, 2070, 2038
4284, 1948, 2072, 2037
4285, 2037, 2072, 2070
4286, 128, 2071, 129
4287, 2060, 2068, 1947
4288, 2000, 2068, 2060
4289, 2046, 2077, 1952
4290, 2077, 2095, 1969
4291, 145, 2073, 1955
4292, 236, 2091, 7
4293, 293, 2075, 1944
4294, 238, 2074, 1941
4295, 147, 2090, 8
4296, 8, 2090, 294
4297, 7, 2091, 111
4298, 112, 2076, 1956
4299, 1962, 2083, 1960
4300, 1974, 2085, 1972
4301, 2053, 2060, 1947
4302, 1993, 2071, 2054
4303, 1937, 2080, 141
4304, 1932, 2082, 117
4305, 118, 2082, 1948
4306, 1945, 2081, 264
4307, 142, 2080, 1957
4308, 263, 2081, 1958
4309, 1936, 2087, 139
4310, 140, 2087, 1937
4311, 2033, 2079, 2036
4312, 1949, 2089, 266
4313, 265, 2089, 1945
4314, 1970, 2077, 1969
4315, 2, 2092, 144
4316, 12, 2093, 239
4317, 143, 2092, 2
4318, 262, 2093, 12
4319, 2055, 2078, 2048
4320, 1952, 2077, 2017
4321, 2048, 2078, 1936
4322, 2036, 2079, 1949
4323, 1968, 2078, 1970
4324, 1981, 2094, 2084
4325, 1980, 2079, 1982
4326, 1970, 2096, 2077
4327, 1969, 2095, 2086
4328, 2014, 2096, 2055
4329, 141, 2080, 142
4330, 264, 2081, 263
4331, 2077, 2096, 2017
4332, 117, 2082, 118
4333, 1978, 2084, 1977
4334, 1965, 2083, 1962
4335, 1966, 2086, 1965
4336, 1977, 2085, 1974
4337, 2088, 2094, 1981
4338, 1932, 2088, 2034
4339, 144, 2092, 2073
4340, 239, 2093, 2074
4341, 139, 2087, 140
4342, 2045, 2088, 1932
4343, 266, 2089, 265
4344, 1959, 2090, 147
4345, 1971, 2091, 236
4346, 2045, 2094, 2088
4347, 294, 2090, 2075
4348, 111, 2091, 2076
4349, 1957, 2092, 143
4350, 1958, 2093, 262
4351, 2073, 2092, 1957
4352, 2074, 2093, 1958
4353, 1928, 2094, 2045
4354, 1951, 2095, 2046
4355, 2017, 2096, 2014
4356, 2075, 2090, 1959
4357, 2076, 2091, 1971
4358, 2086, 2095, 1951
4359, 2084, 2094, 1928
*ELEMENT, type=CPS3, ELSET=Surface7
4360, 152, 3177, 8
4361, 8, 3177, 294
4362, 9, 3188, 166
4363, 171, 3188, 9
4364, 10, 3173, 211
4365, 216, 3173, 10
4366, 11, 3174, 235
4367, 240, 3174, 11
4368, 12, 3172, 261
4369, 262, 3172, 12
4370, 153, 3099, 152
4371, 3099, 3177, 152
4372, 154, 2144, 153
4373, 2144, 3099, 153
4374, 155, 3189, 154
4375, 154, 3189, 2144
4376, 156, 2118, 155
4377, 2118, 3189, 155
4378, 157, 3154, 156
4379, 156, 3154, 2118
4380, 158, 2687, 157
4381, 2687, 3154, 157
4382, 159, 2108, 158
4383, 2108, 2687, 158
4384, 160, 3046, 159
4385, 159, 3046, 2108
4386, 161, 3013, 160
4387, 3013, 3046, 160
4388, 162, 2120, 161
4389, 2120, 3013, 161
4390, 163, 3179, 162
4391, 162, 3179, 2120
4392, 164, 2143, 163
4393, 2143, 3179, 163
4394, 165, 3142, 164
4395, 164, 3142, 2143
4396, 166, 3123, 165
4397, 3123, 3142, 165
4398, 166, 3188, 3123
4399, 172, 2148, 171
4400, 2148, 3188, 171
4401, 173, 3057, 172
4402, 172, 3057, 2148
4403, 174, 2134, 173
4404, 2134, 3057, 173
4405, 175, 2761, 174
4406, 174, 2761, 2134
4407, 176, 2117, 175
4408, 2117, 2761, 175
4409, 177, 3212, 176
4410, 176, 3212, 2117
4411, 178, 3195, 177
4412, 3195, 3212, 177
4413, 179, 2112, 178
4414, 2112, 3195, 178
4415, 180, 2768, 179
4416, 179, 2768, 2112
4417, 181, 2135, 180
4418, 2135, 2768, 180
4419, 182, 2922, 181
4420, 181, 2922, 2135
4421, 183, 2109, 182
4422, 2109, 2922, 182
4423, 184, 2876, 183
4424, 183, 2876, 2109
4425, 185, 2136, 184
4426, 2136, 2876, 184
4427, 186, 2887, 185
4428, 185, 2887, 2136
4429, 187, 2105, 186
4430, 2105, 2887, 186
4431, 188, 2893, 187
4432, 187, 2893, 2105
4433, 189, 2137, 188
4434, 2137, 2893, 188
4435, 190, 2897, 189
4436, 189, 2897, 2137
4437, 191, 2103, 190
4438, 2103, 2897, 190
4439, 192, 2901, 191
4440, 191, 2901, 2103
4441, 193, 2138, 192
4442, 2138, 2901, 192
4443, 194, 3088, 193
4444, 193, 3088, 2138
4445, 195, 2729, 194
4446, 2729, 3088, 194
4447, 196, 2101, 195
4448, 2101, 2729, 195
4449, 197, 2732, 196
4450, 196, 2732, 2101
4451, 198, 2139, 197
4452, 2139, 2732, 197
4453, 199, 3204, 198
4454, 198, 3204, 2139
4455, 200, 3183, 199
4456, 3183, 3204, 199
4457, 201, 2098, 200
4458, 2098, 3183, 200
4459, 202, 3153, 201
4460, 201, 3153, 2098
4461, 203, 2140, 202
4462, 2140, 3153, 202
4463, 204, 3132, 203
4464, 203, 3132, 2140
4465, 205, 2110, 204
4466, 2110, 3132, 204
4467, 206, 2936, 205
4468, 205, 2936, 2110
4469, 207, 2937, 206
4470, 206, 2937, 2936
4471, 208, 2122, 207
4472, 2122, 2937, 207
4473, 209, 2921, 208
4474, 208, 2921, 2122
4475, 210, 2147, 209
4476, 2147, 2921, 209
4477, 211, 3102, 210
4478, 210, 3102, 2147
4479, 211, 3173, 3102
4480, 217, 2150, 216
4481, 2150, 3173, 216
4482, 218, 3118, 217
4483, 217, 3118, 2150
4484, 219, 2126, 218
4485, 2126, 3118, 218
4486, 220, 3133, 219
4487, 219, 3133, 2126
4488, 221, 2728, 220
4489, 2728, 3133, 220
4490, 222, 2116, 221
4491, 2116, 2728, 221
4492, 223, 3101, 222
4493, 222, 3101, 2116
4494, 224, 2133, 223
4495, 2133, 3101, 223
4496, 225, 2726, 224
4497, 224, 2726, 2133
4498, 226, 2099, 225
4499, 2099, 2726, 225
4500, 227, 3125, 226
4501, 226, 3125, 2099
4502, 228, 2132, 227
4503, 2132, 3125, 227
4504, 229, 2723, 228
4505, 228, 2723, 2132
4506, 230, 2115, 229
4507, 2115, 2723, 229
4508, 231, 2725, 230
4509, 230, 2725, 2115
4510, 232, 3197, 231
4511, 231, 3197, 2725
4512, 233, 2125, 232
4513, 2125, 3197, 232
4514, 234, 2721, 233
4515, 233, 2721, 2125
4516, 235, 2151, 234
4517, 2151, 2721, 234
4518, 235, 3174, 2151
4519, 241, 3103, 240
4520, 3103, 3174, 240
4521, 242, 2146, 241
4522, 2146, 3103, 241
4523, 243, 2983, 242
4524, 242, 2983, 2146
4525, 244, 2121, 243
4526, 2121, 2983, 243
4527, 245, 3137, 244
4528, 244, 3137, 2121
4529, 246, 2980, 245
4530, 2980, 3137, 245
4531, 247, 2111, 246
4532, 2111, 2980, 246
4533, 248, 2973, 247
4534, 247, 2973, 2111
4535, 249, 2142, 248
4536, 2142, 2973, 248
4537, 250, 2965, 249
4538, 249, 2965, 2142
4539, 251, 2100, 250
4540, 2100, 2965, 250
4541, 252, 2966, 251
4542, 251, 2966, 2100
4543, 253, 2141, 252
4544, 2141, 2966, 252
4545, 254, 3180, 253
4546, 253, 3180, 2141
4547, 255, 2107, 254
4548, 2107, 3180, 254
4549, 256, 3163, 255
4550, 255, 3163, 2107
4551, 257, 3185, 256
4552, 2749, 3163, 256
4553, 256, 3185, 2749
4554, 258, 2119, 257
4555, 2119, 3185, 257
4556, 259, 3169, 258
4557, 258, 3169, 2119
4558, 260, 2145, 259
4559, 2145, 3169, 259
4560, 261, 3097, 260
4561, 260, 3097, 2145
4562, 261, 3172, 3097
4563, 263, 2149, 262
4564, 2149, 3172, 262
4565, 264, 2696, 263
4566, 263, 2696, 2149
4567, 265, 2124, 264
4568, 2124, 2696, 264
4569, 266, 2694, 265
4570, 265, 2694, 2124
4571, 267, 3149, 266
4572, 266, 3149, 2694
4573, 268, 2114, 267
4574, 2114, 3149, 267
4575, 269, 2695, 268
4576, 268, 2695, 2114
4577, 270, 2127, 269
4578, 2127, 2695, 269
4579, 271, 2701, 270
4580, 270, 2701, 2127
4581, 272, 2097, 271
4582, 2097, 2701, 271
4583, 273, 2707, 272
4584, 272, 2707, 2097
4585, 274, 2128, 273
4586, 2128, 2707, 273
4587, 275, 2718, 274
4588, 274, 2718, 2128
4589, 276, 2102, 275
4590, 2102, 2718, 275
4591, 277, 2702, 276
4592, 276, 2702, 2102
4593, 278, 2129, 277
4594, 2129, 2702, 277
4595, 279, 2708, 278
4596, 278, 2708, 2129
4597, 280, 2104, 279
4598, 2104, 2708, 279
4599, 281, 2735, 280
4600, 280, 2735, 2104
4601, 282, 2130, 281
4602, 2130, 2735, 281
4603, 283, 2715, 282
4604, 282, 2715, 2130
4605, 284, 2714, 283
4606, 2714, 2715, 283
4607, 285, 2106, 284
4608, 2106, 2714, 284
4609, 286, 2691, 285
4610, 285, 2691, 2106
4611, 287, 2131, 286
4612, 2131, 2691, 286
4613, 288, 2690, 287
4614, 287, 2690, 2131
4615, 289, 2113, 288
4616, 2113, 2690, 288
4617, 290, 2736, 289
4618, 289, 2736, 2113
4619, 291, 2737, 290
4620, 290, 2737, 2736
4621, 292, 2123, 291
4622, 2123, 2737, 291
4623, 293, 2153, 292
4624, 292, 2153, 2123
4625, 294, 2152, 293
4626, 2152, 2153, 293
4627, 294, 3177, 2152
4628, 2097, 3157, 2701
4629, 2707, 2890, 2097
4630, 2890, 3157, 2097
4631, 2098, 3166, 2637
4632, 2637, 3183, 2098
4633, 2098, 3153, 2666
4634, 2666, 3166, 2098
4635, 2099, 3125, 2682
4636, 2682, 3208, 2099
4637, 2099, 3208, 2726
4638, 2100, 3221, 2965
4639, 2966, 3131, 2100
4640, 3131, 3221, 2100
4641, 2667, 2669, 2101
4642, 2101, 2732, 2667
4643, 2669, 2729, 2101
4644, 2702, 2703, 2102
4645, 2703, 2704, 2102
4646, 2704, 2718, 2102
4647, 2103, 2898, 2897
4648, 2103, 2899, 2898
4649, 2103, 2901, 2899
4650, 2104, 2709, 2708
4651, 2104, 2710, 2709
4652, 2104, 2735, 2710
4653, 2105, 2893, 2886
4654, 2886, 3074, 2105
4655, 2105, 3074, 2887
4656, 2691, 2693, 2106
4657, 2693, 2733, 2106
4658, 2106, 2733, 2714
4659, 2674, 2681, 2107
4660, 2107, 3107, 2674
4661, 2681, 3180, 2107
4662, 2107, 3163, 3107
4663, 2108, 3121, 2687
4664, 3046, 3184, 2108
4665, 2108, 3184, 3121
4666, 2109, 2888, 2775
4667, 2775, 2922, 2109
4668, 2876, 2888, 2109
4669, 2936, 2964, 2110
4670, 2964, 3113, 2110
4671, 3113, 3132, 2110
4672, 2973, 3181, 2111
4673, 2111, 3215, 2980
4674, 2111, 3181, 3117
4675, 3117, 3215, 2111
4676, 2730, 3195, 2112
4677, 2112, 3210, 2730
4678, 2768, 2791, 2112
4679, 2791, 3210, 2112
4680, 2113, 2679, 2673
4681, 2673, 2690, 2113
4682, 2113, 2736, 2679
4683, 2695, 3206, 2114
4684, 3059, 3149, 2114
4685, 2114, 3206, 3059
4686, 2115, 2724, 2723
4687, 2115, 3178, 2724
4688, 2725, 3178, 2115
4689, 2116, 2659, 2652
4690, 2652, 3182, 2116
4691, 2116, 3101, 2659
4692, 2116, 3182, 2728
4693, 2651, 2761, 2117
4694, 2117, 3010, 2651
4695, 2731, 3010, 2117
4696, 2117, 3212, 2731
4697, 2686, 2738, 2118
4698, 2118, 3154, 2686
4699, 2738, 2739, 2118
4700, 2739, 3189, 2118
4701, 2746, 3185, 2119
4702, 2119, 3217, 2746
4703, 2119, 3169, 2748
4704, 2748, 3217, 2119
4705, 2663, 3111, 2120
4706, 2120, 3179, 2663
4707, 2120, 3170, 3013
4708, 3111, 3170, 2120
4709, 2121, 3140, 2983
4710, 3137, 3216, 2121
4711, 2121, 3216, 3140
4712, 2921, 3191, 2122
4713, 2122, 3207, 2937
4714, 3191, 3207, 2122
4715, 2153, 2154, 2123
4716, 2154, 2155, 2123
4717, 2155, 2737, 2123
4718, 2694, 3115, 2124
4719, 2124, 2697, 2696
4720, 2124, 3115, 2697
4721, 2635, 3197, 2125
4722, 2125, 3209, 2635
4723, 2721, 3194, 2125
4724, 3194, 3209, 2125
4725, 2126, 3158, 3118
4726, 3133, 3218, 2126
4727, 2126, 3218, 3158
4728, 2127, 3155, 2695
4729, 2701, 3112, 2127
4730, 3112, 3155, 2127
4731, 2128, 3162, 2707
4732, 2718, 2719, 2128
4733, 2719, 3162, 2128
4734, 2129, 2713, 2702
4735, 2708, 2711, 2129
4736, 2711, 2713, 2129
4737, 2715, 2716, 2130
4738, 2716, 2717, 2130
4739, 2717, 2735, 2130
4740, 2690, 3203, 2131
4741, 2131, 2692, 2691
4742, 2131, 3203, 2692
4743, 2634, 3125, 2132
4744, 2132, 3143, 2634
4745, 2723, 3201, 2132
4746, 2132, 3201, 3143
4747, 2726, 2727, 2133
4748, 2727, 3148, 2133
4749, 2133, 3148, 3101
4750, 2761, 2762, 2134
4751, 2762, 3106, 2134
4752, 2134, 3106, 3057
4753, 2135, 2769, 2768
4754, 2135, 2770, 2769
4755, 2135, 2922, 2770
4756, 2136, 2877, 2876
4757, 2136, 2878, 2877
4758, 2136, 2887, 2878
4759, 2137, 3192, 2893
4760, 2897, 3130, 2137
4761, 3130, 3192, 2137
4762, 2138, 3136, 2901
4763, 3088, 3124, 2138
4764, 3124, 3136, 2138
4765, 2629, 2632, 2139
4766, 2139, 2767, 2629
4767, 2632, 2732, 2139
4768, 2139, 3204, 2767
4769, 2140, 3132, 2636
4770, 2636, 3141, 2140
4771, 2140, 3141, 2666
4772, 2666, 3153, 2140
4773, 2681, 3108, 2141
4774, 2141, 3180, 2681
4775, 2141, 3200, 2966
4776, 3108, 3200, 2141
4777, 2872, 2973, 2142
4778, 2142, 3138, 2872
4779, 2965, 3138, 2142
4780, 2143, 2662, 2661
4781, 2661, 2663, 2143
4782, 2143, 3142, 2662
4783, 2663, 3179, 2143
4784, 2739, 3119, 2144
4785, 2144, 3189, 2739
4786, 2144, 3198, 3099
4787, 3119, 3198, 2144
4788, 2145, 3129, 2748
4789, 2748, 3169, 2145
4790, 3097, 3211, 2145
4791, 2145, 3211, 3129
4792, 2146, 2983, 2664
4793, 2664, 3165, 2146
4794, 2146, 3165, 3103
4795, 2147, 3171, 2921
4796, 3102, 3159, 2147
4797, 3159, 3171, 2147
4798, 2148, 3057, 2677
4799, 2677, 3202, 2148
4800, 3123, 3188, 2148
4801, 2148, 3202, 3123
4802, 2696, 2698, 2149
4803, 2698, 3211, 2149
4804, 3097, 3172, 2149
4805, 2149, 3211, 3097
4806, 2150, 3118, 2676
4807, 2676, 3159, 2150
4808, 2150, 3159, 3102
4809, 3102, 3173, 2150
4810, 2151, 3190, 2721
4811, 3103, 3165, 2151
4812, 2151, 3174, 3103
4813, 3165, 3190, 2151
4814, 2152, 2660, 2153
4815, 2152, 3198, 2660
4816, 2152, 3177, 3099
4817, 3099, 3198, 2152
4818, 2153, 2660, 2154
4819, 2154, 2156, 2155
4820, 2154, 2683, 2156
4821, 2660, 2683, 2154
4822, 2156, 2157, 2155
4823, 2157, 2577, 2155
4824, 2577, 2737, 2155
4825, 2156, 2158, 2157
4826, 2156, 2483, 2158
4827, 2156, 2683, 2483
4828, 2158, 2159, 2157
4829, 2159, 2995, 2157
4830, 2157, 2995, 2577
4831, 2158, 2160, 2159
4832, 2158, 3068, 2160
4833, 2483, 3068, 2158
4834, 2160, 2161, 2159
4835, 2161, 2428, 2159
4836, 2428, 2995, 2159
4837, 2160, 2162, 2161
4838, 2160, 2387, 2162
4839, 2160, 3068, 2387
4840, 2162, 2163, 2161
4841, 2163, 3116, 2161
4842, 2161, 3116, 2428
4843, 2162, 2164, 2163
4844, 2162, 2753, 2164
4845, 2387, 2753, 2162
4846, 2164, 2165, 2163
4847, 2165, 2935, 2163
4848, 2935, 3116, 2163
4849, 2164, 2166, 2165
4850, 2164, 2797, 2166
4851, 2753, 2797, 2164
4852, 2166, 2167, 2165
4853, 2167, 2168, 2165
4854, 2168, 2935, 2165
4855, 2166, 2249, 2167
4856, 2166, 2261, 2249
4857, 2166, 2797, 2261
4858, 2167, 2169, 2168
4859, 2167, 3001, 2169
4860, 2249, 3001, 2167
4861, 2169, 2170, 2168
4862, 2170, 2934, 2168
4863, 2934, 2935, 2168
4864, 2169, 2171, 2170
4865, 2169, 2489, 2171
4866, 2169, 3001, 2489
4867, 2171, 2172, 2170
4868, 2172, 2306, 2170
4869, 2306, 2934, 2170
4870, 2171, 2173, 2172
4871, 2171, 3087, 2173
4872, 2489, 3087, 2171
4873, 2173, 2174, 2172
4874, 2174, 2925, 2172
4875, 2172, 2925, 2306
4876, 2173, 2175, 2174
4877, 2173, 2247, 2175
4878, 2173, 3087, 2247
4879, 2175, 2176, 2174
4880, 2176, 2924, 2174
4881, 2924, 2925, 2174
4882, 2175, 2177, 2176
4883, 2175, 3091, 2177
4884, 2247, 3091, 2175
4885, 2177, 2178, 2176
4886, 2178, 2281, 2176
4887, 2281, 2924, 2176
4888, 2177, 2179, 2178
4889, 2177, 3092, 2179
4890, 3091, 3092, 2177
4891, 2179, 2180, 2178
4892, 2180, 2919, 2178
4893, 2178, 2919, 2281
4894, 2179, 2181, 2180
4895, 2179, 2245, 2181
4896, 2179, 3092, 2245
4897, 2181, 2182, 2180
4898, 2182, 2916, 2180
4899, 2916, 2919, 2180
4900, 2181, 2183, 2182
4901, 2181, 3086, 2183
4902, 2245, 3086, 2181
4903, 2183, 2184, 2182
4904, 2184, 2258, 2182
4905, 2258, 2916, 2182
4906, 2183, 2185, 2184
4907, 2183, 3084, 2185
4908, 2183, 3086, 3084
4909, 2185, 2186, 2184
4910, 2186, 2996, 2184
4911, 2184, 2996, 2258
4912, 2185, 2187, 2186
4913, 2185, 2241, 2187
4914, 2185, 3084, 2241
4915, 2187, 2188, 2186
4916, 2188, 3104, 2186
4917, 2186, 3104, 2996
4918, 2187, 2189, 2188
4919, 2187, 3082, 2189
4920, 2241, 3082, 2187
4921, 2189, 2190, 2188
4922, 2190, 2248, 2188
4923, 2248, 3104, 2188
4924, 2189, 2191, 2190
4925, 2189, 3081, 2191
4926, 2189, 3082, 3081
4927, 2191, 2192, 2190
4928, 2192, 3022, 2190
4929, 2190, 3022, 2248
4930, 2191, 2193, 2192
4931, 2191, 2239, 2193
4932, 2191, 3081, 2239
4933, 2193, 2194, 2192
4934, 2194, 3100, 2192
4935, 2192, 3100, 3022
4936, 2193, 2195, 2194
4937, 2193, 3077, 2195
4938, 2239, 3077, 2193
4939, 2195, 2196, 2194
4940, 2196, 2235, 2194
4941, 2235, 3100, 2194
4942, 2195, 2197, 2196
4943, 2195, 3075, 2197
4944, 2195, 3077, 3075
4945, 2197, 2198, 2196
4946, 2198, 2912, 2196
4947, 2196, 2912, 2235
4948, 2197, 2199, 2198
4949, 2197, 2238, 2199
4950, 2197, 3075, 2238
4951, 2199, 2200, 2198
4952, 2200, 2911, 2198
4953, 2911, 2912, 2198
4954, 2199, 2201, 2200
4955, 2199, 3072, 2201
4956, 2238, 3072, 2199
4957, 2201, 2202, 2200
4958, 2202, 2228, 2200
4959, 2228, 2911, 2200
4960, 2201, 2203, 2202
4961, 2201, 3071, 2203
4962, 2201, 3072, 3071
4963, 2203, 2204, 2202
4964, 2204, 2950, 2202
4965, 2202, 2950, 2228
4966, 2203, 2205, 2204
4967, 2203, 2236, 2205
4968, 2203, 3071, 2236
4969, 2205, 2206, 2204
4970, 2206, 2894, 2204
4971, 2894, 2950, 2204
4972, 2205, 2207, 2206
4973, 2205, 3064, 2207
4974, 2236, 3064, 2205
4975, 2207, 2208, 2206
4976, 2208, 2330, 2206
4977, 2330, 2894, 2206
4978, 2207, 2209, 2208
4979, 2207, 3062, 2209
4980, 2207, 3064, 3062
4981, 2209, 2210, 2208
4982, 2210, 2818, 2208
4983, 2208, 2818, 2330
4984, 2209, 2211, 2210
4985, 2209, 2232, 2211
4986, 2209, 3062, 2232
4987, 2211, 2212, 2210
4988, 2212, 2213, 2210
4989, 2213, 2818, 2210
4990, 2211, 2220, 2212
4991, 2211, 3065, 2220
4992, 2232, 3065, 2211
4993, 2212, 2214, 2213
4994, 2212, 2955, 2214
4995, 2220, 2955, 2212
4996, 2214, 2215, 2213
4997, 2215, 2520, 2213
4998, 2520, 2818, 2213
4999, 2214, 2216, 2215
5000, 2214, 2539, 2216
5001, 2214, 2955, 2539
5002, 2216, 2217, 2215
5003, 2217, 2844, 2215
5004, 2215, 2844, 2520
5005, 2216, 2218, 2217
5006, 2216, 2990, 2218
5007, 2539, 2990, 2216
5008, 2218, 2219, 2217
5009, 2219, 2225, 2217
5010, 2225, 2844, 2217
5011, 2218, 2221, 2219
5012, 2218, 2223, 2221
5013, 2218, 2990, 2223
5014, 2221, 2222, 2219
5015, 2222, 3012, 2219
5016, 2219, 3012, 2225
5017, 2220, 3070, 2955
5018, 2220, 3065, 3045
5019, 3045, 3070, 2220
5020, 2221, 2914, 2222
5021, 2223, 2224, 2221
5022, 2224, 2914, 2221
5023, 2222, 2906, 2841
5024, 2841, 3012, 2222
5025, 2222, 2914, 2906
5026, 2223, 2226, 2224
5027, 2223, 2345, 2226
5028, 2223, 2990, 2345
5029, 2226, 2227, 2224
5030, 2227, 2902, 2224
5031, 2902, 2914, 2224
5032, 2225, 2835, 2834
5033, 2834, 2844, 2225
5034, 2225, 3012, 2835
5035, 2226, 2229, 2227
5036, 2226, 3006, 2229
5037, 2345, 3006, 2226
5038, 2229, 2230, 2227
5039, 2230, 2231, 2227
5040, 2231, 2902, 2227
5041, 2228, 2950, 2843
5042, 2843, 2974, 2228
5043, 2228, 2974, 2911
5044, 2229, 2237, 2230
5045, 2229, 2240, 2237
5046, 2229, 3006, 2240
5047, 2230, 2233, 2231
5048, 2230, 2957, 2233
5049, 2237, 2957, 2230
5050, 2233, 2234, 2231
5051, 2234, 2442, 2231
5052, 2442, 2902, 2231
5053, 2810, 3056, 2232
5054, 2232, 3062, 2810
5055, 3056, 3065, 2232
5056, 2233, 2244, 2234
5057, 2233, 2443, 2244
5058, 2233, 2957, 2443
5059, 2244, 2246, 2234
5060, 2246, 2949, 2234
5061, 2234, 2949, 2442
5062, 2912, 3098, 2235
5063, 2235, 3098, 3027
5064, 3027, 3100, 2235
5065, 2817, 3067, 2236
5066, 2236, 3071, 2817
5067, 2236, 3067, 3064
5068, 2240, 2242, 2237
5069, 2242, 2953, 2237
5070, 2953, 2957, 2237
5071, 2849, 3073, 2238
5072, 2238, 3075, 2849
5073, 2238, 3073, 3072
5074, 2802, 3078, 2239
5075, 2239, 3081, 2802
5076, 2239, 3078, 3077
5077, 2240, 2243, 2242
5078, 2240, 2865, 2243
5079, 2240, 3006, 2865
5080, 2785, 3083, 2241
5081, 2241, 3084, 2785
5082, 2241, 3083, 3082
5083, 2243, 2250, 2242
5084, 2250, 2252, 2242
5085, 2252, 2953, 2242
5086, 2243, 2251, 2250
5087, 2243, 2538, 2251
5088, 2243, 2865, 2538
5089, 2244, 2253, 2246
5090, 2244, 2956, 2253
5091, 2443, 2956, 2244
5092, 2688, 3085, 2245
5093, 2245, 3092, 2688
5094, 3085, 3086, 2245
5095, 2253, 2254, 2246
5096, 2254, 2255, 2246
5097, 2255, 2949, 2246
5098, 2247, 3087, 2680
5099, 2680, 3089, 2247
5100, 3089, 3091, 2247
5101, 2722, 3020, 2248
5102, 2248, 3022, 2722
5103, 3020, 3104, 2248
5104, 2261, 2262, 2249
5105, 2262, 3021, 2249
5106, 2249, 3021, 3001
5107, 2251, 2256, 2250
5108, 2250, 2967, 2252
5109, 2256, 2967, 2250
5110, 2251, 2257, 2256
5111, 2251, 2971, 2257
5112, 2538, 2971, 2251
5113, 2252, 3051, 2953
5114, 2967, 3047, 2252
5115, 3047, 3051, 2252
5116, 2253, 2263, 2254
5117, 2253, 2264, 2263
5118, 2253, 2956, 2264
5119, 2254, 2259, 2255
5120, 2254, 2908, 2259
5121, 2263, 2908, 2254
5122, 2259, 2260, 2255
5123, 2260, 2537, 2255
5124, 2537, 2949, 2255
5125, 2257, 2267, 2256
5126, 2267, 2333, 2256
5127, 2333, 2967, 2256
5128, 2257, 2268, 2267
5129, 2257, 2269, 2268
5130, 2257, 2971, 2269
5131, 2685, 2917, 2258
5132, 2258, 2996, 2685
5133, 2258, 2917, 2916
5134, 2259, 2265, 2260
5135, 2259, 2909, 2265
5136, 2908, 2909, 2259
5137, 2265, 2266, 2260
5138, 2266, 2975, 2260
5139, 2260, 2975, 2537
5140, 2261, 2294, 2262
5141, 2261, 2328, 2294
5142, 2261, 2797, 2328
5143, 2294, 2295, 2262
5144, 2295, 2296, 2262
5145, 2296, 3021, 2262
5146, 2264, 2297, 2263
5147, 2297, 2951, 2263
5148, 2263, 2951, 2908
5149, 2264, 2298, 2297
5150, 2264, 2993, 2298
5151, 2956, 2993, 2264
5152, 2265, 2282, 2266
5153, 2265, 2327, 2282
5154, 2265, 2909, 2327
5155, 2282, 2283, 2266
5156, 2283, 2284, 2266
5157, 2284, 2975, 2266
5158, 2268, 2976, 2267
5159, 2267, 2343, 2333
5160, 2267, 2976, 2343
5161, 2269, 2270, 2268
5162, 2270, 2304, 2268
5163, 2304, 2976, 2268
5164, 2269, 2271, 2270
5165, 2269, 2332, 2271
5166, 2269, 2971, 2332
5167, 2271, 2272, 2270
5168, 2272, 3042, 2270
5169, 2270, 3042, 2304
5170, 2271, 2273, 2272
5171, 2271, 2945, 2273
5172, 2332, 2945, 2271
5173, 2273, 2274, 2272
5174, 2274, 2946, 2272
5175, 2946, 3042, 2272
5176, 2273, 2275, 2274
5177, 2273, 2944, 2275
5178, 2273, 2945, 2944
5179, 2275, 2276, 2274
5180, 2276, 2278, 2274
5181, 2278, 2946, 2274
5182, 2275, 2277, 2276
5183, 2275, 2319, 2277
5184, 2275, 2944, 2319
5185, 2277, 2989, 2276
5186, 2276, 2279, 2278
5187, 2276, 2989, 2279
5188, 2319, 2320, 2277
5189, 2320, 2338, 2277
5190, 2338, 2989, 2277
5191, 2279, 2280, 2278
5192, 2280, 2932, 2278
5193, 2932, 2946, 2278
5194, 2279, 2307, 2280
5195, 2279, 2997, 2307
5196, 2989, 2997, 2279
5197, 2307, 2325, 2280
5198, 2325, 2326, 2280
5199, 2326, 2932, 2280
5200, 2764, 2924, 2281
5201, 2281, 3109, 2764
5202, 2919, 3109, 2281
5203, 2282, 2305, 2283
5204, 2282, 2915, 2305
5205, 2327, 2915, 2282
5206, 2283, 2285, 2284
5207, 2283, 3018, 2285
5208, 2305, 3018, 2283
5209, 2285, 2286, 2284
5210, 2286, 2410, 2284
5211, 2410, 2975, 2284
5212, 2285, 2287, 2286
5213, 2285, 3014, 2287
5214, 2285, 3018, 3014
5215, 2287, 2288, 2286
5216, 2288, 3023, 2286
5217, 2286, 3023, 2410
5218, 2287, 2289, 2288
5219, 2287, 2291, 2289
5220, 2287, 3014, 2291
5221, 2289, 2290, 2288
5222, 2290, 2415, 2288
5223, 2415, 3023, 2288
5224, 2289, 2292, 2290
5225, 2291, 2889, 2289
5226, 2289, 2889, 2292
5227, 2292, 2293, 2290
5228, 2293, 3033, 2290
5229, 2290, 3033, 2415
5230, 2291, 2999, 2889
5231, 2291, 3007, 2999
5232, 2291, 3014, 3007
5233, 2292, 2299, 2293
5234, 2292, 2331, 2299
5235, 2292, 2889, 2331
5236, 2299, 2300, 2293
5237, 2300, 2308, 2293
5238, 2308, 3033, 2293
5239, 2294, 2765, 2295
5240, 2328, 2352, 2294
5241, 2352, 2765, 2294
5242, 2295, 2301, 2296
5243, 2295, 2303, 2301
5244, 2295, 2765, 2303
5245, 2301, 2302, 2296
5246, 2302, 2962, 2296
5247, 2962, 3021, 2296
5248, 2298, 2323, 2297
5249, 2323, 2329, 2297
5250, 2329, 2951, 2297
5251, 2298, 2324, 2323
5252, 2298, 2353, 2324
5253, 2298, 2993, 2353
5254, 2299, 2940, 2300
5255, 2331, 2389, 2299
5256, 2389, 2940, 2299
5257, 2300, 2309, 2308
5258, 2300, 2310, 2309
5259, 2300, 2940, 2310
5260, 2301, 2402, 2302
5261, 2303, 2948, 2301
5262, 2301, 2948, 2402
5263, 2402, 2403, 2302
5264, 2403, 2423, 2302
5265, 2423, 2962, 2302
5266, 2758, 2948, 2303
5267, 2303, 3015, 2758
5268, 2765, 3015, 2303
5269, 2927, 2928, 2304
5270, 2304, 3042, 2927
5271, 2928, 2976, 2304
5272, 2787, 3018, 2305
5273, 2305, 3024, 2787
5274, 2915, 3024, 2305
5275, 2741, 2934, 2306
5276, 2306, 3110, 2741
5277, 2925, 3110, 2306
5278, 2307, 2407, 2325
5279, 2307, 2444, 2407
5280, 2307, 2997, 2444
5281, 2309, 2977, 2308
5282, 2977, 3076, 2308
5283, 2308, 3076, 3033
5284, 2310, 2311, 2309
5285, 2311, 2312, 2309
5286, 2312, 2977, 2309
5287, 2310, 2388, 2311
5288, 2310, 2595, 2388
5289, 2310, 2940, 2595
5290, 2311, 2313, 2312
5291, 2311, 2920, 2313
5292, 2388, 2920, 2311
5293, 2313, 2314, 2312
5294, 2314, 2421, 2312
5295, 2421, 2977, 2312
5296, 2313, 2315, 2314
5297, 2313, 2316, 2315
5298, 2313, 2920, 2316
5299, 2315, 2318, 2314
5300, 2318, 3028, 2314
5301, 2314, 3028, 2421
5302, 2316, 2317, 2315
5303, 2317, 3036, 2315
5304, 2315, 3036, 2318
5305, 2316, 2321, 2317
5306, 2316, 2530, 2321
5307, 2316, 2920, 2530
5308, 2321, 2322, 2317
5309, 2322, 2334, 2317
5310, 2334, 3036, 2317
5311, 2833, 3031, 2318
5312, 2318, 3036, 2833
5313, 2318, 3031, 3028
5314, 2319, 2923, 2320
5315, 2319, 2960, 2923
5316, 2944, 2960, 2319
5317, 2320, 2339, 2338
5318, 2320, 2340, 2339
5319, 2320, 2923, 2340
5320, 2321, 2868, 2322
5321, 2530, 2531, 2321
5322, 2531, 2868, 2321
5323, 2322, 2335, 2334
5324, 2322, 2336, 2335
5325, 2322, 2868, 2336
5326, 2324, 2952, 2323
5327, 2323, 2426, 2329
5328, 2323, 2952, 2426
5329, 2353, 2354, 2324
5330, 2354, 2355, 2324
5331, 2355, 2952, 2324
5332, 2325, 2942, 2326
5333, 2407, 2408, 2325
5334, 2408, 2942, 2325
5335, 2777, 2932, 2326
5336, 2326, 2947, 2777
5337, 2942, 2947, 2326
5338, 2909, 2910, 2327
5339, 2910, 3003, 2327
5340, 2327, 3003, 2915
5341, 2328, 2429, 2352
5342, 2328, 3005, 2429
5343, 2797, 3005, 2328
5344, 2426, 2441, 2329
5345, 2441, 2484, 2329
5346, 2484, 2951, 2329
5347, 2818, 2819, 2330
5348, 2819, 2820, 2330
5349, 2820, 2894, 2330
5350, 2331, 2390, 2389
5351, 2331, 2931, 2390
5352, 2889, 2931, 2331
5353, 2864, 2961, 2332
5354, 2332, 2971, 2864
5355, 2332, 2961, 2945
5356, 2343, 2344, 2333
5357, 2344, 2547, 2333
5358, 2547, 2967, 2333
5359, 2335, 3035, 2334
5360, 3035, 3090, 2334
5361, 2334, 3090, 3036
5362, 2336, 2337, 2335
5363, 2337, 2409, 2335
5364, 2409, 3035, 2335
5365, 2336, 2391, 2337
5366, 2336, 2420, 2391
5367, 2336, 2868, 2420
5368, 2391, 2392, 2337
5369, 2392, 2979, 2337
5370, 2337, 2979, 2409
5371, 2339, 2342, 2338
5372, 2342, 2597, 2338
5373, 2597, 2989, 2338
5374, 2340, 2341, 2339
5375, 2341, 3017, 2339
5376, 2339, 3017, 2342
5377, 2340, 2346, 2341
5378, 2340, 2422, 2346
5379, 2340, 2923, 2422
5380, 2346, 2347, 2341
5381, 2347, 2398, 2341
5382, 2398, 3017, 2341
5383, 2342, 3008, 2597
5384, 2790, 3008, 2342
5385, 2342, 3017, 2790
5386, 2343, 2413, 2344
5387, 2343, 3044, 2413
5388, 2976, 3044, 2343
5389, 2413, 2414, 2344
5390, 2414, 3060, 2344
5391, 2344, 3060, 2547
5392, 2990, 3038, 2345
5393, 2345, 3029, 3006
5394, 2345, 3038, 3029
5395, 2346, 2348, 2347
5396, 2346, 2851, 2348
5397, 2422, 2851, 2346
5398, 2348, 2349, 2347
5399, 2349, 3025, 2347
5400, 2347, 3025, 2398
5401, 2348, 2350, 2349
5402, 2348, 2486, 2350
5403, 2348, 2851, 2486
5404, 2350, 2351, 2349
5405, 2351, 2393, 2349
5406, 2393, 3025, 2349
5407, 2350, 2358, 2351
5408, 2350, 2806, 2358
5409, 2486, 2806, 2350
5410, 2358, 2359, 2351
5411, 2359, 3037, 2351
5412, 2351, 3037, 2393
5413, 2429, 2432, 2352
5414, 2432, 3030, 2352
5415, 2352, 3030, 2765
5416, 2353, 2978, 2354
5417, 2794, 2978, 2353
5418, 2353, 2993, 2794
5419, 2354, 2356, 2355
5420, 2354, 2357, 2356
5421, 2354, 2978, 2357
5422, 2356, 2895, 2355
5423, 2355, 2895, 2779
5424, 2779, 2952, 2355
5425, 2357, 2399, 2356
5426, 2399, 2400, 2356
5427, 2400, 2895, 2356
5428, 2357, 2401, 2399
5429, 2357, 2430, 2401
5430, 2357, 2978, 2430
5431, 2358, 2360, 2359
5432, 2358, 2446, 2360
5433, 2358, 2806, 2446
5434, 2360, 2361, 2359
5435, 2361, 3039, 2359
5436, 2359, 3039, 3037
5437, 2360, 2362, 2361
5438, 2360, 2811, 2362
5439, 2446, 2811, 2360
5440, 2362, 2363, 2361
5441, 2363, 2406, 2361
5442, 2406, 3039, 2361
5443, 2362, 2364, 2363
5444, 2362, 2813, 2364
5445, 2811, 2813, 2362
5446, 2364, 2365, 2363
5447, 2365, 3043, 2363
5448, 2363, 3043, 2406
5449, 2364, 2366, 2365
5450, 2364, 2447, 2366
5451, 2364, 2813, 2447
5452, 2366, 2367, 2365
5453, 2367, 2405, 2365
5454, 2405, 3043, 2365
5455, 2366, 2368, 2367
5456, 2366, 2891, 2368
5457, 2447, 2891, 2366
5458, 2368, 2369, 2367
5459, 2369, 3053, 2367
5460, 2367, 3053, 2405
5461, 2368, 2370, 2369
5462, 2368, 2958, 2370
5463, 2891, 2958, 2368
5464, 2370, 2371, 2369
5465, 2371, 3058, 2369
5466, 2369, 3058, 3053
5467, 2370, 2372, 2371
5468, 2370, 2448, 2372
5469, 2370, 2958, 2448
5470, 2372, 2373, 2371
5471, 2373, 2431, 2371
5472, 2431, 3058, 2371
5473, 2372, 2374, 2373
5474, 2372, 2845, 2374
5475, 2448, 2845, 2372
5476, 2374, 2375, 2373
5477, 2375, 2992, 2373
5478, 2373, 2992, 2431
5479, 2374, 2376, 2375
5480, 2374, 2963, 2376
5481, 2845, 2963, 2374
5482, 2376, 2377, 2375
5483, 2377, 2440, 2375
5484, 2440, 2992, 2375
5485, 2376, 2378, 2377
5486, 2376, 2449, 2378
5487, 2376, 2963, 2449
5488, 2378, 2379, 2377
5489, 2379, 3146, 2377
5490, 2377, 3146, 2440
5491, 2378, 2380, 2379
5492, 2378, 2798, 2380
5493, 2449, 2798, 2378
5494, 2380, 2381, 2379
5495, 2381, 2456, 2379
5496, 2456, 3146, 2379
5497, 2380, 2382, 2381
5498, 2380, 2970, 2382
5499, 2798, 2970, 2380
5500, 2382, 2383, 2381
5501, 2383, 3205, 2381
5502, 2381, 3205, 2456
5503, 2382, 2384, 2383
5504, 2382, 2452, 2384
5505, 2382, 2970, 2452
5506, 2384, 2385, 2383
5507, 2385, 2469, 2383
5508, 2469, 3205, 2383
5509, 2384, 2386, 2385
5510, 2384, 2781, 2386
5511, 2452, 2781, 2384
5512, 2386, 2394, 2385
5513, 2394, 3011, 2385
5514, 2385, 3011, 2469
5515, 2386, 2395, 2394
5516, 2386, 2985, 2395
5517, 2781, 2985, 2386
5518, 2387, 2752, 2734
5519, 2734, 2753, 2387
5520, 2387, 3068, 2752
5521, 2595, 2796, 2388
5522, 2796, 2968, 2388
5523, 2388, 2968, 2920
5524, 2390, 2433, 2389
5525, 2433, 2867, 2389
5526, 2867, 2940, 2389
5527, 2390, 2436, 2433
5528, 2390, 2437, 2436
5529, 2390, 2931, 2437
5530, 2391, 2411, 2392
5531, 2391, 2869, 2411
5532, 2420, 2869, 2391
5533, 2411, 2412, 2392
5534, 2412, 2416, 2392
5535, 2416, 2979, 2392
5536, 2892, 3026, 2393
5537, 2393, 3037, 2892
5538, 2393, 3026, 3025
5539, 2395, 2396, 2394
5540, 2396, 2479, 2394
5541, 2479, 3011, 2394
5542, 2395, 2397, 2396
5543, 2395, 2455, 2397
5544, 2395, 2985, 2455
5545, 2397, 2404, 2396
5546, 2404, 3135, 2396
5547, 2396, 3135, 2479
5548, 2397, 3093, 2404
5549, 2455, 2457, 2397
5550, 2457, 3093, 2397
5551, 2766, 3019, 2398
5552, 2398, 3025, 2766
5553, 2398, 3019, 3017
5554, 2399, 2424, 2400
5555, 2401, 2994, 2399
5556, 2399, 2994, 2424
5557, 2424, 2425, 2400
5558, 2425, 2427, 2400
5559, 2427, 2895, 2400
5560, 2430, 2487, 2401
5561, 2487, 2488, 2401
5562, 2488, 2994, 2401
5563, 2402, 2453, 2403
5564, 2402, 2454, 2453
5565, 2402, 2948, 2454
5566, 2403, 3000, 2423
5567, 2453, 2458, 2403
5568, 2458, 3000, 2403
5569, 2404, 2793, 2792
5570, 2792, 3135, 2404
5571, 2404, 3093, 2793
5572, 2743, 3048, 2405
5573, 2405, 3053, 2743
5574, 2405, 3048, 3043
5575, 2751, 3040, 2406
5576, 2406, 3043, 2751
5577, 2406, 3040, 3039
5578, 2407, 2988, 2408
5579, 2444, 2450, 2407
5580, 2450, 2988, 2407
5581, 2805, 2941, 2408
5582, 2408, 2988, 2805
5583, 2941, 2942, 2408
5584, 2979, 3004, 2409
5585, 3004, 3094, 2409
5586, 2409, 3094, 3035
5587, 2907, 2981, 2410
5588, 2410, 3023, 2907
5589, 2410, 2981, 2975
5590, 2411, 2874, 2412
5591, 2869, 3151, 2411
5592, 2411, 3151, 2874
5593, 2412, 2417, 2416
5594, 2412, 2418, 2417
5595, 2412, 2874, 2418
5596, 2413, 2480, 2414
5597, 2413, 2481, 2480
5598, 2413, 3044, 2481
5599, 2480, 2482, 2414
5600, 2482, 2929, 2414
5601, 2929, 3060, 2414
5602, 2415, 3033, 2840
5603, 2840, 3034, 2415
5604, 2415, 3034, 3023
5605, 2417, 2445, 2416
5606, 2445, 2542, 2416
5607, 2542, 2979, 2416
5608, 2418, 2419, 2417
5609, 2419, 2954, 2417
5610, 2417, 2954, 2445
5611, 2418, 2434, 2419
5612, 2418, 2493, 2434
5613, 2418, 2874, 2493
5614, 2434, 2435, 2419
5615, 2435, 2982, 2419
5616, 2419, 2982, 2954
5617, 2868, 2938, 2420
5618, 2420, 2870, 2869
5619, 2420, 2938, 2870
5620, 2421, 3079, 2977
5621, 3028, 3080, 2421
5622, 2421, 3080, 3079
5623, 2422, 2852, 2851
5624, 2422, 2853, 2852
5625, 2422, 2923, 2853
5626, 2423, 3126, 2962
5627, 3000, 3128, 2423
5628, 2423, 3128, 3126
5629, 2424, 2496, 2425
5630, 2424, 2540, 2496
5631, 2424, 2994, 2540
5632, 2425, 2470, 2427
5633, 2425, 2969, 2470
5634, 2496, 2969, 2425
5635, 2426, 2494, 2441
5636, 2426, 2756, 2494
5637, 2426, 2952, 2756
5638, 2470, 2501, 2427
5639, 2501, 2516, 2427
5640, 2516, 2895, 2427
5641, 2428, 2789, 2675
5642, 2675, 2995, 2428
5643, 2428, 3116, 2789
5644, 2429, 2502, 2432
5645, 2429, 2511, 2502
5646, 2429, 3005, 2511
5647, 2430, 2490, 2487
5648, 2430, 2536, 2490
5649, 2430, 2978, 2536
5650, 2992, 3152, 2431
5651, 2431, 3061, 3058
5652, 2431, 3152, 3061
5653, 2502, 2503, 2432
5654, 2503, 2504, 2432
5655, 2504, 3030, 2432
5656, 2436, 2497, 2433
5657, 2497, 2498, 2433
5658, 2498, 2867, 2433
5659, 2434, 2459, 2435
5660, 2434, 3213, 2459
5661, 2493, 3213, 2434
5662, 2459, 2460, 2435
5663, 2460, 2461, 2435
5664, 2461, 2982, 2435
5665, 2437, 2438, 2436
5666, 2438, 2926, 2436
5667, 2436, 2926, 2497
5668, 2437, 2439, 2438
5669, 2437, 2987, 2439
5670, 2931, 2987, 2437
5671, 2439, 2471, 2438
5672, 2471, 2576, 2438
5673, 2576, 2926, 2438
5674, 2439, 2472, 2471
5675, 2439, 2473, 2472
5676, 2439, 2987, 2473
5677, 2440, 3120, 2992
5678, 2440, 3186, 3120
5679, 3146, 3186, 2440
5680, 2441, 2485, 2484
5681, 2441, 2871, 2485
5682, 2494, 2871, 2441
5683, 2442, 2903, 2902
5684, 2442, 2904, 2903
5685, 2442, 2949, 2904
5686, 2443, 3032, 2956
5687, 2957, 3041, 2443
5688, 2443, 3041, 3032
5689, 2444, 2451, 2450
5690, 2444, 2998, 2451
5691, 2997, 2998, 2444
5692, 2445, 2548, 2542
5693, 2445, 2550, 2548
5694, 2445, 2954, 2550
5695, 2806, 2807, 2446
5696, 2807, 2808, 2446
5697, 2808, 2811, 2446
5698, 2813, 2814, 2447
5699, 2814, 2815, 2447
5700, 2815, 2891, 2447
5701, 2448, 2846, 2845
5702, 2448, 2847, 2846
5703, 2448, 2958, 2847
5704, 2449, 2799, 2798
5705, 2449, 2800, 2799
5706, 2449, 2963, 2800
5707, 2451, 2495, 2450
5708, 2495, 2505, 2450
5709, 2505, 2988, 2450
5710, 2451, 2551, 2495
5711, 2451, 2552, 2551
5712, 2451, 2998, 2552
5713, 2452, 2782, 2781
5714, 2452, 2783, 2782
5715, 2452, 2970, 2783
5716, 2454, 2499, 2453
5717, 2453, 3002, 2458
5718, 2499, 3002, 2453
5719, 2454, 2500, 2499
5720, 2454, 2521, 2500
5721, 2454, 2948, 2521
5722, 2455, 2555, 2457
5723, 2455, 2557, 2555
5724, 2455, 2985, 2557
5725, 2881, 2882, 2456
5726, 2456, 3205, 2881
5727, 2882, 2883, 2456
5728, 2883, 3146, 2456
5729, 2555, 2556, 2457
5730, 2556, 2572, 2457
5731, 2572, 3093, 2457
5732, 2458, 3164, 3000
5733, 3002, 3176, 2458
5734, 2458, 3176, 3164
5735, 2459, 2875, 2460
5736, 2459, 3096, 2875
5737, 2459, 3213, 3096
5738, 2460, 2462, 2461
5739, 2460, 2463, 2462
5740, 2460, 2875, 2463
5741, 2462, 2509, 2461
5742, 2509, 2512, 2461
5743, 2512, 2982, 2461
5744, 2463, 2464, 2462
5745, 2464, 2918, 2462
5746, 2462, 2918, 2509
5747, 2463, 2465, 2464
5748, 2463, 2546, 2465
5749, 2463, 2875, 2546
5750, 2465, 2466, 2464
5751, 2466, 3105, 2464
5752, 2464, 3105, 2918
5753, 2465, 2467, 2466
5754, 2465, 3139, 2467
5755, 2546, 3139, 2465
5756, 2467, 2468, 2466
5757, 2468, 2508, 2466
5758, 2508, 3105, 2466
5759, 2467, 2506, 2468
5760, 2467, 2519, 2506
5761, 2467, 3139, 2519
5762, 2506, 2507, 2468
5763, 2507, 2991, 2468
5764, 2468, 2991, 2508
5765, 2879, 2880, 2469
5766, 2469, 3011, 2879
5767, 2880, 2881, 2469
5768, 2881, 3205, 2469
5769, 2470, 2579, 2501
5770, 2470, 2580, 2579
5771, 2470, 2969, 2580
5772, 2472, 3144, 2471
5773, 2471, 2581, 2576
5774, 2471, 3144, 2581
5775, 2473, 2474, 2472
5776, 2474, 2478, 2472
5777, 2478, 3144, 2472
5778, 2473, 2475, 2474
5779, 2473, 2596, 2475
5780, 2473, 2987, 2596
5781, 2475, 2476, 2474
5782, 2476, 2943, 2474
5783, 2474, 2943, 2478
5784, 2475, 2477, 2476
5785, 2475, 2972, 2477
5786, 2596, 2972, 2475
5787, 2477, 2491, 2476
5788, 2491, 2573, 2476
5789, 2573, 2943, 2476
5790, 2477, 2492, 2491
5791, 2477, 2518, 2492
5792, 2477, 2972, 2518
5793, 2943, 3055, 2478
5794, 3055, 3214, 2478
5795, 2478, 3214, 3144
5796, 2776, 3114, 2479
5797, 2479, 3135, 2776
5798, 2479, 3114, 3011
5799, 2481, 2986, 2480
5800, 2480, 2562, 2482
5801, 2480, 2986, 2562
5802, 2481, 3052, 2986
5803, 3044, 3049, 2481
5804, 3049, 3052, 2481
5805, 2562, 2586, 2482
5806, 2586, 2601, 2482
5807, 2601, 2929, 2482
5808, 2683, 2684, 2483
5809, 2684, 2720, 2483
5810, 2720, 3068, 2483
5811, 2485, 2513, 2484
5812, 2513, 2593, 2484
5813, 2593, 2951, 2484
5814, 2485, 2514, 2513
5815, 2485, 2608, 2514
5816, 2485, 2871, 2608
5817, 2486, 2873, 2806
5818, 2851, 2866, 2486
5819, 2866, 2873, 2486
5820, 2487, 3063, 2488
5821, 2490, 2600, 2487
5822, 2600, 3063, 2487
5823, 2488, 3063, 2780
5824, 2780, 3069, 2488
5825, 2488, 3069, 2994
5826, 3001, 3050, 2489
5827, 3050, 3122, 2489
5828, 2489, 3122, 3087
5829, 2536, 2603, 2490
5830, 2490, 3054, 2600
5831, 2603, 3054, 2490
5832, 2492, 2933, 2491
5833, 2491, 2574, 2573
5834, 2491, 2933, 2574
5835, 2518, 2543, 2492
5836, 2543, 2544, 2492
5837, 2544, 2933, 2492
5838, 2493, 3134, 2712
5839, 2712, 3213, 2493
5840, 2874, 3134, 2493
5841, 2494, 2756, 2754
5842, 2754, 2757, 2494
5843, 2757, 2871, 2494
5844, 2495, 2610, 2505
5845, 2551, 2964, 2495
5846, 2495, 2964, 2610
5847, 2540, 2541, 2496
5848, 2541, 2625, 2496
5849, 2625, 2969, 2496
5850, 2497, 2618, 2498
5851, 2497, 2628, 2618
5852, 2497, 2926, 2628
5853, 2618, 2763, 2498
5854, 2763, 2795, 2498
5855, 2795, 2867, 2498
5856, 2500, 2510, 2499
5857, 2510, 2621, 2499
5858, 2621, 3002, 2499
5859, 2500, 3010, 2510
5860, 2521, 2522, 2500
5861, 2522, 3010, 2500
5862, 2501, 2517, 2516
5863, 2501, 2804, 2517
5864, 2579, 2804, 2501
5865, 2502, 2755, 2503
5866, 2511, 2558, 2502
5867, 2558, 2755, 2502
5868, 2503, 2606, 2504
5869, 2503, 2609, 2606
5870, 2503, 2755, 2609
5871, 2606, 2607, 2504
5872, 2607, 2740, 2504
5873, 2740, 3030, 2504
5874, 2610, 2638, 2505
5875, 2638, 2639, 2505
5876, 2639, 2988, 2505
5877, 2506, 2563, 2507
5878, 2519, 2733, 2506
5879, 2506, 2733, 2563
5880, 2563, 2564, 2507
5881, 2564, 2565, 2507
5882, 2565, 2991, 2507
5883, 2930, 3105, 2508
5884, 2508, 3109, 2930
5885, 2991, 3109, 2508
5886, 2509, 2588, 2512
5887, 2509, 2685, 2588
5888, 2509, 2918, 2685
5889, 2510, 2730, 2621
5890, 2510, 2731, 2730
5891, 2510, 3010, 2731
5892, 2511, 2559, 2558
5893, 2511, 2734, 2559
5894, 2511, 3005, 2734
5895, 2588, 3020, 2512
5896, 2512, 3009, 2982
5897, 2512, 3020, 3009
5898, 2514, 2515, 2513
5899, 2515, 2910, 2513
5900, 2513, 2910, 2593
5901, 2514, 2575, 2515
5902, 2514, 2896, 2575
5903, 2608, 2896, 2514
5904, 2575, 2591, 2515
5905, 2591, 3003, 2515
5906, 2515, 3003, 2910
5907, 2517, 2592, 2516
5908, 2592, 2779, 2516
5909, 2779, 2895, 2516
5910, 2517, 2611, 2592
5911, 2517, 2626, 2611
5912, 2517, 2804, 2626
5913, 2518, 2787, 2543
5914, 2518, 2788, 2787
5915, 2518, 2972, 2788
5916, 2519, 3139, 2716
5917, 2716, 3193, 2519
5918, 2519, 3193, 2733
5919, 2520, 2819, 2818
5920, 2520, 2959, 2819
5921, 2844, 2959, 2520
5922, 2521, 2523, 2522
5923, 2521, 2758, 2523
5924, 2521, 2948, 2758
5925, 2523, 2524, 2522
5926, 2524, 2651, 2522
5927, 2651, 3010, 2522
5928, 2523, 2525, 2524
5929, 2523, 2529, 2525
5930, 2523, 2758, 2529
5931, 2525, 2526, 2524
5932, 2526, 2762, 2524
5933, 2524, 2762, 2651
5934, 2525, 2527, 2526
5935, 2525, 2750, 2527
5936, 2529, 2750, 2525
5937, 2527, 2528, 2526
5938, 2528, 3106, 2526
5939, 2526, 3106, 2762
5940, 2527, 2661, 2528
5941, 2527, 2678, 2661
5942, 2527, 2750, 2678
5943, 2661, 2662, 2528
5944, 2662, 2677, 2528
5945, 2677, 3106, 2528
5946, 2740, 2750, 2529
5947, 2529, 3015, 2740
5948, 2758, 3015, 2529
5949, 2530, 2532, 2531
5950, 2530, 2968, 2532
5951, 2920, 2968, 2530
5952, 2532, 2533, 2531
5953, 2533, 2938, 2531
5954, 2531, 2938, 2868
5955, 2532, 2534, 2533
5956, 2532, 2535, 2534
5957, 2532, 2968, 2535
5958, 2534, 2622, 2533
5959, 2622, 2623, 2533
5960, 2623, 2938, 2533
5961, 2535, 2598, 2534
5962, 2598, 2890, 2534
5963, 2534, 2890, 2622
5964, 2535, 2599, 2598
5965, 2535, 2796, 2599
5966, 2535, 2968, 2796
5967, 2536, 2604, 2603
5968, 2536, 2794, 2604
5969, 2536, 2978, 2794
5970, 2904, 2949, 2537
5971, 2537, 2981, 2904
5972, 2975, 2981, 2537
5973, 2863, 2864, 2538
5974, 2538, 2865, 2863
5975, 2864, 2971, 2538
5976, 2955, 3066, 2539
5977, 2539, 3038, 2990
5978, 2539, 3066, 3038
5979, 2540, 2620, 2541
5980, 2540, 3069, 2620
5981, 2994, 3069, 2540
5982, 2620, 3219, 2541
5983, 2541, 2635, 2625
5984, 2541, 3219, 2635
5985, 2548, 2549, 2542
5986, 2549, 3004, 2542
5987, 2542, 3004, 2979
5988, 2543, 2545, 2544
5989, 2543, 3024, 2545
5990, 2787, 3024, 2543
5991, 2545, 2594, 2544
5992, 2594, 2674, 2544
5993, 2674, 2933, 2544
5994, 2545, 2759, 2594
5995, 2545, 2760, 2759
5996, 2545, 3024, 2760
5997, 2717, 3139, 2546
5998, 2546, 3156, 2717
5999, 2875, 3156, 2546
6000, 2547, 3047, 2967
6001, 2547, 3054, 3047
6002, 2547, 3060, 3054
6003, 2548, 3027, 2549
6004, 2550, 2589, 2548
6005, 2589, 3027, 2548
6006, 2549, 3095, 3004
6007, 3027, 3098, 2549
6008, 2549, 3098, 3095
6009, 2550, 2722, 2589
6010, 2550, 3009, 2722
6011, 2954, 3009, 2550
6012, 2552, 2553, 2551
6013, 2553, 3113, 2551
6014, 2551, 3113, 2964
6015, 2552, 2554, 2553
6016, 2552, 3008, 2554
6017, 2998, 3008, 2552
6018, 2554, 2582, 2553
6019, 2582, 2636, 2553
6020, 2636, 3113, 2553
6021, 2554, 2583, 2582
6022, 2554, 2790, 2583
6023, 2554, 3008, 2790
6024, 2555, 3089, 2556
6025, 2557, 2590, 2555
6026, 2590, 3089, 2555
6027, 2556, 2578, 2572
6028, 2556, 2680, 2578
6029, 2556, 3089, 2680
6030, 2557, 2688, 2590
6031, 2557, 2689, 2688
6032, 2557, 2985, 2689
6033, 2559, 2560, 2558
6034, 2560, 3121, 2558
6035, 2558, 3121, 2755
6036, 2559, 2561, 2560
6037, 2559, 2752, 2561
6038, 2734, 2752, 2559
6039, 2561, 2686, 2560
6040, 2686, 2687, 2560
6041, 2687, 3121, 2560
6042, 2561, 2738, 2686
6043, 2720, 2738, 2561
6044, 2561, 2752, 2720
6045, 2562, 2634, 2586
6046, 2562, 2682, 2634
6047, 2562, 2986, 2682
6048, 2563, 3145, 2564
6049, 2563, 2733, 2693
6050, 2693, 3145, 2563
6051, 2564, 2566, 2565
6052, 2564, 2567, 2566
6053, 2564, 3145, 2567
6054, 2566, 2587, 2565
6055, 2587, 2764, 2565
6056, 2764, 2991, 2565
6057, 2567, 2568, 2566
6058, 2568, 3110, 2566
6059, 2566, 3110, 2587
6060, 2567, 2569, 2568
6061, 2567, 3168, 2569
6062, 3145, 3168, 2567
6063, 2569, 2570, 2568
6064, 2570, 2741, 2568
6065, 2741, 3110, 2568
6066, 2569, 2571, 2570
6067, 2569, 2627, 2571
6068, 2569, 3168, 2627
6069, 2571, 2789, 2570
6070, 2570, 2742, 2741
6071, 2570, 2789, 2742
6072, 2627, 2673, 2571
6073, 2673, 2675, 2571
6074, 2675, 2789, 2571
6075, 2578, 3128, 2572
6076, 2572, 3150, 3093
6077, 3128, 3150, 2572
6078, 2574, 2746, 2573
6079, 2746, 2747, 2573
6080, 2747, 2943, 2573
6081, 2574, 2749, 2746
6082, 2574, 3107, 2749
6083, 2933, 3107, 2574
6084, 2575, 2619, 2591
6085, 2575, 3131, 2619
6086, 2896, 3131, 2575
6087, 2581, 2624, 2576
6088, 2624, 3059, 2576
6089, 2576, 3059, 2926
6090, 2679, 2736, 2577
6091, 2577, 2995, 2679
6092, 2736, 2737, 2577
6093, 2680, 3122, 2578
6094, 3122, 3126, 2578
6095, 3126, 3128, 2578
6096, 2580, 2664, 2579
6097, 2664, 3140, 2579
6098, 2579, 3140, 2804
6099, 2580, 2665, 2664
6100, 2580, 3016, 2665
6101, 2969, 3016, 2580
6102, 2581, 3220, 2624
6103, 2700, 3115, 2581
6104, 2581, 3144, 2700
6105, 3115, 3220, 2581
6106, 2583, 2584, 2582
6107, 2584, 3141, 2582
6108, 2582, 3141, 2636
6109, 2583, 2585, 2584
6110, 2583, 3019, 2585
6111, 2790, 3019, 2583
6112, 2585, 2612, 2584
6113, 2612, 2666, 2584
6114, 2666, 3141, 2584
6115, 2585, 2613, 2612
6116, 2585, 2766, 2613
6117, 2585, 3019, 2766
6118, 2586, 2602, 2601
6119, 2586, 3143, 2602
6120, 2634, 3143, 2586
6121, 2587, 2924, 2764
6122, 2587, 2925, 2924
6123, 2587, 3110, 2925
6124, 2685, 2996, 2588
6125, 2996, 3104, 2588
6126, 2588, 3104, 3020
6127, 2722, 3022, 2589
6128, 3022, 3100, 2589
6129, 2589, 3100, 3027
6130, 2688, 3092, 2590
6131, 2590, 3091, 3089
6132, 2590, 3092, 3091
6133, 2619, 2759, 2591
6134, 2759, 2760, 2591
6135, 2760, 3003, 2591
6136, 2611, 2754, 2592
6137, 2754, 2756, 2592
6138, 2756, 2779, 2592
6139, 2593, 2909, 2908
6140, 2908, 2951, 2593
6141, 2593, 2910, 2909
6142, 2594, 2681, 2674
6143, 2594, 3108, 2681
6144, 2759, 3108, 2594
6145, 2795, 2796, 2595
6146, 2595, 2867, 2795
6147, 2595, 2940, 2867
6148, 2596, 3007, 2972
6149, 2987, 2999, 2596
6150, 2999, 3007, 2596
6151, 2597, 2997, 2989
6152, 2597, 2998, 2997
6153, 2597, 3008, 2998
6154, 2599, 2605, 2598
6155, 2605, 3157, 2598
6156, 2598, 3157, 2890
6157, 2599, 2763, 2605
6158, 2599, 2795, 2763
6159, 2599, 2796, 2795
6160, 2600, 3060, 2929
6161, 2929, 3063, 2600
6162, 3054, 3060, 2600
6163, 2602, 2780, 2601
6164, 2780, 3063, 2601
6165, 2601, 3063, 2929
6166, 2724, 3167, 2602
6167, 2602, 3201, 2724
6168, 2602, 3167, 2780
6169, 3143, 3201, 2602
6170, 2604, 3051, 2603
6171, 2603, 3051, 3047
6172, 3047, 3054, 2603
6173, 2794, 3032, 2604
6174, 3032, 3041, 2604
6175, 3041, 3051, 2604
6176, 2605, 3112, 2701
6177, 2701, 3157, 2605
6178, 2763, 3112, 2605
6179, 2606, 3111, 2607
6180, 2609, 3170, 2606
6181, 2606, 3170, 3111
6182, 2678, 2750, 2607
6183, 2607, 3111, 2678
6184, 2607, 2750, 2740
6185, 2871, 2872, 2608
6186, 2872, 3138, 2608
6187, 2608, 3138, 2896
6188, 2755, 3184, 2609
6189, 2609, 3046, 3013
6190, 3013, 3170, 2609
6191, 2609, 3184, 3046
6192, 2610, 3207, 2638
6193, 2936, 2937, 2610
6194, 2610, 2964, 2936
6195, 2937, 3207, 2610
6196, 2626, 3215, 2611
6197, 2611, 3117, 2754
6198, 2611, 3215, 3117
6199, 2613, 2614, 2612
6200, 2614, 3166, 2612
6201, 2612, 3166, 2666
6202, 2613, 2615, 2614
6203, 2613, 3026, 2615
6204, 2766, 3026, 2613
6205, 2615, 2616, 2614
6206, 2616, 2637, 2614
6207, 2637, 3166, 2614
6208, 2615, 2617, 2616
6209, 2615, 2892, 2617
6210, 2615, 3026, 2892
6211, 2617, 2629, 2616
6212, 2629, 2767, 2616
6213, 2616, 2767, 2637
6214, 2617, 2630, 2629
6215, 2617, 2631, 2630
6216, 2617, 2892, 2631
6217, 2628, 3155, 2618
6218, 2618, 3112, 2763
6219, 2618, 3155, 3112
6220, 2619, 3108, 2759
6221, 2619, 3200, 3108
6222, 3131, 3200, 2619
6223, 2620, 3167, 2724
6224, 2724, 3178, 2620
6225, 3069, 3167, 2620
6226, 3178, 3219, 2620
6227, 2730, 3210, 2621
6228, 2621, 3196, 3002
6229, 2621, 3210, 3196
6230, 2622, 2719, 2623
6231, 2622, 3162, 2719
6232, 2890, 3162, 2622
6233, 2719, 3160, 2623
6234, 2870, 2938, 2623
6235, 2623, 3160, 2870
6236, 2694, 3149, 2624
6237, 2624, 3220, 2694
6238, 2624, 3149, 3059
6239, 2635, 3209, 2625
6240, 2625, 3016, 2969
6241, 2625, 3209, 3016
6242, 2804, 3216, 2626
6243, 2626, 3137, 2980
6244, 2980, 3215, 2626
6245, 2626, 3216, 3137
6246, 2627, 2690, 2673
6247, 2627, 3203, 2690
6248, 3168, 3203, 2627
6249, 2926, 3059, 2628
6250, 3059, 3206, 2628
6251, 2628, 3206, 3155
6252, 2630, 2632, 2629
6253, 2631, 3040, 2630
6254, 2630, 2633, 2632
6255, 2630, 3040, 2633
6256, 2892, 3037, 2631
6257, 3037, 3039, 2631
6258, 3039, 3040, 2631
6259, 2633, 2667, 2632
6260, 2667, 2732, 2632
6261, 2633, 2668, 2667
6262, 2633, 2751, 2668
6263, 2633, 3040, 2751
6264, 2682, 3125, 2634
6265, 2725, 3197, 2635
6266, 2635, 3219, 2725
6267, 2636, 3132, 3113
6268, 2767, 3204, 2637
6269, 2637, 3204, 3183
6270, 2638, 2640, 2639
6271, 2638, 3191, 2640
6272, 2638, 3207, 3191
6273, 2640, 2641, 2639
6274, 2641, 2805, 2639
6275, 2805, 2988, 2639
6276, 2640, 2642, 2641
6277, 2640, 3171, 2642
6278, 2640, 3191, 3171
6279, 2642, 2643, 2641
6280, 2643, 2644, 2641
6281, 2644, 2805, 2641
6282, 2642, 2676, 2643
6283, 2642, 3159, 2676
6284, 2642, 3171, 3159
6285, 2643, 2645, 2644
6286, 2643, 3158, 2645
6287, 2676, 3158, 2643
6288, 2645, 2646, 2644
6289, 2646, 2941, 2644
6290, 2644, 2941, 2805
6291, 2645, 2647, 2646
6292, 2645, 3218, 2647
6293, 3158, 3218, 2645
6294, 2647, 2648, 2646
6295, 2648, 2649, 2646
6296, 2649, 2941, 2646
6297, 2647, 3182, 2648
6298, 2647, 3133, 2728
6299, 2728, 3182, 2647
6300, 2647, 3218, 3133
6301, 2648, 2650, 2649
6302, 2648, 2652, 2650
6303, 2648, 3182, 2652
6304, 2650, 2947, 2649
6305, 2649, 2942, 2941
6306, 2649, 2947, 2942
6307, 2652, 2653, 2650
6308, 2653, 2654, 2650
6309, 2654, 2947, 2650
6310, 2651, 2762, 2761
6311, 2652, 2659, 2653
6312, 2653, 2655, 2654
6313, 2653, 2939, 2655
6314, 2659, 2939, 2653
6315, 2655, 2656, 2654
6316, 2656, 2777, 2654
6317, 2777, 2947, 2654
6318, 2655, 2657, 2656
6319, 2655, 2658, 2657
6320, 2655, 2939, 2658
6321, 2657, 2927, 2656
6322, 2656, 2778, 2777
6323, 2656, 2927, 2778
6324, 2658, 3049, 2657
6325, 2657, 2928, 2927
6326, 2657, 3049, 2928
6327, 2939, 3175, 2658
6328, 2658, 3052, 3049
6329, 2658, 3175, 3052
6330, 2659, 3148, 2939
6331, 3101, 3148, 2659
6332, 2660, 3119, 2683
6333, 2660, 3198, 3119
6334, 2661, 2678, 2663
6335, 2662, 3202, 2677
6336, 3142, 3202, 2662
6337, 2678, 3111, 2663
6338, 2665, 3165, 2664
6339, 2983, 3140, 2664
6340, 3016, 3194, 2665
6341, 2665, 3190, 3165
6342, 2665, 3194, 3190
6343, 2668, 2669, 2667
6344, 2668, 2670, 2669
6345, 2668, 3048, 2670
6346, 2751, 3048, 2668
6347, 2670, 2671, 2669
6348, 2671, 2729, 2669
6349, 2670, 2672, 2671
6350, 2670, 2743, 2672
6351, 2670, 3048, 2743
6352, 2672, 3124, 2671
6353, 2671, 3088, 2729
6354, 2671, 3124, 3088
6355, 2743, 2744, 2672
6356, 2744, 2745, 2672
6357, 2745, 3124, 2672
6358, 2673, 2679, 2675
6359, 2674, 3107, 2933
6360, 2679, 2995, 2675
6361, 3118, 3158, 2676
6362, 3057, 3106, 2677
6363, 3087, 3122, 2680
6364, 2986, 3127, 2682
6365, 3127, 3208, 2682
6366, 2683, 3119, 2684
6367, 2684, 2738, 2720
6368, 2684, 2739, 2738
6369, 2684, 3119, 2739
6370, 2685, 2918, 2917
6371, 2686, 3154, 2687
6372, 2689, 3085, 2688
6373, 2781, 2782, 2689
6374, 2689, 2985, 2781
6375, 2782, 3085, 2689
6376, 2692, 2693, 2691
6377, 2692, 3145, 2693
6378, 2692, 3168, 3145
6379, 2692, 3203, 3168
6380, 2694, 3220, 3115
6381, 3155, 3206, 2695
6382, 2697, 2698, 2696
6383, 2697, 2699, 2698
6384, 2697, 2700, 2699
6385, 2697, 3115, 2700
6386, 2699, 3129, 2698
6387, 3129, 3211, 2698
6388, 2700, 3214, 2699
6389, 3055, 3199, 2699
6390, 2699, 3214, 3055
6391, 2699, 3199, 3129
6392, 3144, 3214, 2700
6393, 2702, 2713, 2703
6394, 2703, 2705, 2704
6395, 2703, 2706, 2705
6396, 2703, 2713, 2706
6397, 2705, 3160, 2704
6398, 2704, 2719, 2718
6399, 2704, 3160, 2719
6400, 2706, 3151, 2705
6401, 2869, 2870, 2705
6402, 2705, 3151, 2869
6403, 2870, 3160, 2705
6404, 2713, 3134, 2706
6405, 2706, 3134, 2874
6406, 2874, 3151, 2706
6407, 2707, 3162, 2890
6408, 2709, 2711, 2708
6409, 2710, 3096, 2709
6410, 2709, 2712, 2711
6411, 2709, 3096, 2712
6412, 2710, 2735, 2717
6413, 2717, 3156, 2710
6414, 2710, 3156, 3096
6415, 2712, 3134, 2711
6416, 2711, 3134, 2713
6417, 3096, 3213, 2712
6418, 2714, 3193, 2715
6419, 2733, 3193, 2714
6420, 2715, 3193, 2716
6421, 2716, 3139, 2717
6422, 2752, 3068, 2720
6423, 3190, 3194, 2721
6424, 3009, 3020, 2722
6425, 2724, 3201, 2723
6426, 2725, 3219, 3178
6427, 2726, 3208, 2727
6428, 3127, 3175, 2727
6429, 2727, 3208, 3127
6430, 2727, 3175, 3148
6431, 2731, 3195, 2730
6432, 2731, 3212, 3195
6433, 2734, 3005, 2753
6434, 3015, 3030, 2740
6435, 2742, 2934, 2741
6436, 2789, 3116, 2742
6437, 2742, 2935, 2934
6438, 2742, 3116, 2935
6439, 2743, 3053, 2744
6440, 2744, 3061, 2745
6441, 3053, 3058, 2744
6442, 3058, 3061, 2744
6443, 3061, 3147, 2745
6444, 2745, 3136, 3124
6445, 2745, 3147, 3136
6446, 2746, 3217, 2747
6447, 2749, 3185, 2746
6448, 2748, 3199, 2747
6449, 2747, 3217, 2748
6450, 2747, 3055, 2943
6451, 2747, 3199, 3055
6452, 3129, 3199, 2748
6453, 3107, 3163, 2749
6454, 3043, 3048, 2751
6455, 2753, 3005, 2797
6456, 2754, 3117, 2757
6457, 3121, 3184, 2755
6458, 2756, 2952, 2779
6459, 2757, 2872, 2871
6460, 2757, 3181, 2872
6461, 3117, 3181, 2757
6462, 2915, 3003, 2760
6463, 2760, 3024, 2915
6464, 2764, 3109, 2991
6465, 2765, 3030, 3015
6466, 3025, 3026, 2766
6467, 2769, 2791, 2768
6468, 2770, 2771, 2769
6469, 2771, 2773, 2769
6470, 2773, 2791, 2769
6471, 2770, 2772, 2771
6472, 2770, 2775, 2772
6473, 2770, 2922, 2775
6474, 2772, 2792, 2771
6475, 2771, 2774, 2773
6476, 2771, 2792, 2774
6477, 2775, 2776, 2772
6478, 2776, 3135, 2772
6479, 2772, 3135, 2792
6480, 2774, 3176, 2773
6481, 2773, 3196, 2791
6482, 3176, 3196, 2773
6483, 2792, 2793, 2774
6484, 2793, 3164, 2774
6485, 3164, 3176, 2774
6486, 2775, 2888, 2776
6487, 2888, 3114, 2776
6488, 2778, 2932, 2777
6489, 2927, 3042, 2778
6490, 2778, 2946, 2932
6491, 2778, 3042, 2946
6492, 2780, 3167, 3069
6493, 2783, 2784, 2782
6494, 2784, 3085, 2782
6495, 2783, 2785, 2784
6496, 2783, 2786, 2785
6497, 2783, 2970, 2786
6498, 2785, 3084, 2784
6499, 3084, 3086, 2784
6500, 2784, 3086, 3085
6501, 2786, 3083, 2785
6502, 2798, 2799, 2786
6503, 2786, 2970, 2798
6504, 2799, 3083, 2786
6505, 2788, 3018, 2787
6506, 2972, 3007, 2788
6507, 3007, 3014, 2788
6508, 3014, 3018, 2788
6509, 3017, 3019, 2790
6510, 3196, 3210, 2791
6511, 3093, 3150, 2793
6512, 3150, 3164, 2793
6513, 2993, 3032, 2794
6514, 2800, 2801, 2799
6515, 2801, 3083, 2799
6516, 2800, 2802, 2801
6517, 2800, 2803, 2802
6518, 2800, 2963, 2803
6519, 2802, 3081, 2801
6520, 3081, 3082, 2801
6521, 3082, 3083, 2801
6522, 2803, 3078, 2802
6523, 2845, 2846, 2803
6524, 2803, 2963, 2845
6525, 2846, 3078, 2803
6526, 3140, 3216, 2804
6527, 2806, 2873, 2807
6528, 2807, 2809, 2808
6529, 2807, 2810, 2809
6530, 2807, 2873, 2810
6531, 2809, 3067, 2808
6532, 2808, 2812, 2811
6533, 2808, 3067, 2812
6534, 2810, 3062, 2809
6535, 3062, 3064, 2809
6536, 3064, 3067, 2809
6537, 2873, 3056, 2810
6538, 2812, 2813, 2811
6539, 2812, 2814, 2813
6540, 2812, 2817, 2814
6541, 2812, 3067, 2817
6542, 2814, 2816, 2815
6543, 2814, 2817, 2816
6544, 2816, 3073, 2815
6545, 2850, 2891, 2815
6546, 2815, 3073, 2850
6547, 2817, 3071, 2816
6548, 3071, 3072, 2816
6549, 3072, 3073, 2816
6550, 2819, 2821, 2820
6551, 2819, 2959, 2821
6552, 2821, 2822, 2820
6553, 2822, 2984, 2820
6554, 2820, 2984, 2894
6555, 2821, 2823, 2822
6556, 2821, 2825, 2823
6557, 2821, 2959, 2825
6558, 2823, 2824, 2822
6559, 2824, 2826, 2822
6560, 2826, 2984, 2822
6561, 2823, 3031, 2824
6562, 2825, 2829, 2823
6563, 2829, 3031, 2823
6564, 2824, 2827, 2826
6565, 2824, 2833, 2827
6566, 2824, 3031, 2833
6567, 2825, 2830, 2829
6568, 2825, 2834, 2830
6569, 2825, 2959, 2834
6570, 2827, 2828, 2826
6571, 2828, 2843, 2826
6572, 2843, 2984, 2826
6573, 2827, 2831, 2828
6574, 2827, 3090, 2831
6575, 2833, 3090, 2827
6576, 2831, 2832, 2828
6577, 2832, 2974, 2828
6578, 2828, 2974, 2843
6579, 2830, 3080, 2829
6580, 3028, 3031, 2829
6581, 2829, 3080, 3028
6582, 2834, 2835, 2830
6583, 2835, 2836, 2830
6584, 2836, 3080, 2830
6585, 2831, 3094, 2832
6586, 2831, 3090, 3035
6587, 3035, 3094, 2831
6588, 2913, 2974, 2832
6589, 2832, 3095, 2913
6590, 3094, 3095, 2832
6591, 3036, 3090, 2833
6592, 2834, 2959, 2844
6593, 2835, 2837, 2836
6594, 2835, 3012, 2837
6595, 2837, 2838, 2836
6596, 2838, 3079, 2836
6597, 3079, 3080, 2836
6598, 2837, 2839, 2838
6599, 2837, 2841, 2839
6600, 2837, 3012, 2841
6601, 2839, 2840, 2838
6602, 2840, 3076, 2838
6603, 3076, 3079, 2838
6604, 2839, 3034, 2840
6605, 2841, 2842, 2839
6606, 2842, 3034, 2839
6607, 3033, 3076, 2840
6608, 2841, 2906, 2842
6609, 2842, 2906, 2905
6610, 2905, 2907, 2842
6611, 2907, 3034, 2842
6612, 2950, 2984, 2843
6613, 2847, 2848, 2846
6614, 2848, 3078, 2846
6615, 2847, 2849, 2848
6616, 2847, 2850, 2849
6617, 2847, 2958, 2850
6618, 2849, 3075, 2848
6619, 3075, 3077, 2848
6620, 3077, 3078, 2848
6621, 2850, 3073, 2849
6622, 2850, 2958, 2891
6623, 2852, 2866, 2851
6624, 2853, 2854, 2852
6625, 2854, 2862, 2852
6626, 2862, 2866, 2852
6627, 2853, 2855, 2854
6628, 2853, 2960, 2855
6629, 2923, 2960, 2853
6630, 2855, 2856, 2854
6631, 2856, 3045, 2854
6632, 2854, 3045, 2862
6633, 2855, 2857, 2856
6634, 2855, 2860, 2857
6635, 2855, 2960, 2860
6636, 2857, 2858, 2856
6637, 2858, 3070, 2856
6638, 2856, 3070, 3045
6639, 2857, 2859, 2858
6640, 2857, 2961, 2859
6641, 2860, 2961, 2857
6642, 2859, 2861, 2858
6643, 2861, 3066, 2858
6644, 3066, 3070, 2858
6645, 2859, 2863, 2861
6646, 2859, 2864, 2863
6647, 2859, 2961, 2864
6648, 2944, 2945, 2860
6649, 2860, 2960, 2944
6650, 2945, 2961, 2860
6651, 2863, 3029, 2861
6652, 3029, 3038, 2861
6653, 3038, 3066, 2861
6654, 2862, 3056, 2866
6655, 3045, 3065, 2862
6656, 2862, 3065, 3056
6657, 2865, 3029, 2863
6658, 3006, 3029, 2865
6659, 2866, 3056, 2873
6660, 2872, 3181, 2973
6661, 3096, 3156, 2875
6662, 2877, 2888, 2876
6663, 2878, 2879, 2877
6664, 2879, 3114, 2877
6665, 2877, 3114, 2888
6666, 2878, 2880, 2879
6667, 2878, 3074, 2880
6668, 2887, 3074, 2878
6669, 3011, 3114, 2879
6670, 2880, 3161, 2881
6671, 3074, 3161, 2880
6672, 2881, 3161, 2882
6673, 2882, 2884, 2883
6674, 2882, 2886, 2884
6675, 2882, 3161, 2886
6676, 2884, 2885, 2883
6677, 2885, 3186, 2883
6678, 2883, 3186, 3146
6679, 2884, 3130, 2885
6680, 2886, 3192, 2884
6681, 2884, 3192, 3130
6682, 3120, 3186, 2885
6683, 2885, 3187, 3120
6684, 3130, 3187, 2885
6685, 2893, 3192, 2886
6686, 2886, 3161, 3074
6687, 2889, 2999, 2931
6688, 2894, 2984, 2950
6689, 2896, 3221, 3131
6690, 3138, 3221, 2896
6691, 2898, 3130, 2897
6692, 2899, 2900, 2898
6693, 2900, 3187, 2898
6694, 2898, 3187, 3130
6695, 2899, 3147, 2900
6696, 2901, 3136, 2899
6697, 3136, 3147, 2899
6698, 2900, 3152, 3120
6699, 3120, 3187, 2900
6700, 3147, 3152, 2900
6701, 2903, 2914, 2902
6702, 2904, 2905, 2903
6703, 2905, 2906, 2903
6704, 2906, 2914, 2903
6705, 2904, 2981, 2905
6706, 2905, 2981, 2907
6707, 3023, 3034, 2907
6708, 2911, 2913, 2912
6709, 2911, 2974, 2913
6710, 2913, 3098, 2912
6711, 3095, 3098, 2913
6712, 2917, 2930, 2916
6713, 2916, 2930, 2919
6714, 2918, 3105, 2917
6715, 2917, 3105, 2930
6716, 2930, 3109, 2919
6717, 3171, 3191, 2921
6718, 2928, 3044, 2976
6719, 2928, 3049, 3044
6720, 2931, 2999, 2987
6721, 3148, 3175, 2939
6722, 2953, 3041, 2957
6723, 2953, 3051, 3041
6724, 2982, 3009, 2954
6725, 2955, 3070, 3066
6726, 2956, 3032, 2993
6727, 2962, 3050, 3021
6728, 2962, 3126, 3050
6729, 2965, 3221, 3138
6730, 2966, 3200, 3131
6731, 2977, 3079, 3076
6732, 3052, 3127, 2986
6733, 3120, 3152, 2992
6734, 3000, 3150, 3128
6735, 3000, 3164, 3150
6736, 3021, 3050, 3001
6737, 3002, 3196, 3176
6738, 3004, 3095, 3094
6739, 3016, 3209, 3194
6740, 3050, 3126, 3122
6741, 3052, 3175, 3127
6742, 3061, 3152, 3147
6743, 3123, 3202, 3142
*ELEMENT, type=CPS3, ELSET=Surface8
6744, 2, 13, 3296
6745, 144, 2, 3296
6746, 27, 3, 3298
6747, 3, 148, 3298
6748, 8, 147, 3297
6749, 152, 8, 3297
6750, 151, 9, 3295
6751, 9, 166, 3295
6752, 13, 14, 3279
6753, 13, 3279, 3296
6754, 14, 15, 3231
6755, 14, 3231, 3279
6756, 15, 16, 3270
6757, 3231, 15, 3270
6758, 16, 17, 3287
6759, 3270, 16, 3287
6760, 17, 18, 3226
6761, 17, 3226, 3287
6762, 18, 19, 3281
6763, 3226, 18, 3281
6764, 19, 20, 3223
6765, 19, 3223, 3281
6766, 20, 21, 3273
6767, 3223, 20, 3273
6768, 21, 22, 3227
6769, 21, 3227, 3273
6770, 22, 23, 3256
6771, 3227, 22, 3256
6772, 23, 24, 3290
6773, 3256, 23, 3290
6774, 24, 25, 3225
6775, 24, 3225, 3290
6776, 25, 26, 3283
6777, 3225, 25, 3283
6778, 26, 27, 3234
6779, 26, 3234, 3283
6780, 3234, 27, 3298
6781, 145, 144, 3257
6782, 3257, 144, 3296
6783, 146, 145, 3232
6784, 3232, 145, 3257
6785, 147, 146, 3277
6786, 146, 3232, 3277
6787, 147, 3277, 3297
6788, 148, 149, 3276
6789, 148, 3276, 3298
6790, 149, 150, 3233
6791, 149, 3233, 3276
6792, 150, 151, 3236
6793, 3233, 150, 3236
6794, 3236, 151, 3295
6795, 153, 152, 3235
6796, 3235, 152, 3297
6797, 154, 153, 3284
6798, 153, 3235, 3284
6799, 155, 154, 3224
6800, 3224, 154, 3284
6801, 156, 155, 3291
6802, 155, 3224, 3291
6803, 157, 156, 3271
6804, 3271, 156, 3291
6805, 158, 157, 3230
6806, 3230, 157, 3271
6807, 159, 158, 3274
6808, 158, 3230, 3274
6809, 160, 159, 3228
6810, 3228, 159, 3274
6811, 161, 160, 3275
6812, 160, 3228, 3275
6813, 162, 161, 3222
6814, 3222, 161, 3275
6815, 163, 162, 3293
6816, 162, 3222, 3293
6817, 164, 163, 3255
6818, 3255, 163, 3293
6819, 165, 164, 3229
6820, 3229, 164, 3255
6821, 166, 165, 3280
6822, 165, 3229, 3280
6823, 166, 3280, 3295
6824, 3246, 3222, 3248
6825, 3222, 3246, 3250
6826, 3248, 3222, 3275
6827, 3222, 3250, 3293
6828, 3223, 3273, 3294
6829, 3223, 3278, 3281
6830, 3278, 3223, 3294
6831, 3224, 3261, 3262
6832, 3261, 3224, 3284
6833, 3224, 3262, 3265
6834, 3224, 3265, 3291
6835, 3225, 3240, 3241
6836, 3240, 3225, 3283
6837, 3225, 3241, 3244
6838, 3225, 3244, 3290
6839, 3226, 3267, 3268
6840, 3267, 3226, 3269
6841, 3226, 3268, 3287
6842, 3269, 3226, 3281
6843, 3227, 3251, 3273
6844, 3251, 3227, 3288
6845, 3227, 3256, 3288
6846, 3253, 3228, 3274
6847, 3228, 3253, 3292
6848, 3275, 3228, 3292
6849, 3229, 3255, 3286
6850, 3280, 3229, 3303
6851, 3229, 3286, 3303
6852, 3230, 3271, 3289
6853, 3274, 3230, 3282
6854, 3282, 3230, 3289
6855, 3231, 3270, 3285
6856, 3279, 3231, 3302
6857, 3231, 3285, 3302
6858, 3232, 3257, 3258
6859, 3232, 3258, 3259
6860, 3232, 3259, 3277
6861, 3233, 3236, 3237
6862, 3233, 3237, 3238
6863, 3233, 3238, 3276
6864, 3276, 3234, 3298
6865, 3234, 3276, 3300
6866, 3283, 3234, 3300
6867, 3277, 3235, 3297
6868, 3235, 3277, 3301
6869, 3284, 3235, 3301
6870, 3237, 3236, 3303
6871, 3280, 3236, 3295
6872, 3236, 3280, 3303
6873, 3238, 3237, 3239
6874, 3239, 3237, 3286
6875, 3286, 3237, 3303
6876, 3238, 3239, 3240
6877, 3238, 3240, 3300
6878, 3276, 3238, 3300
6879, 3240, 3239, 3241
6880, 3241, 3239, 3242
6881, 3242, 3239, 3286
6882, 3240, 3283, 3300
6883, 3241, 3242, 3243
6884, 3241, 3243, 3244
6885, 3243, 3242, 3250
6886, 3250, 3242, 3255
6887, 3255, 3242, 3286
6888, 3244, 3243, 3245
6889, 3245, 3243, 3246
6890, 3246, 3243, 3250
6891, 3244, 3245, 3256
6892, 3244, 3256, 3290
6893, 3245, 3246, 3247
6894, 3245, 3247, 3288
6895, 3256, 3245, 3288
6896, 3247, 3246, 3248
6897, 3247, 3248, 3249
6898, 3247, 3249, 3251
6899, 3247, 3251, 3288
6900, 3249, 3248, 3292
6901, 3248, 3275, 3292
6902, 3251, 3249, 3252
6903, 3252, 3249, 3253
6904, 3253, 3249, 3292
6905, 3250, 3255, 3293
6906, 3251, 3252, 3294
6907, 3273, 3251, 3294
6908, 3252, 3253, 3254
6909, 3252, 3254, 3278
6910, 3252, 3278, 3294
6911, 3254, 3253, 3282
6912, 3253, 3274, 3282
6913, 3272, 3254, 3282
6914, 3254, 3272, 3299
6915, 3278, 3254, 3299
6916, 3258, 3257, 3302
6917, 3279, 3257, 3296
6918, 3257, 3279, 3302
6919, 3259, 3258, 3260
6920, 3260, 3258, 3285
6921, 3285, 3258, 3302
6922, 3259, 3260, 3261
6923, 3259, 3261, 3301
6924, 3277, 3259, 3301
6925, 3261, 3260, 3262
6926, 3262, 3260, 3263
6927, 3263, 3260, 3285
6928, 3261, 3284, 3301
6929, 3262, 3263, 3264
6930, 3262, 3264, 3265
6931, 3264, 3263, 3268
6932, 3268, 3263, 3270
6933, 3270, 3263, 3285
6934, 3265, 3264, 3266
6935, 3266, 3264, 3267
6936, 3267, 3264, 3268
6937, 3265, 3266, 3271
6938, 3265, 3271, 3291
6939, 3266, 3267, 3272
6940, 3271, 3266, 3289
6941, 3266, 3272, 3289
6942, 3267, 3269, 3272
6943, 3268, 3270, 3287
6944, 3272, 3269, 3299
6945, 3278, 3269, 3281
6946, 3269, 3278, 3299
6947, 3272, 3282, 3289
*ELEMENT, type=CPS3, ELSET=Surface9
6948, 143, 2, 3468
6949, 2, 144, 3468
6950, 7, 111, 3467
6951, 236, 7, 3467
6952, 147, 8, 3466
6953, 8, 294, 3466
6954, 12, 239, 3469
6955, 262, 12, 3469
6956, 111, 112, 3452
6957, 111, 3452, 3467
6958, 112, 113, 3333
6959, 112, 3333, 3452
6960, 113, 114, 3424
6961, 3333, 113, 3424
6962, 114, 115, 3304
6963, 114, 3304, 3424
6964, 115, 116, 3420
6965, 3304, 115, 3420
6966, 116, 117, 3308
6967, 116, 3308, 3420
6968, 117, 118, 3458
6969, 3308, 117, 3458
6970, 118, 119, 3324
6971, 118, 3324, 3458
6972, 119, 120, 3412
6973, 3324, 119, 3412
6974, 120, 121, 3413
6975, 3412, 120, 3413
6976, 121, 122, 3309
6977, 121, 3309, 3413
6978, 122, 123, 3422
6979, 3309, 122, 3422
6980, 123, 124, 3313
6981, 123, 3313, 3422
6982, 124, 125, 3415
6983, 3313, 124, 3415
6984, 125, 126, 3305
6985, 125, 3305, 3415
6986, 126, 127, 3416
6987, 3305, 126, 3416
6988, 127, 128, 3315
6989, 127, 3315, 3416
6990, 128, 129, 3419
6991, 3315, 128, 3419
6992, 129, 130, 3310
6993, 129, 3310, 3419
6994, 130, 131, 3446
6995, 3310, 130, 3446
6996, 131, 132, 3429
6997, 131, 3429, 3446
6998, 132, 133, 3326
6999, 132, 3326, 3429
7000, 133, 134, 3414
7001, 3326, 133, 3414
7002, 134, 135, 3307
7003, 134, 3307, 3414
7004, 135, 136, 3417
7005, 3307, 135, 3417
7006, 136, 137, 3311
7007, 136, 3311, 3417
7008, 137, 138, 3423
7009, 3311, 137, 3423
7010, 138, 139, 3312
7011, 138, 3312, 3423
7012, 139, 140, 3463
7013, 3312, 139, 3463
7014, 140, 141, 3314
7015, 140, 3314, 3463
7016, 141, 142, 3456
7017, 3314, 141, 3456
7018, 142, 143, 3334
7019, 142, 3334, 3456
7020, 3334, 143, 3468
7021, 144, 145, 3449
7022, 144, 3449, 3468
7023, 145, 146, 3332
7024, 145, 3332, 3449
7025, 146, 147, 3336
7026, 3332, 146, 3336
7027, 3336, 147, 3466
7028, 237, 236, 3348
7029, 3348, 236, 3467
7030, 238, 237, 3317
7031, 3317, 237, 3348
7032, 239, 238, 3450
7033, 238, 3317, 3450
7034, 239, 3450, 3469
7035, 263, 262, 3335
7036, 3335, 262, 3469
7037, 264, 263, 3457
7038, 263, 3335, 3457
7039, 265, 264, 3321
7040, 3321, 264, 3457
7041, 266, 265, 3465
7042, 265, 3321, 3465
7043, 267, 266, 3325
7044, 3325, 266, 3465
7045, 268, 267, 3411
7046, 267, 3325, 3411
7047, 269, 268, 3318
7048, 3318, 268, 3411
7049, 270, 269, 3403
7050, 269, 3318, 3403
7051, 271, 270, 3306
7052, 3306, 270, 3403
7053, 272, 271, 3399
7054, 271, 3306, 3399
7055, 273, 272, 3400
7056, 272, 3399, 3400
7057, 274, 273, 3331
7058, 3331, 273, 3400
7059, 275, 274, 3391
7060, 274, 3331, 3391
7061, 276, 275, 3322
7062, 3322, 275, 3391
7063, 277, 276, 3388
7064, 276, 3322, 3388
7065, 278, 277, 3319
7066, 3319, 277, 3388
7067, 279, 278, 3382
7068, 278, 3319, 3382
7069, 280, 279, 3328
7070, 3328, 279, 3382
7071, 281, 280, 3378
7072, 280, 3328, 3378
7073, 282, 281, 3379
7074, 281, 3378, 3379
7075, 283, 282, 3316
7076, 3316, 282, 3379
7077, 284, 283, 3369
7078, 283, 3316, 3369
7079, 285, 284, 3323
7080, 3323, 284, 3369
7081, 286, 285, 3366
7082, 285, 3323, 3366
7083, 287, 286, 3327
7084, 3327, 286, 3366
7085, 288, 287, 3360
7086, 287, 3327, 3360
7087, 289, 288, 3330
7088, 3330, 288, 3360
7089, 290, 289, 3421
7090, 289, 3330, 3421
7091, 291, 290, 3329
7092, 3329, 290, 3421
7093, 292, 291, 3418
7094, 291, 3329, 3418
7095, 293, 292, 3320
7096, 3320, 292, 3418
7097, 294, 293, 3451
7098, 293, 3320, 3451
7099, 294, 3451, 3466
7100, 3304, 3420, 3470
7101, 3424, 3304, 3460
7102, 3460, 3304, 3470
7103, 3415, 3305, 3440
7104, 3305, 3416, 3437
7105, 3305, 3437, 3440
7106, 3399, 3306, 3401
7107, 3401, 3306, 3402
7108, 3402, 3306, 3403
7109, 3414, 3307, 3438
7110, 3307, 3417, 3433
7111, 3307, 3433, 3438
7112, 3409, 3308, 3410
7113, 3308, 3409, 3464
7114, 3410, 3308, 3458
7115, 3420, 3308, 3464
7116, 3413, 3309, 3435
7117, 3309, 3422, 3436
7118, 3435, 3309, 3436
7119, 3419, 3310, 3439
7120, 3310, 3430, 3439
7121, 3430, 3310, 3446
7122, 3417, 3311, 3434
7123, 3311, 3423, 3448
7124, 3434, 3311, 3448
7125, 3312, 3344, 3345
7126, 3344, 3312, 3463
7127, 3312, 3345, 3454
7128, 3423, 3312, 3454
7129, 3313, 3415, 3442
7130, 3422, 3313, 3432
7131, 3432, 3313, 3442
7132, 3314, 3340, 3341
7133, 3340, 3314, 3456
7134, 3314, 3341, 3344
7135, 3314, 3344, 3463
7136, 3416, 3315, 3431
7137, 3315, 3419, 3443
7138, 3431, 3315, 3443
7139, 3369, 3316, 3371
7140, 3371, 3316, 3372
7141, 3372, 3316, 3379
7142, 3317, 3348, 3349
7143, 3317, 3349, 3350
7144, 3317, 3350, 3450
7145, 3403, 3318, 3405
7146, 3405, 3318, 3408
7147, 3408, 3318, 3411
7148, 3382, 3319, 3384
7149, 3384, 3319, 3385
7150, 3385, 3319, 3388
7151, 3320, 3337, 3451
7152, 3337, 3320, 3459
7153, 3320, 3418, 3459
7154, 3321, 3352, 3353
7155, 3352, 3321, 3457
7156, 3321, 3353, 3356
7157, 3321, 3356, 3465
7158, 3388, 3322, 3389
7159, 3389, 3322, 3390
7160, 3390, 3322, 3391
7161, 3366, 3323, 3367
7162, 3367, 3323, 3368
7163, 3368, 3323, 3369
7164, 3410, 3324, 3447
7165, 3324, 3410, 3458
7166, 3324, 3412, 3447
7167, 3325, 3356, 3357
7168, 3356, 3325, 3465
7169, 3325, 3357, 3455
7170, 3411, 3325, 3455
7171, 3326, 3414, 3441
7172, 3429, 3326, 3445
7173, 3326, 3441, 3445
7174, 3360, 3327, 3361
7175, 3361, 3327, 3362
7176, 3362, 3327, 3366
7177, 3378, 3328, 3380
7178, 3380, 3328, 3381
7179, 3381, 3328, 3382
7180, 3418, 3329, 3462
7181, 3329, 3421, 3471
7182, 3462, 3329, 3471
7183, 3330, 3360, 3370
7184, 3330, 3370, 3453
7185, 3421, 3330, 3453
7186, 3391, 3331, 3393
7187, 3393, 3331, 3394
7188, 3394, 3331, 3400
7189, 3332, 3336, 3337
7190, 3332, 3337, 3338
7191, 3332, 3338, 3449
7192, 3333, 3349, 3452
7193, 3349, 3333, 3461
7194, 3333, 3424, 3461
7195, 3334, 3338, 3340
7196, 3338, 3334, 3449
7197, 3334, 3340, 3456
7198, 3449, 3334, 3468
7199, 3335, 3350, 3352
7200, 3350, 3335, 3450
7201, 3335, 3352, 3457
7202, 3450, 3335, 3469
7203, 3337, 3336, 3451
7204, 3451, 3336, 3466
7205, 3338, 3337, 3339
7206, 3339, 3337, 3459
7207, 3338, 3339, 3340
7208, 3340, 3339, 3341
7209, 3341, 3339, 3342
7210, 3342, 3339, 3459
7211, 3341, 3342, 3343
7212, 3341, 3343, 3344
7213, 3343, 3342, 3462
7214, 3418, 3342, 3459
7215, 3342, 3418, 3462
7216, 3344, 3343, 3345
7217, 3345, 3343, 3346
7218, 3346, 3343, 3462
7219, 3345, 3346, 3347
7220, 3345, 3347, 3454
7221, 3347, 3346, 3453
7222, 3453, 3346, 3471
7223, 3346, 3462, 3471
7224, 3347, 3448, 3454
7225, 3448, 3347, 3472
7226, 3347, 3453, 3472
7227, 3349, 3348, 3452
7228, 3452, 3348, 3467
7229, 3350, 3349, 3351
7230, 3351, 3349, 3461
7231, 3350, 3351, 3352
7232, 3352, 3351, 3353
7233, 3353, 3351, 3354
7234, 3354, 3351, 3461
7235, 3353, 3354, 3355
7236, 3353, 3355, 3356
7237, 3355, 3354, 3460
7238, 3354, 3424, 3460
7239, 3424, 3354, 3461
7240, 3356, 3355, 3357
7241, 3357, 3355, 3358
7242, 3358, 3355, 3460
7243, 3357, 3358, 3359
7244, 3357, 3359, 3455
7245, 3359, 3358, 3464
7246, 3358, 3460, 3470
7247, 3464, 3358, 3470
7248, 3359, 3407, 3408
7249, 3407, 3359, 3409
7250, 3359, 3408, 3455
7251, 3409, 3359, 3464
7252, 3360, 3361, 3370
7253, 3361, 3362, 3363
7254, 3361, 3363, 3365
7255, 3361, 3365, 3370
7256, 3363, 3362, 3364
7257, 3364, 3362, 3367
7258, 3362, 3366, 3367
7259, 3363, 3364, 3433
7260, 3365, 3363, 3434
7261, 3363, 3433, 3434
7262, 3364, 3367, 3425
7263, 3364, 3425, 3438
7264, 3433, 3364, 3438
7265, 3370, 3365, 3472
7266, 3365, 3434, 3448
7267, 3365, 3448, 3472
7268, 3367, 3368, 3425
7269, 3368, 3369, 3371
7270, 3368, 3371, 3383
7271, 3368, 3383, 3425
7272, 3453, 3370, 3472
7273, 3371, 3372, 3373
7274, 3371, 3373, 3383
7275, 3373, 3372, 3374
7276, 3374, 3372, 3375
7277, 3375, 3372, 3379
7278, 3373, 3374, 3377
7279, 3373, 3377, 3445
7280, 3383, 3373, 3445
7281, 3374, 3375, 3376
7282, 3374, 3376, 3430
7283, 3377, 3374, 3430
7284, 3376, 3375, 3380
7285, 3378, 3375, 3379
7286, 3375, 3378, 3380
7287, 3376, 3380, 3427
7288, 3376, 3427, 3439
7289, 3430, 3376, 3439
7290, 3377, 3429, 3445
7291, 3429, 3377, 3446
7292, 3377, 3430, 3446
7293, 3380, 3381, 3427
7294, 3381, 3382, 3384
7295, 3381, 3384, 3392
7296, 3381, 3392, 3427
7297, 3425, 3383, 3441
7298, 3441, 3383, 3445
7299, 3384, 3385, 3386
7300, 3384, 3386, 3392
7301, 3386, 3385, 3387
7302, 3387, 3385, 3389
7303, 3385, 3388, 3389
7304, 3386, 3387, 3437
7305, 3392, 3386, 3431
7306, 3431, 3386, 3437
7307, 3387, 3389, 3426
7308, 3387, 3426, 3440
7309, 3437, 3387, 3440
7310, 3389, 3390, 3426
7311, 3390, 3391, 3393
7312, 3390, 3393, 3404
7313, 3390, 3404, 3426
7314, 3427, 3392, 3443
7315, 3392, 3431, 3443
7316, 3393, 3394, 3395
7317, 3393, 3395, 3404
7318, 3395, 3394, 3396
7319, 3396, 3394, 3397
7320, 3397, 3394, 3400
7321, 3395, 3396, 3436
7322, 3404, 3395, 3432
7323, 3432, 3395, 3436
7324, 3396, 3397, 3398
7325, 3396, 3398, 3435
7326, 3396, 3435, 3436
7327, 3398, 3397, 3401
7328, 3399, 3397, 3400
7329, 3397, 3399, 3401
7330, 3398, 3401, 3428
7331, 3398, 3428, 3444
7332, 3435, 3398, 3444
7333, 3401, 3402, 3428
7334, 3402, 3403, 3405
7335, 3402, 3405, 3406
7336, 3402, 3406, 3428
7337, 3426, 3404, 3442
7338, 3404, 3432, 3442
7339, 3406, 3405, 3407
7340, 3407, 3405, 3408
7341, 3406, 3407, 3410
7342, 3406, 3410, 3447
7343, 3428, 3406, 3447
7344, 3407, 3409, 3410
7345, 3408, 3411, 3455
7346, 3412, 3413, 3444
7347, 3412, 3444, 3447
7348, 3413, 3435, 3444
7349, 3414, 3438, 3441
7350, 3415, 3440, 3442
7351, 3416, 3431, 3437
7352, 3433, 3417, 3434
7353, 3419, 3439, 3443
7354, 3420, 3464, 3470
7355, 3421, 3453, 3471
7356, 3422, 3432, 3436
7357, 3448, 3423, 3454
7358, 3438, 3425, 3441
7359, 3440, 3426, 3442
7360, 3439, 3427, 3443
7361, 3444, 3428, 3447
*ELEMENT, type=CPS3, ELSET=Surface10
7362, 6, 89, 3583
7363, 212, 6, 3583
7364, 110, 7, 3581
7365, 7, 236, 3581
7366, 11, 215, 3580
7367, 240, 11, 3580
7368, 239, 12, 3584
7369, 12, 261, 3584
7370, 89, 90, 3492
7371, 89, 3492, 3583
7372, 90, 91, 3572
7373, 3492, 90, 3572
7374, 91, 92, 3480
7375, 91, 3480, 3572
7376, 92, 93, 3571
7377, 3480, 92, 3571
7378, 93, 94, 3477
7379, 93, 3477, 3571
7380, 94, 95, 3566
7381, 3477, 94, 3566
7382, 95, 96, 3479
7383, 95, 3479, 3566
7384, 96, 97, 3523
7385, 3479, 96, 3523
7386, 97, 98, 3475
7387, 97, 3475, 3523
7388, 98, 99, 3553
7389, 3475, 98, 3553
7390, 99, 100, 3558
7391, 3553, 99, 3558
7392, 100, 101, 3476
7393, 100, 3476, 3558
7394, 101, 102, 3538
7395, 3476, 101, 3538
7396, 102, 103, 3478
7397, 102, 3478, 3538
7398, 103, 104, 3544
7399, 3478, 103, 3544
7400, 104, 105, 3489
7401, 104, 3489, 3544
7402, 105, 106, 3549
7403, 3489, 105, 3549
7404, 106, 107, 3473
7405, 106, 3473, 3549
7406, 107, 108, 3551
7407, 3473, 107, 3551
7408, 108, 109, 3491
7409, 108, 3491, 3551
7410, 109, 110, 3563
7411, 3491, 109, 3563
7412, 3563, 110, 3581
7413, 213, 212, 3560
7414, 3560, 212, 3583
7415, 214, 213, 3490
7416, 3490, 213, 3560
7417, 215, 214, 3494
7418, 214, 3490, 3494
7419, 215, 3494, 3580
7420, 236, 237, 3511
7421, 236, 3511, 3581
7422, 237, 238, 3481
7423, 237, 3481, 3511
7424, 238, 239, 3561
7425, 3481, 238, 3561
7426, 3561, 239, 3584
7427, 241, 240, 3562
7428, 3562, 240, 3580
7429, 242, 241, 3487
7430, 3487, 241, 3562
7431, 243, 242, 3524
7432, 242, 3487, 3524
7433, 244, 243, 3488
7434, 3488, 243, 3524
7435, 245, 244, 3541
7436, 244, 3488, 3541
7437, 246, 245, 3485
7438, 3485, 245, 3541
7439, 247, 246, 3525
7440, 246, 3485, 3525
7441, 248, 247, 3486
7442, 3486, 247, 3525
7443, 249, 248, 3539
7444, 248, 3486, 3539
7445, 250, 249, 3484
7446, 3484, 249, 3539
7447, 251, 250, 3543
7448, 250, 3484, 3543
7449, 252, 251, 3546
7450, 251, 3543, 3546
7451, 253, 252, 3483
7452, 3483, 252, 3546
7453, 254, 253, 3526
7454, 253, 3483, 3526
7455, 255, 254, 3547
7456, 254, 3526, 3547
7457, 256, 255, 3474
7458, 3474, 255, 3547
7459, 257, 256, 3537
7460, 256, 3474, 3537
7461, 258, 257, 3577
7462, 257, 3537, 3577
7463, 259, 258, 3482
7464, 3482, 258, 3577
7465, 260, 259, 3573
7466, 259, 3482, 3573
7467, 261, 260, 3493
7468, 3493, 260, 3573
7469, 261, 3493, 3584
7470, 3549, 3473, 3585
7471, 3473, 3551, 3569
7472, 3473, 3569, 3585
7473, 3537, 3474, 3576
7474, 3474, 3547, 3548
7475, 3474, 3548, 3576
7476, 3523, 3475, 3565
7477, 3475, 3553, 3557
7478, 3475, 3557, 3565
7479, 3476, 3538, 3556
7480, 3552, 3476, 3556
7481, 3476, 3552, 3558
7482, 3502, 3477, 3503
7483, 3477, 3502, 3571
7484, 3503, 3477, 3504
7485, 3504, 3477, 3566
7486, 3538, 3478, 3555
7487, 3478, 3544, 3554
7488, 3478, 3554, 3555
7489, 3509, 3479, 3523
7490, 3479, 3509, 3579
7491, 3566, 3479, 3579
7492, 3498, 3480, 3499
7493, 3480, 3498, 3572
7494, 3499, 3480, 3502
7495, 3502, 3480, 3571
7496, 3511, 3481, 3512
7497, 3512, 3481, 3513
7498, 3513, 3481, 3561
7499, 3515, 3482, 3516
7500, 3482, 3515, 3573
7501, 3516, 3482, 3517
7502, 3517, 3482, 3577
7503, 3526, 3483, 3527
7504, 3527, 3483, 3528
7505, 3528, 3483, 3546
7506, 3534, 3484, 3540
7507, 3484, 3534, 3543
7508, 3484, 3539, 3540
7509, 3485, 3507, 3525
7510, 3507, 3485, 3570
7511, 3485, 3541, 3570
7512, 3486, 3525, 3582
7513, 3539, 3486, 3564
7514, 3564, 3486, 3582
7515, 3495, 3487, 3562
7516, 3487, 3495, 3574
7517, 3524, 3487, 3574
7518, 3488, 3524, 3578
7519, 3541, 3488, 3542
7520, 3542, 3488, 3578
7521, 3544, 3489, 3545
7522, 3545, 3489, 3567
7523, 3489, 3549, 3567
7524, 3494, 3490, 3495
7525, 3495, 3490, 3496
7526, 3496, 3490, 3560
7527, 3512, 3491, 3563
7528, 3491, 3512, 3575
7529, 3551, 3491, 3575
7530, 3496, 3492, 3498
7531, 3492, 3496, 3560
7532, 3498, 3492, 3572
7533, 3492, 3560, 3583
7534, 3513, 3493, 3515
7535, 3493, 3513, 3561
7536, 3515, 3493, 3573
7537, 3493, 3561, 3584
7538, 3494, 3495, 3562
7539, 3494, 3562, 3580
7540, 3495, 3496, 3497
7541, 3495, 3497, 3574
7542, 3497, 3496, 3498
7543, 3497, 3498, 3499
7544, 3497, 3499, 3500
7545, 3497, 3500, 3574
7546, 3500, 3499, 3501
7547, 3501, 3499, 3502
7548, 3500, 3501, 3578
7549, 3500, 3524, 3574
7550, 3524, 3500, 3578
7551, 3501, 3502, 3503
7552, 3501, 3503, 3587
7553, 3501, 3542, 3578
7554, 3542, 3501, 3587
7555, 3503, 3504, 3505
7556, 3503, 3505, 3587
7557, 3505, 3504, 3506
7558, 3506, 3504, 3579
7559, 3504, 3566, 3579
7560, 3505, 3506, 3507
7561, 3505, 3507, 3570
7562, 3505, 3570, 3587
7563, 3507, 3506, 3508
7564, 3508, 3506, 3509
7565, 3509, 3506, 3579
7566, 3507, 3508, 3582
7567, 3525, 3507, 3582
7568, 3508, 3509, 3510
7569, 3508, 3510, 3582
7570, 3510, 3509, 3565
7571, 3509, 3523, 3565
7572, 3564, 3510, 3568
7573, 3510, 3564, 3582
7574, 3510, 3565, 3568
7575, 3511, 3512, 3563
7576, 3511, 3563, 3581
7577, 3512, 3513, 3514
7578, 3512, 3514, 3575
7579, 3514, 3513, 3515
7580, 3514, 3515, 3516
7581, 3514, 3516, 3522
7582, 3514, 3522, 3575
7583, 3516, 3517, 3518
7584, 3516, 3518, 3522
7585, 3518, 3517, 3519
7586, 3519, 3517, 3537
7587, 3537, 3517, 3577
7588, 3518, 3519, 3520
7589, 3518, 3520, 3569
7590, 3522, 3518, 3569
7591, 3520, 3519, 3521
7592, 3521, 3519, 3576
7593, 3519, 3537, 3576
7594, 3520, 3521, 3567
7595, 3520, 3567, 3585
7596, 3569, 3520, 3585
7597, 3548, 3521, 3576
7598, 3521, 3548, 3586
7599, 3567, 3521, 3586
7600, 3551, 3522, 3569
7601, 3522, 3551, 3575
7602, 3526, 3527, 3550
7603, 3547, 3526, 3550
7604, 3527, 3528, 3529
7605, 3527, 3529, 3530
7606, 3527, 3530, 3550
7607, 3529, 3528, 3531
7608, 3531, 3528, 3532
7609, 3532, 3528, 3546
7610, 3530, 3529, 3555
7611, 3529, 3531, 3556
7612, 3555, 3529, 3556
7613, 3550, 3530, 3559
7614, 3554, 3530, 3555
7615, 3530, 3554, 3559
7616, 3531, 3532, 3533
7617, 3531, 3533, 3552
7618, 3531, 3552, 3556
7619, 3533, 3532, 3534
7620, 3534, 3532, 3543
7621, 3543, 3532, 3546
7622, 3533, 3534, 3535
7623, 3533, 3535, 3536
7624, 3533, 3536, 3552
7625, 3535, 3534, 3540
7626, 3536, 3535, 3557
7627, 3535, 3540, 3568
7628, 3557, 3535, 3568
7629, 3552, 3536, 3558
7630, 3553, 3536, 3557
7631, 3536, 3553, 3558
7632, 3538, 3555, 3556
7633, 3540, 3539, 3564
7634, 3540, 3564, 3568
7635, 3541, 3542, 3570
7636, 3570, 3542, 3587
7637, 3544, 3545, 3554
7638, 3554, 3545, 3559
7639, 3559, 3545, 3586
7640, 3545, 3567, 3586
7641, 3548, 3547, 3550
7642, 3548, 3550, 3559
7643, 3548, 3559, 3586
7644, 3567, 3549, 3585
7645, 3565, 3557, 3568
*ELEMENT, type=CPS3, ELSET=Surface11
7646, 4, 69, 3685
7647, 167, 4, 3685
7648, 88, 6, 3689
7649, 6, 212, 3689
7650, 10, 170, 3688
7651, 216, 10, 3688
7652, 215, 11, 3686
7653, 11, 235, 3686
7654, 69, 70, 3663
7655, 69, 3663, 3685
7656, 70, 71, 3599
7657, 70, 3599, 3663
7658, 71, 72, 3652
7659, 3599, 71, 3652
7660, 72, 73, 3672
7661, 3652, 72, 3672
7662, 73, 74, 3590
7663, 73, 3590, 3672
7664, 74, 75, 3668
7665, 3590, 74, 3668
7666, 75, 76, 3602
7667, 75, 3602, 3668
7668, 76, 77, 3669
7669, 3602, 76, 3669
7670, 77, 78, 3591
7671, 77, 3591, 3669
7672, 78, 79, 3654
7673, 3591, 78, 3654
7674, 79, 80, 3650
7675, 79, 3650, 3654
7676, 80, 81, 3588
7677, 80, 3588, 3650
7678, 81, 82, 3653
7679, 3588, 81, 3653
7680, 82, 83, 3594
7681, 82, 3594, 3653
7682, 83, 84, 3651
7683, 3594, 83, 3651
7684, 84, 85, 3682
7685, 3651, 84, 3682
7686, 85, 86, 3598
7687, 85, 3598, 3682
7688, 86, 87, 3675
7689, 3598, 86, 3675
7690, 87, 88, 3606
7691, 87, 3606, 3675
7692, 3606, 88, 3689
7693, 168, 167, 3607
7694, 3607, 167, 3685
7695, 169, 168, 3603
7696, 3603, 168, 3607
7697, 170, 169, 3661
7698, 169, 3603, 3661
7699, 170, 3661, 3688
7700, 212, 213, 3662
7701, 212, 3662, 3689
7702, 213, 214, 3595
7703, 213, 3595, 3662
7704, 214, 215, 3628
7705, 3595, 214, 3628
7706, 3628, 215, 3686
7707, 217, 216, 3605
7708, 3605, 216, 3688
7709, 218, 217, 3673
7710, 217, 3605, 3673
7711, 219, 218, 3593
7712, 3593, 218, 3673
7713, 220, 219, 3681
7714, 219, 3593, 3681
7715, 221, 220, 3600
7716, 3600, 220, 3681
7717, 222, 221, 3658
7718, 221, 3600, 3658
7719, 223, 222, 3592
7720, 3592, 222, 3658
7721, 224, 223, 3690
7722, 223, 3592, 3690
7723, 225, 224, 3601
7724, 3601, 224, 3690
7725, 226, 225, 3645
7726, 225, 3601, 3645
7727, 227, 226, 3596
7728, 3596, 226, 3645
7729, 228, 227, 3649
7730, 227, 3596, 3649
7731, 229, 228, 3597
7732, 3597, 228, 3649
7733, 230, 229, 3667
7734, 229, 3597, 3667
7735, 231, 230, 3644
7736, 3644, 230, 3667
7737, 232, 231, 3589
7738, 3589, 231, 3644
7739, 233, 232, 3657
7740, 232, 3589, 3657
7741, 234, 233, 3604
7742, 3604, 233, 3657
7743, 235, 234, 3664
7744, 234, 3604, 3664
7745, 235, 3664, 3686
7746, 3650, 3588, 3665
7747, 3588, 3653, 3683
7748, 3665, 3588, 3683
7749, 3589, 3644, 3691
7750, 3657, 3589, 3670
7751, 3670, 3589, 3691
7752, 3615, 3590, 3616
7753, 3590, 3615, 3672
7754, 3616, 3590, 3617
7755, 3617, 3590, 3668
7756, 3591, 3626, 3669
7757, 3626, 3591, 3676
7758, 3591, 3654, 3676
7759, 3592, 3620, 3621
7760, 3620, 3592, 3658
7761, 3592, 3621, 3624
7762, 3592, 3624, 3690
7763, 3593, 3611, 3612
7764, 3611, 3593, 3673
7765, 3593, 3612, 3625
7766, 3593, 3625, 3681
7767, 3594, 3642, 3653
7768, 3642, 3594, 3674
7769, 3594, 3651, 3674
7770, 3595, 3628, 3629
7771, 3595, 3629, 3630
7772, 3595, 3630, 3662
7773, 3596, 3645, 3646
7774, 3596, 3646, 3647
7775, 3596, 3647, 3649
7776, 3597, 3649, 3656
7777, 3597, 3656, 3687
7778, 3667, 3597, 3687
7779, 3598, 3632, 3633
7780, 3632, 3598, 3675
7781, 3598, 3633, 3634
7782, 3598, 3634, 3682
7783, 3599, 3608, 3663
7784, 3608, 3599, 3677
7785, 3599, 3652, 3677
7786, 3600, 3625, 3660
7787, 3625, 3600, 3681
7788, 3658, 3600, 3678
7789, 3600, 3660, 3678
7790, 3601, 3624, 3680
7791, 3624, 3601, 3690
7792, 3645, 3601, 3655
7793, 3655, 3601, 3680
7794, 3622, 3602, 3669
7795, 3602, 3622, 3684
7796, 3668, 3602, 3684
7797, 3603, 3607, 3608
7798, 3603, 3608, 3609
7799, 3603, 3609, 3661
7800, 3604, 3629, 3664
7801, 3629, 3604, 3671
7802, 3604, 3657, 3671
7803, 3605, 3609, 3611
7804, 3609, 3605, 3661
7805, 3605, 3611, 3673
7806, 3661, 3605, 3688
7807, 3606, 3630, 3632
7808, 3630, 3606, 3662
7809, 3606, 3632, 3675
7810, 3662, 3606, 3689
7811, 3608, 3607, 3663
7812, 3663, 3607, 3685
7813, 3609, 3608, 3610
7814, 3610, 3608, 3677
7815, 3609, 3610, 3611
7816, 3611, 3610, 3612
7817, 3612, 3610, 3613
7818, 3613, 3610, 3677
7819, 3612, 3613, 3614
7820, 3612, 3614, 3625
7821, 3614, 3613, 3615
7822, 3615, 3613, 3652
7823, 3652, 3613, 3677
7824, 3614, 3615, 3616
7825, 3614, 3616, 3660
7826, 3625, 3614, 3660
7827, 3615, 3652, 3672
7828, 3616, 3617, 3618
7829, 3616, 3618, 3660
7830, 3618, 3617, 3619
7831, 3619, 3617, 3684
7832, 3617, 3668, 3684
7833, 3618, 3619, 3620
7834, 3618, 3620, 3678
7835, 3660, 3618, 3678
7836, 3620, 3619, 3621
7837, 3621, 3619, 3622
7838, 3622, 3619, 3684
7839, 3620, 3658, 3678
7840, 3621, 3622, 3623
7841, 3621, 3623, 3624
7842, 3623, 3622, 3626
7843, 3626, 3622, 3669
7844, 3624, 3623, 3680
7845, 3623, 3626, 3627
7846, 3623, 3627, 3680
7847, 3627, 3626, 3676
7848, 3655, 3627, 3659
7849, 3627, 3655, 3680
7850, 3659, 3627, 3676
7851, 3629, 3628, 3664
7852, 3664, 3628, 3686
7853, 3630, 3629, 3631
7854, 3631, 3629, 3671
7855, 3630, 3631, 3632
7856, 3632, 3631, 3633
7857, 3633, 3631, 3641
7858, 3641, 3631, 3671
7859, 3634, 3633, 3635
7860, 3635, 3633, 3641
7861, 3634, 3635, 3636
7862, 3634, 3636, 3651
7863, 3634, 3651, 3682
7864, 3636, 3635, 3637
7865, 3637, 3635, 3670
7866, 3635, 3641, 3670
7867, 3636, 3637, 3638
7868, 3636, 3638, 3674
7869, 3651, 3636, 3674
7870, 3638, 3637, 3639
7871, 3639, 3637, 3691
7872, 3637, 3670, 3691
7873, 3638, 3639, 3640
7874, 3638, 3640, 3642
7875, 3638, 3642, 3674
7876, 3640, 3639, 3687
7877, 3639, 3644, 3667
7878, 3644, 3639, 3691
7879, 3639, 3667, 3687
7880, 3642, 3640, 3643
7881, 3643, 3640, 3656
7882, 3656, 3640, 3687
7883, 3641, 3657, 3670
7884, 3657, 3641, 3671
7885, 3642, 3643, 3683
7886, 3653, 3642, 3683
7887, 3643, 3656, 3679
7888, 3643, 3679, 3683
7889, 3646, 3645, 3655
7890, 3647, 3646, 3648
7891, 3648, 3646, 3659
7892, 3646, 3655, 3659
7893, 3647, 3648, 3679
7894, 3649, 3647, 3656
7895, 3656, 3647, 3679
7896, 3648, 3659, 3666
7897, 3665, 3648, 3666
7898, 3648, 3665, 3679
7899, 3654, 3650, 3666
7900, 3650, 3665, 3666
7901, 3654, 3666, 3676
7902, 3666, 3659, 3676
7903, 3679, 3665, 3683
*ELEMENT, type=CPS3, ELSET=Surface12
7904, 3, 28, 3897
7905, 148, 3, 3897
7906, 68, 4, 3895
7907, 4, 167, 3895
7908, 9, 151, 3896
7909, 171, 9, 3896
7910, 170, 10, 3898
7911, 10, 211, 3898
7912, 28, 29, 3727
7913, 28, 3727, 3897
7914, 29, 30, 3885
7915, 3727, 29, 3885
7916, 30, 31, 3706
7917, 30, 3706, 3885
7918, 31, 32, 3891
7919, 3706, 31, 3891
7920, 32, 33, 3823
7921, 32, 3823, 3891
7922, 33, 34, 3718
7923, 33, 3718, 3823
7924, 34, 35, 3835
7925, 3718, 34, 3835
7926, 35, 36, 3814
7927, 35, 3814, 3835
7928, 36, 37, 3703
7929, 36, 3703, 3814
7930, 37, 38, 3827
7931, 3703, 37, 3827
7932, 38, 39, 3717
7933, 38, 3717, 3827
7934, 39, 40, 3836
7935, 3717, 39, 3836
7936, 40, 41, 3813
7937, 40, 3813, 3836
7938, 41, 42, 3704
7939, 41, 3704, 3813
7940, 42, 43, 3824
7941, 3704, 42, 3824
7942, 43, 44, 3705
7943, 43, 3705, 3824
7944, 44, 45, 3819
7945, 3705, 44, 3819
7946, 45, 46, 3697
7947, 45, 3697, 3819
7948, 46, 47, 3825
7949, 3697, 46, 3825
7950, 47, 48, 3815
7951, 47, 3815, 3825
7952, 48, 49, 3698
7953, 48, 3698, 3815
7954, 49, 50, 3778
7955, 3698, 49, 3778
7956, 50, 51, 3716
7957, 50, 3716, 3778
7958, 51, 52, 3830
7959, 3716, 51, 3830
7960, 52, 53, 3713
7961, 52, 3713, 3830
7962, 53, 54, 3771
7963, 3713, 53, 3771
7964, 54, 55, 3693
7965, 54, 3693, 3771
7966, 55, 56, 3838
7967, 3693, 55, 3838
7968, 56, 57, 3833
7969, 56, 3833, 3838
7970, 57, 58, 3694
7971, 57, 3694, 3833
7972, 58, 59, 3762
7973, 3694, 58, 3762
7974, 59, 60, 3841
7975, 3762, 59, 3841
7976, 60, 61, 3692
7977, 60, 3692, 3841
7978, 61, 62, 3893
7979, 3692, 61, 3893
7980, 62, 63, 3880
7981, 62, 3880, 3893
7982, 63, 64, 3695
7983, 63, 3695, 3880
7984, 64, 65, 3884
7985, 3695, 64, 3884
7986, 65, 66, 3831
7987, 65, 3831, 3884
7988, 66, 67, 3709
7989, 66, 3709, 3831
7990, 67, 68, 3847
7991, 3709, 67, 3847
7992, 3847, 68, 3895
7993, 149, 148, 3845
7994, 3845, 148, 3897
7995, 150, 149, 3725
7996, 3725, 149, 3845
7997, 151, 150, 3728
7998, 150, 3725, 3728
7999, 151, 3728, 3896
8000, 167, 168, 3742
8001, 167, 3742, 3895
8002, 168, 169, 3724
8003, 168, 3724, 3742
8004, 169, 170, 3846
8005, 3724, 169, 3846
8006, 3846, 170, 3898
8007, 172, 171, 3848
8008, 3848, 171, 3896
8009, 173, 172, 3721
8010, 3721, 172, 3848
8011, 174, 173, 3741
8012, 173, 3721, 3741
8013, 175, 174, 3881
8014, 174, 3741, 3881
8015, 176, 175, 3701
8016, 3701, 175, 3881
8017, 177, 176, 3820
8018, 176, 3701, 3820
8019, 178, 177, 3700
8020, 3700, 177, 3820
8021, 179, 178, 3854
8022, 178, 3700, 3854
8023, 180, 179, 3876
8024, 179, 3854, 3876
8025, 181, 180, 3720
8026, 3720, 180, 3876
8027, 182, 181, 3821
8028, 181, 3720, 3821
8029, 183, 182, 3702
8030, 3702, 182, 3821
8031, 184, 183, 3852
8032, 183, 3702, 3852
8033, 185, 184, 3874
8034, 184, 3852, 3874
8035, 186, 185, 3719
8036, 3719, 185, 3874
8037, 187, 186, 3822
8038, 186, 3719, 3822
8039, 188, 187, 3715
8040, 3715, 187, 3822
8041, 189, 188, 3828
8042, 188, 3715, 3828
8043, 190, 189, 3714
8044, 3714, 189, 3828
8045, 191, 190, 3850
8046, 190, 3714, 3850
8047, 192, 191, 3872
8048, 191, 3850, 3872
8049, 193, 192, 3712
8050, 3712, 192, 3872
8051, 194, 193, 3826
8052, 193, 3712, 3826
8053, 195, 194, 3699
8054, 3699, 194, 3826
8055, 196, 195, 3817
8056, 195, 3699, 3817
8057, 197, 196, 3710
8058, 3710, 196, 3817
8059, 198, 197, 3818
8060, 197, 3710, 3818
8061, 199, 198, 3711
8062, 3711, 198, 3818
8063, 200, 199, 3829
8064, 199, 3711, 3829
8065, 201, 200, 3722
8066, 3722, 200, 3829
8067, 202, 201, 3816
8068, 201, 3722, 3816
8069, 203, 202, 3707
8070, 3707, 202, 3816
8071, 204, 203, 3894
8072, 203, 3707, 3894
8073, 205, 204, 3708
8074, 3708, 204, 3894
8075, 206, 205, 3879
8076, 205, 3708, 3879
8077, 207, 206, 3723
8078, 3723, 206, 3879
8079, 208, 207, 3883
8080, 207, 3723, 3883
8081, 209, 208, 3696
8082, 3696, 208, 3883
8083, 210, 209, 3886
8084, 209, 3696, 3886
8085, 211, 210, 3726
8086, 3726, 210, 3886
8087, 211, 3726, 3898
8088, 3692, 3756, 3844
8089, 3756, 3692, 3893
8090, 3841, 3692, 3844
8091, 3771, 3693, 3777
8092, 3777, 3693, 3839
8093, 3693, 3838, 3839
8094, 3694, 3762, 3763
8095, 3694, 3763, 3764
8096, 3694, 3764, 3833
8097, 3695, 3750, 3751
8098, 3750, 3695, 3884
8099, 3695, 3751, 3752
8100, 3695, 3752, 3880
8101, 3746, 3696, 3747
8102, 3696, 3746, 3886
8103, 3747, 3696, 3761
8104, 3761, 3696, 3883
8105, 3697, 3787, 3789
8106, 3787, 3697, 3825
8107, 3697, 3789, 3819
8108, 3698, 3778, 3779
8109, 3698, 3779, 3780
8110, 3698, 3780, 3815
8111, 3817, 3699, 3857
8112, 3699, 3826, 3856
8113, 3699, 3856, 3857
8114, 3700, 3820, 3843
8115, 3700, 3843, 3877
8116, 3854, 3700, 3877
8117, 3737, 3701, 3739
