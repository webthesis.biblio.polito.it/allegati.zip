31873, 6164, 5802, 4593, 4338
31874, 6164, 4593, 5802, 3988
31875, 5510, 4593, 5802, 4338
31876, 5510, 5802, 4593, 3988
31877, 5993, 404, 403, 402
31878, 5993, 403, 404, 4992
31879, 4688, 3171, 5613, 2642
31880, 4688, 5613, 3171, 4479
31881, 5113, 5769, 5542, 3935
31882, 5542, 5769, 5113, 4210
31883, 5579, 5378, 2384, 2383
31884, 5579, 2384, 5378, 4258
31885, 4465, 5657, 4761, 4061
31886, 4761, 5657, 4465, 4987
31887, 4268, 5830, 4847, 5250
31888, 4268, 4847, 5830, 4279
31889, 3955, 4847, 5830, 5250
31890, 3955, 5830, 4847, 4279
31891, 5634, 740, 4740, 4175
31892, 5634, 4740, 740, 746
31893, 5260, 3793, 5388, 4534
31894, 5260, 5388, 3793, 3792
31895, 2251, 5255, 4862, 2971
31896, 4862, 5255, 2251, 4407
31897, 5250, 4639, 5406, 3955
31898, 5250, 5406, 4639, 4129
31899, 5485, 4242, 4027, 4827
31900, 5485, 4027, 4242, 4532
31901, 5760, 5579, 4536, 4258
31902, 5760, 4536, 5579, 4733
31903, 5715, 3779, 5758, 3834
31904, 5715, 5758, 3779, 5186
31905, 5940, 3969, 5979, 4253
31906, 5940, 5979, 3969, 4964
31907, 5389, 2191, 2189, 4498
31908, 5389, 2189, 2191, 2190
31909, 3033, 5218, 5991, 2840
31910, 5991, 5218, 3033, 4280
31911, 4733, 2382, 5910, 4536
31912, 4733, 5910, 2382, 2381
31913, 5959, 4235, 2168, 5106
31914, 5800, 2168, 4235, 5106
31915, 4850, 6187, 4481, 3961
31916, 4481, 6187, 4850, 6080
31917, 5627, 2962, 2423, 3126
31918, 5627, 2423, 2962, 5618
31919, 5681, 2370, 5868, 2448
31920, 5681, 5868, 2370, 5662
31921, 6185, 4734, 4099, 5813
31922, 6185, 4099, 4734, 5756
31923, 5402, 5764, 5825, 3517
31924, 5825, 5764, 5402, 4078
31925, 5187, 6079, 4585, 3908
31926, 4585, 6079, 5187, 5201
31927, 5887, 6137, 4288, 5279
31928, 4288, 6137, 5887, 5532
31929, 5741, 6016, 492, 526
31930, 492, 6016, 5741, 4337
31931, 4979, 6125, 5081, 4263
31932, 5081, 6125, 4979, 4289
31933, 670, 4507, 676, 1342
31934, 670, 676, 4507, 4873
31935, 5632, 3784, 3825, 3815
31936, 5632, 3825, 3784, 4500
31937, 5015, 775, 4993, 4394
31938, 5015, 4993, 775, 1193
31939, 4430, 5538, 4561, 3965
31940, 4561, 5538, 4430, 5022
31941, 6104, 5030, 4006, 4355
31942, 6104, 4006, 5030, 4250
31943, 5373, 5849, 1212, 1205
31944, 1212, 5849, 5373, 4144
31945, 6141, 2374, 4129, 5406
31946, 6141, 4129, 2374, 2375
31947, 6014, 4238, 5130, 4816
31948, 6014, 5130, 4238, 5538
31949, 5660, 2278, 4505, 4823
31950, 5660, 4505, 2278, 2932
31951, 2292, 5991, 2289, 2290
31952, 2289, 5991, 2292, 5785
31953, 5896, 5417, 980, 887
31954, 5896, 980, 5417, 4355
31955, 5989, 4049, 4449, 5683
31956, 5989, 4449, 4049, 5569
31957, 2100, 3484, 250, 2965
31958, 2100, 250, 3484, 3543
31959, 6221, 3855, 4424, 5773
31960, 6221, 4424, 3855, 5136
31961, 5336, 3359, 3357, 4905
31962, 5336, 3357, 3359, 3455
31963, 5115, 4682, 3945, 4514
31964, 5115, 3945, 4682, 4807
31965, 5361, 2941, 5986, 2644
31966, 5361, 5986, 2941, 4335
31967, 4852, 5986, 2941, 2644
31968, 4852, 2941, 5986, 4335
31969, 5507, 4260, 534, 5063
31970, 5507, 534, 4260, 5124
31971, 1066, 534, 4260, 5063
31972, 1066, 4260, 534, 5124
31973, 5678, 5555, 5202, 4272
31974, 5678, 5202, 5555, 4089
31975, 4985, 5832, 5225, 3976
31976, 5225, 5832, 4985, 4225
31977, 5221, 2751, 3043, 3048
31978, 5221, 3043, 2751, 5129
31979, 6119, 2479, 3114, 3011
31980, 6119, 3114, 2479, 4546
31981, 814, 5325, 812, 813
31982, 812, 5325, 814, 4320
31983, 2192, 4932, 2194, 2193
31984, 2194, 4932, 2192, 4653
31985, 2459, 4509, 5788, 2435
31986, 2459, 5788, 4509, 4788
31987, 5504, 1252, 1258, 745
31988, 5504, 1258, 1252, 4712
31989, 5771, 1411, 5565, 910
31990, 5771, 5565, 1411, 4651
31991, 1294, 5565, 1411, 910
31992, 1294, 1411, 5565, 4651
31993, 5286, 965, 4915, 337
31994, 5286, 4915, 965, 4395
31995, 3121, 4344, 2108, 5294
31996, 2108, 4344, 3121, 6170
31997, 4926, 5724, 4750, 4177
31998, 4750, 5724, 4926, 3977
31999, 3462, 5713, 3418, 3342
32000, 3418, 5713, 3462, 4593
32001, 4775, 1410, 4469, 929
32002, 4775, 4469, 1410, 3718
32003, 5644, 5735, 4787, 4326
32004, 4787, 5735, 5644, 558
32005, 5558, 3181, 6201, 5486
32006, 5558, 6201, 3181, 2757
32007, 4278, 4253, 5671, 5940
32008, 4278, 5671, 4253, 6181
32009, 4831, 3111, 5647, 3170
32010, 4831, 5647, 3111, 4531
32011, 5699, 5152, 4807, 4377
32012, 5699, 4807, 5152, 4102
32013, 6161, 4249, 3931, 5374
32014, 6161, 3931, 4249, 5253
32015, 5260, 3789, 3791, 4880
32016, 5260, 3791, 3789, 3790
32017, 637, 5606, 669, 636
32018, 669, 5606, 637, 4398
32019, 6122, 374, 5342, 4690
32020, 6122, 5342, 374, 373
32021, 3990, 6081, 5431, 4423
32022, 5431, 6081, 3990, 5739
32023, 6214, 2658, 4908, 2657
32024, 6214, 4908, 2658, 4356
32025, 4979, 5691, 5616, 4289
32026, 5616, 5691, 4979, 4145
32027, 6170, 3121, 2755, 4344
32028, 6170, 2755, 3121, 3184
32029, 5527, 2994, 2540, 4353
32030, 5527, 2540, 2994, 3069
32031, 2676, 5613, 5310, 3159
32032, 5310, 5613, 2676, 4224
32033, 3142, 3280, 5021, 3123
32034, 3142, 5021, 3280, 3229
32035, 6181, 4278, 6107, 4253
32036, 6181, 6107, 4278, 5433
32037, 5734, 5563, 5337, 3684
32038, 5734, 5337, 5563, 4137
32039, 3239, 5452, 3286, 3237
32040, 3286, 5452, 3239, 4931
32041, 5804, 4250, 5033, 4794
32042, 5804, 5033, 4250, 4598
32043, 5868, 2370, 2368, 2958
32044, 5868, 2368, 2370, 5662
32045, 4143, 5217, 5403, 4718
32046, 4143, 5403, 5217, 5140
32047, 3918, 5403, 5217, 4718
32048, 3918, 5217, 5403, 5140
32049, 5091, 593, 5295, 594
32050, 5091, 5295, 593, 4379
32051, 4918, 5110, 5170, 4055
32052, 5170, 5110, 4918, 4406
32053, 5995, 2627, 3168, 3203
32054, 5995, 3168, 2627, 4242
32055, 6137, 5532, 4665, 3972
32056, 6137, 4665, 5532, 4288
32057, 5485, 2789, 2571, 2675
32058, 5485, 2571, 2789, 4532
32059, 3506, 6151, 3509, 3579
32060, 3509, 6151, 3506, 5111
32061, 5927, 4013, 4387, 4675
32062, 5927, 4387, 4013, 5470
32063, 6037, 4427, 4021, 5156
32064, 6037, 4021, 4427, 4493
32065, 6038, 5998, 3266, 4236
32066, 6038, 3266, 5998, 3289
32067, 6140, 5909, 5884, 4084
32068, 6140, 5884, 5909, 4560
32069, 5852, 830, 828, 827
32070, 5852, 828, 830, 4858
32071, 5076, 5159, 5188, 3921
32072, 5188, 5159, 5076, 4153
32073, 4716, 5793, 5002, 4274
32074, 5002, 5793, 4716, 3908
32075, 5579, 2381, 2382, 2383
32076, 5579, 2382, 2381, 4733
32077, 6182, 4199, 4033, 4521
32078, 6182, 4033, 4199, 5315
32079, 5805, 5968, 471, 1142
32080, 471, 5968, 5805, 4367
32081, 471, 473, 5805, 1142
32082, 5805, 473, 471, 4367
32083, 3238, 5780, 3276, 3300
32084, 3276, 5780, 3238, 4349
32085, 1144, 5398, 1130, 976
32086, 1130, 5398, 1144, 4575
32087, 5852, 5286, 965, 4395
32088, 5852, 965, 5286, 827
32089, 6180, 5012, 5419, 3910
32090, 5419, 5012, 6180, 5355
32091, 5419, 4493, 6180, 3910
32092, 6180, 4493, 5419, 5355
32093, 5933, 2314, 4453, 2421
32094, 5933, 4453, 2314, 5075
32095, 5933, 2308, 5387, 2309
32096, 5933, 5387, 2308, 5731
32097, 6113, 5387, 2308, 2309
32098, 6113, 2308, 5387, 5731
32099, 5462, 1157, 5809, 4373
32100, 5462, 5809, 1157, 1042
32101, 4996, 2745, 3061, 4804
32102, 4996, 3061, 2745, 2744
32103, 5248, 5308, 4004, 4606
32104, 4004, 5308, 5248, 4885
32105, 5583, 3758, 5827, 3759
32106, 5583, 5827, 3758, 4819
32107, 787, 5872, 5496, 1298
32108, 5496, 5872, 787, 4336
32109, 5157, 411, 5386, 4584
32110, 5157, 5386, 411, 412
32111, 5959, 5800, 2168, 4235
32112, 5959, 2168, 5800, 2934
32113, 6090, 4518, 2688, 5893
32114, 6090, 2688, 4518, 5099
32115, 4612, 2700, 3214, 2699
32116, 4612, 3214, 2700, 6237
32117, 5578, 5470, 5235, 4066
32118, 5578, 5235, 5470, 4310
32119, 5780, 875, 346, 1400
32120, 5780, 346, 875, 4349
32121, 5488, 5282, 5161, 4259
32122, 5488, 5161, 5282, 4044
32123, 5117, 6055, 5845, 4291
32124, 5845, 6055, 5117, 4005
32125, 5197, 3863, 3864, 3803
32126, 5197, 3864, 3863, 4439
32127, 4943, 6063, 5239, 4240
32128, 5239, 6063, 4943, 4097
32129, 5406, 2449, 5944, 4639
32130, 5406, 5944, 2449, 2963
32131, 6087, 4408, 2792, 5071
32132, 6087, 2792, 4408, 5418
32133, 6057, 2408, 2325, 2407
32134, 6057, 2325, 2408, 4574
32135, 4663, 6149, 4220, 3962
32136, 4220, 6149, 4663, 6057
32137, 4941, 5769, 4749, 3935
32138, 4749, 5769, 4941, 4284
32139, 5336, 2694, 2624, 4415
32140, 5336, 2624, 2694, 3149
32141, 4921, 5560, 4786, 4169
32142, 4786, 5560, 4921, 4426
32143, 2866, 5898, 5270, 2486
32144, 5270, 5898, 2866, 4496
32145, 6178, 4792, 4734, 4168
32146, 6178, 4734, 4792, 5142
32147, 5983, 4832, 4440, 5950
32148, 5983, 4440, 4832, 4594
32149, 3938, 4440, 4832, 5950
32150, 3938, 4832, 4440, 4594
32151, 5966, 6035, 3983, 4500
32152, 3983, 6035, 5966, 4842
32153, 5653, 6213, 5339, 4315
32154, 5339, 6213, 5653, 1404
32155, 5131, 295, 3413, 899
32156, 5131, 3413, 295, 4454
32157, 6236, 4987, 4975, 4230
32158, 6236, 4975, 4987, 4146
32159, 5576, 6202, 803, 4221
32160, 803, 6202, 5576, 797
32161, 5364, 805, 1309, 4700
32162, 5364, 1309, 805, 876
32163, 5365, 1343, 4206, 891
32164, 5365, 4206, 1343, 4715
32165, 5899, 1250, 4194, 1184
32166, 5899, 4194, 1250, 5304
32167, 5460, 476, 478, 5282
32168, 5460, 478, 476, 1130
32169, 4729, 5933, 5600, 4453
32170, 4729, 5600, 5933, 4152
32171, 5128, 5600, 5933, 4453
32172, 5128, 5933, 5600, 4152
32173, 5926, 4466, 4084, 5107
32174, 5926, 4084, 4466, 5033
32175, 2322, 6173, 2868, 2321
32176, 2868, 6173, 2322, 4499
32177, 5893, 3091, 5296, 2590
32178, 5893, 5296, 3091, 5316
32179, 5656, 3733, 5046, 3732
32180, 5656, 5046, 3733, 5284
32181, 3731, 5046, 3733, 3732
32182, 3731, 3733, 5046, 5284
32183, 5950, 2955, 4938, 2539
32184, 5950, 4938, 2955, 4832
32185, 5764, 3199, 2747, 2748
32186, 5764, 2747, 3199, 5695
32187, 747, 5673, 1202, 740
32188, 1202, 5673, 747, 5285
32189, 6086, 355, 6017, 354
32190, 6086, 6017, 355, 4993
32191, 4888, 6032, 5974, 3970
32192, 5974, 6032, 4888, 4381
32193, 776, 5305, 754, 878
32194, 754, 5305, 776, 4776
32195, 5501, 1144, 5066, 4575
32196, 5501, 5066, 1144, 472
32197, 2387, 5060, 2753, 2734
32198, 2753, 5060, 2387, 4597
32199, 5658, 1258, 612, 542
32200, 5658, 612, 1258, 5537
32201, 5520, 1005, 1008, 1071
32202, 5520, 1008, 1005, 5051
32203, 5507, 4178, 533, 5124
32204, 5507, 533, 4178, 4735
32205, 5982, 2399, 2994, 2424
32206, 5982, 2994, 2399, 5191
32207, 5244, 5590, 4603, 4319
32208, 4603, 5590, 5244, 4054
32209, 2180, 4517, 2178, 2919
32210, 2180, 2178, 4517, 6080
32211, 5959, 2570, 4225, 5225
32212, 5959, 4225, 2570, 2741
32213, 5163, 1179, 5401, 4724
32214, 5163, 5401, 1179, 1102
32215, 3189, 3291, 5669, 2118
32216, 5669, 3291, 3189, 3224
32217, 5514, 2218, 4411, 2221
32218, 5514, 4411, 2218, 5374
32219, 2223, 4411, 2218, 2221
32220, 2223, 2218, 4411, 5374
32221, 5242, 3024, 4232, 2915
32222, 5242, 4232, 3024, 4891
32223, 2305, 4232, 3024, 2915
32224, 4056, 4504, 4435, 4952
32225, 4435, 4504, 4056, 5668
32226, 5793, 5178, 4390, 4274
32227, 5793, 4390, 5178, 4039
32228, 5610, 5488, 6149, 4093
32229, 5610, 6149, 5488, 4259
32230, 5715, 3832, 4331, 5079
32231, 5715, 4331, 3832, 3834
32232, 5241, 5982, 4708, 4353
32233, 4708, 5982, 5241, 4300
32234, 6042, 1073, 5826, 4308
32235, 6042, 5826, 1073, 658
32236, 5833, 2961, 5255, 4401
32237, 5833, 5255, 2961, 2332
32238, 5808, 6138, 4744, 3954
32239, 4744, 6138, 5808, 4418
32240, 5945, 3171, 4688, 2640
32241, 5945, 4688, 3171, 4479
32242, 6038, 2560, 4236, 2686
32243, 6038, 4236, 2560, 5294
32244, 5251, 5493, 4566, 4042
32245, 4566, 5493, 5251, 4333
32246, 5782, 6045, 4889, 4219
32247, 4889, 6045, 5782, 1329
32248, 5763, 4368, 5534, 4646
32249, 5763, 5534, 4368, 4704
32250, 5428, 2373, 4129, 2375
32251, 5428, 4129, 2373, 4677
32252, 2374, 4129, 2373, 2375
32253, 2374, 2373, 4129, 4677
32254, 5159, 6200, 4632, 3921
32255, 4632, 6200, 5159, 5931
32256, 5816, 688, 4712, 5276
32257, 5816, 4712, 688, 798
32258, 6001, 5006, 5184, 4158
32259, 6001, 5184, 5006, 4321
32260, 3312, 935, 139, 934
32261, 139, 935, 3312, 3463
32262, 5292, 1199, 687, 1248
32263, 5292, 687, 1199, 4520
32264, 5902, 5986, 6230, 3960
32265, 6230, 5986, 5902, 5361
32266, 5675, 626, 357, 4366
32267, 5675, 357, 626, 359
32268, 5821, 4396, 4014, 5228
32269, 5821, 4014, 4396, 4471
32270, 5198, 5708, 4818, 4303
32271, 4818, 5708, 5198, 4014
32272, 4818, 4396, 5198, 4303
32273, 5198, 4396, 4818, 4014
32274, 5659, 2855, 2860, 2857
32275, 5659, 2860, 2855, 5086
32276, 6070, 662, 660, 1116
32277, 6070, 660, 662, 4741
32278, 5410, 2720, 2738, 2561
32279, 5410, 2738, 2720, 4722
32280, 5454, 1176, 4610, 4980
32281, 5454, 4610, 1176, 551
32282, 2959, 5983, 2844, 2520
32283, 2844, 5983, 2959, 5275
32284, 6184, 4651, 5358, 3901
32285, 6184, 5358, 4651, 4482
32286, 5972, 5038, 4870, 4296
32287, 5972, 4870, 5038, 4116
32288, 5117, 3630, 3606, 4539
32289, 5117, 3606, 3630, 3632
32290, 5984, 2493, 3134, 2712
32291, 5984, 3134, 2493, 4489
32292, 4394, 5510, 3454, 3345
32293, 4394, 3454, 5510, 5442
32294, 3347, 3454, 5510, 3345
32295, 3347, 5510, 3454, 5442
32296, 6067, 4171, 397, 4797
32297, 6067, 397, 4171, 5103
32298, 5325, 5927, 4385, 4320
32299, 4385, 5927, 5325, 3971
32300, 5005, 5627, 4989, 4161
32301, 4989, 5627, 5005, 4299
32302, 5567, 1397, 5637, 946
32303, 5567, 5637, 1397, 4209
32304, 6039, 3124, 5668, 3136
32305, 6039, 5668, 3124, 5114
32306, 2114, 3318, 268, 3411
32307, 268, 3318, 2114, 2695
32308, 5957, 5008, 5255, 4128
32309, 5957, 5255, 5008, 4407
32310, 5957, 2251, 5255, 4407
32311, 5957, 5255, 2251, 2538
32312, 6023, 1385, 6003, 1318
32313, 6023, 6003, 1385, 4297
32314, 5551, 2554, 5629, 2552
32315, 5551, 5629, 2554, 4580
32316, 5890, 5641, 5409, 4074
32317, 5890, 5409, 5641, 4287
32318, 423, 6065, 1210, 1033
32319, 1210, 6065, 423, 4599
32320, 5230, 6002, 5800, 4477
32321, 5800, 6002, 5230, 4205
32322, 5409, 5697, 5169, 4034
32323, 5169, 5697, 5409, 4568
32324, 5709, 5969, 4549, 4673
32325, 4549, 5969, 5709, 4167
32326, 4549, 5281, 5709, 4673
32327, 5709, 5281, 4549, 4167
32328, 2737, 3418, 291, 3329
32329, 291, 3418, 2737, 2123
32330, 4146, 6236, 1198, 656
32331, 4146, 1198, 6236, 4975
32332, 601, 1198, 6236, 656
32333, 601, 6236, 1198, 4975
32334, 6031, 546, 4816, 5130
32335, 6031, 4816, 546, 548
32336, 6021, 801, 1249, 802
32337, 6021, 1249, 801, 5633
32338, 5901, 2195, 2197, 2196
32339, 5901, 2197, 2195, 5004
32340, 5582, 3760, 3890, 4537
32341, 5582, 3890, 3760, 3753
32342, 5672, 6021, 5454, 4188
32343, 5454, 6021, 5672, 4476
32344, 5837, 987, 5592, 4558
32345, 5837, 5592, 987, 768
32346, 5954, 1034, 6065, 1028
32347, 5954, 6065, 1034, 4456
32348, 5218, 3076, 2838, 2840
32349, 5218, 2838, 3076, 4729
32350, 5533, 605, 523, 4602
32351, 5533, 523, 605, 505
32352, 5005, 5791, 5292, 4305
32353, 5292, 5791, 5005, 4162
32354, 2216, 5978, 5374, 2990
32355, 5374, 5978, 2216, 5950
32356, 5264, 5695, 5078, 4612
32357, 5078, 5695, 5264, 4078
32358, 6197, 4966, 5234, 3988
32359, 6197, 5234, 4966, 4366
32360, 5962, 4871, 5012, 4229
32361, 5962, 5012, 4871, 5873
32362, 5778, 4932, 6084, 4498
32363, 5778, 6084, 4932, 5599
32364, 5500, 958, 1222, 743
32365, 5500, 1222, 958, 4892
32366, 5571, 874, 348, 1357
32367, 5571, 348, 874, 5059
32368, 6160, 4647, 763, 5203
32369, 6160, 763, 4647, 6060
32370, 1189, 763, 4647, 5203
32371, 1189, 4647, 763, 6060
32372, 5108, 760, 678, 680
32373, 5108, 678, 760, 4920
32374, 5295, 6223, 6059, 4379
32375, 6059, 6223, 5295, 3999
32376, 4573, 5858, 4983, 4667
32377, 4573, 4983, 5858, 3094
32378, 2831, 4983, 5858, 4667
32379, 2831, 5858, 4983, 3094
32380, 5457, 6124, 5670, 4247
32381, 5670, 6124, 5457, 4576
32382, 4852, 2941, 2408, 2805
32383, 4852, 2408, 2941, 5661
32384, 6006, 5469, 5600, 4453
32385, 6006, 5600, 5469, 4068
32386, 5367, 1348, 5539, 4474
32387, 5367, 5539, 1348, 991
32388, 5167, 5689, 4530, 4018
32389, 4530, 5689, 5167, 4337
32390, 4209, 5313, 1397, 945
32391, 4209, 1397, 5313, 4771
32392, 1253, 1397, 5313, 945
32393, 1253, 5313, 1397, 4771
32394, 421, 5969, 4673, 424
32395, 4673, 5969, 421, 5709
32396, 5502, 5520, 1004, 1071
32397, 5502, 1004, 5520, 4816
32398, 684, 1004, 5520, 1071
32399, 684, 5520, 1004, 4816
32400, 5458, 689, 1131, 4557
32401, 5458, 1131, 689, 772
32402, 2626, 6201, 5862, 2611
32403, 5862, 6201, 2626, 4684
32404, 2448, 5868, 2847, 2958
32405, 2847, 5868, 2448, 5681
32406, 5772, 884, 758, 5732
32407, 5772, 758, 884, 759
32408, 5190, 5575, 6016, 4213
32409, 6016, 5575, 5190, 4523
32410, 2214, 5983, 4832, 2213
32411, 4832, 5983, 2214, 5950
32412, 5471, 481, 5217, 483
32413, 5471, 5217, 481, 4718
32414, 6077, 3646, 4365, 5883
32415, 6077, 4365, 3646, 3655
32416, 347, 3333, 112, 894
32417, 112, 3333, 347, 3452
32418, 5117, 6159, 4005, 5105
32419, 4005, 6159, 5117, 4539
32420, 2358, 5898, 4874, 2806
32421, 4874, 5898, 2358, 4556
32422, 5904, 2880, 2469, 4403
32423, 5904, 2469, 2880, 2881
32424, 5981, 5749, 4659, 4374
32425, 5981, 4659, 5749, 4167
32426, 6201, 3181, 2111, 5486
32427, 6201, 2111, 3181, 3117
32428, 5822, 2270, 4406, 2304
32429, 5822, 4406, 2270, 5640
32430, 2145, 3493, 260, 3573
32431, 2145, 260, 3493, 3097
32432, 5544, 6214, 4908, 4096
32433, 4908, 6214, 5544, 4356
32434, 5975, 4237, 2484, 4754
32435, 5975, 2484, 4237, 5363
32436, 6199, 2432, 2429, 2502
32437, 6199, 2429, 2432, 5560
32438, 2649, 5482, 5661, 2942
32439, 5661, 5482, 2649, 4732
32440, 5206, 5709, 4953, 4167
32441, 4953, 5709, 5206, 4425
32442, 5814, 6132, 4206, 4900
32443, 4206, 6132, 5814, 5438
32444, 6166, 4618, 4012, 5138
32445, 6166, 4012, 4618, 5615
32446, 6179, 1169, 4978, 467
32447, 6179, 4978, 1169, 4592
32448, 6191, 4339, 3966, 5674
32449, 6191, 3966, 4339, 4759
32450, 5525, 421, 1188, 416
32451, 5525, 1188, 421, 4673
32452, 2824, 5751, 5521, 2827
32453, 5521, 5751, 2824, 5052
32454, 5960, 5320, 4874, 4381
32455, 5960, 4874, 5320, 4293
32456, 5863, 2225, 2835, 4760
32457, 5863, 2835, 2225, 3012
32458, 5757, 5783, 3959, 4418
32459, 3959, 5783, 5757, 4179
32460, 3476, 339, 101, 1164
32461, 3476, 101, 339, 3538
32462, 888, 3417, 136, 3311
32463, 888, 136, 3417, 329
32464, 5855, 2165, 4512, 2166
32465, 5855, 4512, 2165, 5615
32466, 2164, 4512, 2165, 2166
32467, 2164, 2165, 4512, 5615
32468, 5554, 457, 5828, 4851
32469, 5554, 5828, 457, 452
32470, 5530, 531, 454, 1165
32471, 5530, 454, 531, 4719
32472, 5978, 5067, 4938, 4249
32473, 5978, 4938, 5067, 4371
32474, 5939, 5216, 6230, 4163
32475, 5939, 6230, 5216, 4383
32476, 6040, 867, 5211, 4790
32477, 6040, 5211, 867, 869
32478, 5694, 2618, 2497, 2628
32479, 5694, 2497, 2618, 4907
32480, 376, 5612, 375, 377
32481, 375, 5612, 376, 4690
32482, 4907, 6118, 6144, 4009
32483, 6144, 6118, 4907, 4370
32484, 2391, 6011, 5472, 2336
32485, 5472, 6011, 2391, 4552
32486, 3604, 2151, 234, 3664
32487, 234, 2151, 3604, 2721
32488, 2540, 5527, 2620, 3069
32489, 2620, 5527, 2540, 5411
32490, 5572, 4281, 4008, 4902
32491, 5572, 4008, 4281, 5408
32492, 2980, 3525, 4684, 2111
32493, 2980, 4684, 3525, 3485
32494, 5920, 4527, 2586, 5028
32495, 5920, 2586, 4527, 5526
32496, 6151, 1171, 1379, 4781
32497, 6151, 1379, 1171, 309
32498, 5860, 839, 837, 1003
32499, 5860, 837, 839, 4656
32500, 5602, 3168, 2567, 4657
32501, 5602, 2567, 3168, 2569
32502, 5263, 3505, 3570, 3587
32503, 5263, 3570, 3505, 5077
32504, 3748, 5746, 3831, 3750
32505, 3831, 5746, 3748, 5171
32506, 6168, 4951, 5088, 4166
32507, 6168, 5088, 4951, 4407
32508, 344, 3492, 90, 3572
32509, 90, 3492, 344, 1301
32510, 5138, 5935, 5891, 4214
32511, 5891, 5935, 5138, 4388
32512, 5718, 650, 580, 4739
32513, 5718, 580, 650, 1168
32514, 4833, 5574, 4594, 4053
32515, 4833, 4594, 5574, 4380
32516, 5483, 4594, 5574, 4053
32517, 5483, 5574, 4594, 4380
32518, 6207, 5209, 4821, 4400
32519, 6207, 4821, 5209, 4186
32520, 2293, 6113, 2308, 2300
32521, 2308, 6113, 2293, 4865
32522, 6051, 979, 5354, 5896
32523, 6051, 5354, 979, 584
32524, 5442, 3454, 3448, 4956
32525, 5442, 3448, 3454, 3347
32526, 3841, 1351, 5233, 338
32527, 5233, 1351, 3841, 3762
32528, 6179, 5066, 4192, 5968
32529, 6179, 4192, 5066, 5347
32530, 6069, 4512, 2797, 5855
32531, 6069, 2797, 4512, 4786
32532, 2478, 5695, 6237, 3055
32533, 6237, 5695, 2478, 4950
32534, 6151, 3523, 3509, 3479
32535, 6151, 3509, 3523, 4781
32536, 3318, 2127, 269, 3403
32537, 269, 2127, 3318, 2695
32538, 4587, 6041, 5425, 1051
32539, 4587, 5425, 6041, 4799
32540, 620, 5425, 6041, 1051
32541, 620, 6041, 5425, 4799
32542, 5070, 5970, 4634, 4015
32543, 5070, 4634, 5970, 4398
32544, 5478, 4634, 5970, 4015
32545, 5478, 5970, 4634, 4398
32546, 6208, 5285, 6163, 4564
32547, 6208, 6163, 5285, 5673
32548, 6016, 995, 364, 459
32549, 6016, 364, 995, 4967
32550, 5393, 3599, 3677, 5059
32551, 5393, 3677, 3599, 3652
32552, 5841, 5936, 4122, 4966
32553, 4122, 5936, 5841, 5328
32554, 323, 3675, 5117, 3598
32555, 5117, 3675, 323, 919
32556, 6129, 2464, 2463, 2465
32557, 6129, 2463, 2464, 4723
32558, 6195, 6015, 5728, 4128
32559, 6195, 5728, 6015, 4401
32560, 5992, 2307, 2279, 2997
32561, 5992, 2279, 2307, 4834
32562, 5937, 3894, 3759, 3708
32563, 5937, 3759, 3894, 5583
32564, 5681, 2372, 2370, 2448
32565, 5681, 2370, 2372, 5034
32566, 6126, 5200, 3912, 4427
32567, 6126, 3912, 5200, 4109
32568, 5820, 693, 1162, 749
32569, 5820, 1162, 693, 4806
32570, 5817, 2320, 4589, 5456
32571, 5817, 4589, 2320, 2339
32572, 6096, 491, 506, 498
32573, 6096, 506, 491, 4836
32574, 6131, 653, 4629, 655
32575, 6131, 4629, 653, 5829
32576, 5725, 306, 1382, 5495
32577, 5725, 1382, 306, 1319
32578, 699, 5605, 668, 777
32579, 668, 5605, 699, 4801
32580, 1135, 3884, 5746, 3695
32581, 1135, 5746, 3884, 320
32582, 6162, 5509, 5089, 4463
32583, 6162, 5089, 5509, 4082
32584, 1335, 3571, 5426, 319
32585, 1335, 5426, 3571, 3477
32586, 5989, 903, 1068, 4784
32587, 5989, 1068, 903, 1358
32588, 6207, 2954, 2445, 2417
32589, 6207, 2445, 2954, 4753
32590, 5960, 2809, 5085, 2808
32591, 5960, 5085, 2809, 5183
32592, 5788, 3213, 2459, 2434
32593, 5788, 2459, 3213, 4788
32594, 5805, 1158, 1142, 517
32595, 5805, 1142, 1158, 5327
32596, 3693, 1402, 4915, 3838
32597, 4915, 1402, 3693, 337
32598, 1370, 3563, 110, 3581
32599, 110, 3563, 1370, 1295
32600, 1381, 3694, 4672, 3833
32601, 1381, 4672, 3694, 296
32602, 3663, 1316, 5059, 3599
32603, 5059, 1316, 3663, 348
32604, 2098, 3829, 200, 3183
32605, 200, 3829, 2098, 3722
32606, 3295, 3728, 4448, 3896
32607, 3295, 4448, 3728, 3236
32608, 4657, 6165, 2567, 4789
32609, 4657, 2567, 6165, 3145
32610, 2564, 2567, 6165, 4789
32611, 2564, 6165, 2567, 3145
32612, 5921, 272, 2707, 2097
32613, 5921, 2707, 272, 3400
32614, 6172, 5730, 5703, 4476
32615, 6172, 5703, 5730, 4151
32616, 6097, 476, 5501, 5282
32617, 6097, 5501, 476, 474
32618, 3281, 1352, 5732, 885
32619, 5732, 1352, 3281, 3226
32620, 5230, 2247, 2173, 3087
32621, 5230, 2173, 2247, 6022
32622, 3180, 3547, 4890, 2107
32623, 4890, 3547, 3180, 3526
32624, 2726, 3690, 4576, 3601
32625, 2726, 4576, 3690, 2133
32626, 6170, 3292, 3253, 5453
32627, 6170, 3253, 3292, 3228
32628, 5925, 5710, 6139, 4698
32629, 5925, 6139, 5710, 4087
32630, 492, 6016, 460, 459
32631, 460, 6016, 492, 5167
32632, 2144, 3224, 154, 3284
32633, 154, 3224, 2144, 3189
32634, 3103, 3580, 4508, 3562
32635, 4508, 3580, 3103, 3174
32636, 6118, 5444, 4884, 4009
32637, 6118, 4884, 5444, 4437
32638, 4415, 3465, 5336, 2694
32639, 4415, 5336, 3465, 3325
32640, 3149, 5336, 3465, 2694
32641, 3149, 3465, 5336, 3325
32642, 6071, 428, 431, 1155
32643, 6071, 431, 428, 5439
32644, 6191, 5872, 5540, 4244
32645, 6191, 5540, 5872, 4759
32646, 5478, 1313, 898, 779
32647, 5478, 898, 1313, 4997
32648, 5919, 1299, 3669, 5337
32649, 5919, 3669, 1299, 331
32650, 6170, 2755, 2609, 5407
32651, 6170, 2609, 2755, 3184
32652, 6035, 301, 5508, 1096
32653, 6035, 5508, 301, 5632
32654, 2433, 6036, 5487, 2389
32655, 5487, 6036, 2433, 5601
32656, 3188, 3848, 4448, 2148
32657, 3188, 4448, 3848, 3896
32658, 3298, 3845, 5780, 3276
32659, 3298, 5780, 3845, 3897
32660, 5987, 3691, 4701, 3670
32661, 5987, 4701, 3691, 5712
32662, 3451, 3177, 5413, 2152
32663, 3451, 5413, 3177, 3466
32664, 3132, 3708, 204, 3894
32665, 204, 3708, 3132, 2110
32666, 4232, 3024, 5262, 2305
32667, 4232, 5262, 3024, 4891
