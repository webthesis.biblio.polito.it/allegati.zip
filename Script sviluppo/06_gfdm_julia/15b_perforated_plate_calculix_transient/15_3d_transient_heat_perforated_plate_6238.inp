8118, 3701, 3737, 3889
8119, 3739, 3701, 3881
8120, 3820, 3701, 3889
8121, 3702, 3821, 3863
8122, 3852, 3702, 3875
8123, 3702, 3863, 3875
8124, 3703, 3806, 3808
8125, 3806, 3703, 3827
8126, 3703, 3808, 3814
8127, 3704, 3795, 3797
8128, 3795, 3704, 3824
8129, 3704, 3797, 3813
8130, 3705, 3791, 3793
8131, 3791, 3705, 3819
8132, 3705, 3793, 3824
8133, 3732, 3706, 3733
8134, 3706, 3732, 3885
8135, 3733, 3706, 3734
8136, 3734, 3706, 3891
8137, 3759, 3707, 3892
8138, 3707, 3759, 3894
8139, 3707, 3816, 3871
8140, 3707, 3871, 3892
8141, 3757, 3708, 3759
8142, 3708, 3757, 3760
8143, 3759, 3708, 3894
8144, 3708, 3760, 3879
8145, 3743, 3709, 3847
8146, 3709, 3743, 3887
8147, 3831, 3709, 3887
8148, 3710, 3817, 3865
8149, 3818, 3710, 3866
8150, 3710, 3865, 3866
8151, 3711, 3818, 3867
8152, 3829, 3711, 3868
8153, 3711, 3867, 3868
8154, 3826, 3712, 3858
8155, 3712, 3851, 3858
8156, 3851, 3712, 3872
8157, 3713, 3771, 3772
8158, 3713, 3772, 3773
8159, 3713, 3773, 3830
8160, 3714, 3828, 3859
8161, 3850, 3714, 3873
8162, 3714, 3859, 3873
8163, 3715, 3822, 3861
8164, 3828, 3715, 3860
8165, 3860, 3715, 3861
8166, 3778, 3716, 3834
8167, 3716, 3830, 3832
8168, 3716, 3832, 3834
8169, 3717, 3802, 3804
8170, 3802, 3717, 3836
8171, 3717, 3804, 3827
8172, 3823, 3718, 3882
8173, 3718, 3835, 3842
8174, 3718, 3842, 3882
8175, 3822, 3719, 3862
8176, 3719, 3853, 3862
8177, 3853, 3719, 3874
8178, 3821, 3720, 3864
8179, 3720, 3855, 3864
8180, 3855, 3720, 3876
8181, 3729, 3721, 3848
8182, 3721, 3729, 3888
8183, 3741, 3721, 3888
8184, 3816, 3722, 3870
8185, 3722, 3829, 3869
8186, 3722, 3869, 3870
8187, 3761, 3723, 3849
8188, 3723, 3761, 3883
8189, 3849, 3723, 3890
8190, 3723, 3879, 3890
8191, 3742, 3724, 3743
8192, 3743, 3724, 3744
8193, 3744, 3724, 3846
8194, 3728, 3725, 3729
8195, 3729, 3725, 3730
8196, 3730, 3725, 3845
8197, 3744, 3726, 3746
8198, 3726, 3744, 3846
8199, 3746, 3726, 3886
8200, 3726, 3846, 3898
8201, 3730, 3727, 3732
8202, 3727, 3730, 3845
8203, 3732, 3727, 3885
8204, 3727, 3845, 3897
8205, 3728, 3729, 3848
8206, 3728, 3848, 3896
8207, 3729, 3730, 3731
8208, 3729, 3731, 3888
8209, 3731, 3730, 3732
8210, 3731, 3732, 3733
8211, 3731, 3733, 3740
8212, 3731, 3740, 3888
8213, 3733, 3734, 3735
8214, 3733, 3735, 3740
8215, 3735, 3734, 3736
8216, 3736, 3734, 3823
8217, 3823, 3734, 3891
8218, 3735, 3736, 3737
8219, 3735, 3737, 3739
8220, 3735, 3739, 3740
8221, 3737, 3736, 3738
8222, 3738, 3736, 3882
8223, 3736, 3823, 3882
8224, 3737, 3738, 3889
8225, 3812, 3738, 3842
8226, 3738, 3812, 3843
8227, 3842, 3738, 3882
8228, 3738, 3843, 3889
8229, 3740, 3739, 3741
8230, 3741, 3739, 3881
8231, 3740, 3741, 3888
8232, 3742, 3743, 3847
8233, 3742, 3847, 3895
8234, 3743, 3744, 3745
8235, 3743, 3745, 3887
8236, 3745, 3744, 3746
8237, 3745, 3746, 3747
8238, 3745, 3747, 3748
8239, 3745, 3748, 3887
8240, 3748, 3747, 3749
8241, 3749, 3747, 3761
8242, 3748, 3749, 3750
8243, 3748, 3750, 3831
8244, 3748, 3831, 3887
8245, 3750, 3749, 3751
8246, 3751, 3749, 3849
8247, 3749, 3761, 3849
8248, 3831, 3750, 3884
8249, 3752, 3751, 3753
8250, 3753, 3751, 3849
8251, 3752, 3753, 3754
8252, 3752, 3754, 3755
8253, 3752, 3755, 3880
8254, 3754, 3753, 3760
8255, 3760, 3753, 3890
8256, 3753, 3849, 3890
8257, 3755, 3754, 3756
8258, 3756, 3754, 3757
8259, 3757, 3754, 3760
8260, 3755, 3756, 3893
8261, 3880, 3755, 3893
8262, 3756, 3757, 3758
8263, 3756, 3758, 3844
8264, 3758, 3757, 3759
8265, 3758, 3759, 3892
8266, 3844, 3758, 3878
8267, 3878, 3758, 3892
8268, 3879, 3760, 3890
8269, 3763, 3762, 3765
8270, 3765, 3762, 3841
8271, 3764, 3763, 3767
8272, 3763, 3765, 3766
8273, 3763, 3766, 3767
8274, 3764, 3767, 3768
8275, 3764, 3768, 3769
8276, 3764, 3769, 3833
8277, 3766, 3765, 3878
8278, 3765, 3841, 3844
8279, 3765, 3844, 3878
8280, 3767, 3766, 3870
8281, 3870, 3766, 3871
8282, 3871, 3766, 3878
8283, 3768, 3767, 3869
8284, 3869, 3767, 3870
8285, 3769, 3768, 3770
8286, 3770, 3768, 3868
8287, 3868, 3768, 3869
8288, 3769, 3770, 3839
8289, 3833, 3769, 3838
8290, 3838, 3769, 3839
8291, 3839, 3770, 3840
8292, 3840, 3770, 3867
8293, 3867, 3770, 3868
8294, 3772, 3771, 3777
8295, 3773, 3772, 3774
8296, 3774, 3772, 3776
8297, 3776, 3772, 3777
8298, 3773, 3774, 3775
8299, 3773, 3775, 3832
8300, 3830, 3773, 3832
8301, 3775, 3774, 3857
8302, 3774, 3776, 3865
8303, 3857, 3774, 3865
8304, 3832, 3775, 3837
8305, 3837, 3775, 3856
8306, 3856, 3775, 3857
8307, 3776, 3777, 3840
8308, 3776, 3840, 3866
8309, 3865, 3776, 3866
8310, 3777, 3839, 3840
8311, 3779, 3778, 3834
8312, 3780, 3779, 3781
8313, 3781, 3779, 3783
8314, 3783, 3779, 3834
8315, 3780, 3781, 3782
8316, 3780, 3782, 3784
8317, 3780, 3784, 3815
8318, 3782, 3781, 3786
8319, 3781, 3783, 3851
8320, 3786, 3781, 3851
8321, 3784, 3782, 3785
8322, 3785, 3782, 3873
8323, 3782, 3786, 3873
8324, 3783, 3834, 3837
8325, 3783, 3837, 3858
8326, 3851, 3783, 3858
8327, 3784, 3785, 3787
8328, 3784, 3787, 3825
8329, 3815, 3784, 3825
8330, 3787, 3785, 3788
8331, 3788, 3785, 3859
8332, 3859, 3785, 3873
8333, 3850, 3786, 3872
8334, 3786, 3850, 3873
8335, 3786, 3851, 3872
8336, 3787, 3788, 3789
8337, 3789, 3788, 3790
8338, 3790, 3788, 3860
8339, 3788, 3859, 3860
8340, 3789, 3790, 3791
8341, 3789, 3791, 3819
8342, 3791, 3790, 3792
8343, 3792, 3790, 3861
8344, 3790, 3860, 3861
8345, 3791, 3792, 3793
8346, 3793, 3792, 3794
8347, 3794, 3792, 3862
8348, 3792, 3861, 3862
8349, 3793, 3794, 3795
8350, 3793, 3795, 3824
8351, 3795, 3794, 3796
8352, 3796, 3794, 3853
8353, 3853, 3794, 3862
8354, 3795, 3796, 3797
8355, 3797, 3796, 3798
8356, 3798, 3796, 3801
8357, 3801, 3796, 3853
8358, 3797, 3798, 3799
8359, 3797, 3799, 3813
8360, 3799, 3798, 3800
8361, 3800, 3798, 3875
8362, 3798, 3801, 3875
8363, 3799, 3800, 3802
8364, 3799, 3802, 3836
8365, 3813, 3799, 3836
8366, 3802, 3800, 3803
8367, 3803, 3800, 3863
8368, 3863, 3800, 3875
8369, 3852, 3801, 3874
8370, 3801, 3852, 3875
8371, 3801, 3853, 3874
8372, 3802, 3803, 3804
8373, 3804, 3803, 3805
8374, 3805, 3803, 3864
8375, 3803, 3863, 3864
8376, 3804, 3805, 3806
8377, 3804, 3806, 3827
8378, 3806, 3805, 3807
8379, 3807, 3805, 3855
8380, 3855, 3805, 3864
8381, 3806, 3807, 3808
8382, 3808, 3807, 3809
8383, 3809, 3807, 3811
8384, 3811, 3807, 3855
8385, 3808, 3809, 3810
8386, 3808, 3810, 3814
8387, 3810, 3809, 3812
8388, 3809, 3811, 3877
8389, 3812, 3809, 3877
8390, 3810, 3812, 3842
8391, 3814, 3810, 3835
8392, 3835, 3810, 3842
8393, 3854, 3811, 3876
8394, 3811, 3854, 3877
8395, 3811, 3855, 3876
8396, 3843, 3812, 3877
8397, 3816, 3870, 3871
8398, 3817, 3857, 3865
8399, 3818, 3866, 3867
8400, 3843, 3820, 3889
8401, 3863, 3821, 3864
8402, 3861, 3822, 3862
8403, 3856, 3826, 3858
8404, 3859, 3828, 3860
8405, 3829, 3868, 3869
8406, 3834, 3832, 3837
8407, 3837, 3856, 3858
8408, 3866, 3840, 3867
8409, 3871, 3878, 3892
*ELEMENT, type=C3D4, ELSET=Volume1
8410, 5039, 5158, 3957, 5728
8411, 489, 5471, 4727, 5743
8412, 4474, 4629, 770, 6131
8413, 4107, 3957, 5158, 5728
8414, 1095, 4500, 3825, 5632
8415, 4018, 4955, 4330, 5190
8416, 434, 4569, 4992, 5232
8417, 4824, 5129, 4734, 5221
8418, 1279, 4431, 4362, 5794
8419, 858, 4674, 4062, 4857
8420, 4123, 4598, 984, 4661
8421, 2852, 4607, 4251, 4633
8422, 3916, 5202, 4272, 5678
8423, 2641, 4256, 4852, 5986
8424, 890, 1343, 4206, 4689
8425, 3900, 4443, 4206, 4689
8426, 448, 5530, 4155, 5642
8427, 3929, 4300, 4231, 6053
8428, 2523, 2525, 4600, 5013
8429, 4352, 4784, 903, 5759
8430, 3957, 4081, 4364, 5158
8431, 2641, 4256, 2639, 4852
8432, 2280, 4574, 4834, 5660
8433, 4333, 4566, 1020, 4805
8434, 649, 5092, 750, 5820
8435, 3160, 4405, 4327, 5561
8436, 3500, 4707, 4640, 5263
8437, 4155, 450, 4738, 5530
8438, 4202, 4791, 942, 6175
8439, 3916, 5369, 4176, 5450
8440, 4172, 4600, 2525, 5013
8441, 4241, 4569, 1006, 4855
8442, 4163, 4503, 3613, 5133
8443, 4202, 4535, 942, 4791
8444, 3916, 4658, 5369, 5450
8445, 4106, 4292, 3952, 5214
8446, 4227, 4021, 4881, 5419
8447, 1023, 4805, 4373, 4961
8448, 4063, 4002, 4482, 4488
8449, 3952, 4292, 4106, 5205
8450, 647, 4197, 574, 4745
8451, 4081, 3957, 5039, 5158
8452, 4255, 4548, 4037, 5415
8453, 4107, 4401, 3957, 5728
8454, 1015, 4461, 1012, 4855
8455, 1074, 4296, 3813, 4752
8456, 1010, 1006, 4569, 4855
8457, 664, 4741, 663, 4835
8458, 2715, 3369, 3316, 4384
8459, 4645, 4330, 4955, 5190
8460, 2566, 2587, 4269, 4616
8461, 529, 5120, 4613, 5259
8462, 1309, 4700, 4195, 5364
8463, 450, 4155, 4738, 5475
8464, 4909, 5348, 5168, 5907
8465, 543, 4549, 4673, 5366
8466, 3942, 4777, 5341, 5429
8467, 2854, 2852, 4251, 4633
8468, 4129, 2374, 4677, 5406
8469, 3163, 4389, 3547, 4890
8470, 4734, 4824, 3975, 5129
8471, 4204, 5412, 737, 5525
8472, 3971, 5470, 5032, 5630
8473, 4089, 5202, 3916, 5678
8474, 613, 4284, 1038, 5997
8475, 2803, 4755, 4774, 5599
8476, 4738, 5530, 450, 5633
8477, 529, 587, 4613, 5120
8478, 452, 4211, 4678, 5554
8479, 647, 4197, 4745, 4899
8480, 4056, 4504, 4864, 4996
8481, 3912, 4382, 4165, 4721
8482, 1023, 4111, 4805, 4961
8483, 663, 4741, 4345, 4835
8484, 4175, 4339, 3966, 4759
8485, 770, 4474, 1291, 4629
8486, 4284, 4692, 1038, 5997
8487, 4974, 5244, 3919, 5590
8488, 448, 4346, 5530, 5642
8489, 2267, 4217, 2257, 4720
8490, 647, 576, 574, 4197
8491, 4162, 4679, 621, 5963
8492, 3995, 4797, 4244, 6191
8493, 2713, 4934, 4490, 5176
8494, 3945, 4876, 4102, 5115
8495, 3972, 4251, 4496, 5887
8496, 3930, 4167, 4549, 5281
8497, 649, 4324, 5092, 5820
8498, 4075, 2188, 4973, 5351
8499, 4465, 4935, 2403, 4998
8500, 622, 4360, 4595, 5102
8501, 1188, 737, 5412, 5525
8502, 4155, 5530, 4346, 5642
8503, 3966, 4339, 4175, 5101
8504, 664, 4741, 4835, 6076
8505, 5006, 5080, 3939, 5707
8506, 576, 4197, 647, 4899
8507, 1281, 984, 4123, 4598
8508, 4249, 4440, 3938, 5950
8509, 1256, 942, 4791, 6175
8510, 3957, 4778, 4107, 5158
8511, 4117, 5187, 5162, 5885
8512, 4343, 4712, 3946, 5126
8513, 452, 4678, 4211, 5307
8514, 3995, 4130, 4797, 6191
8515, 942, 4202, 1259, 4535
8516, 1186, 4954, 5547, 5860
8517, 3939, 5080, 5006, 5475
8518, 4090, 4004, 4914, 5736
8519, 503, 4718, 4100, 4892
8520, 3090, 4667, 3035, 5188
8521, 3908, 4353, 4117, 5527
8522, 3090, 4667, 5188, 5751
8523, 4490, 4934, 3134, 5984
8524, 4117, 4353, 3908, 5187
8525, 4133, 5162, 5187, 5885
8526, 3934, 5454, 4476, 5700
8527, 2852, 4251, 4607, 5729
8528, 3995, 4244, 4223, 4969
8529, 3957, 4401, 4107, 5086
8530, 2607, 5394, 4531, 5647
8531, 4120, 3946, 4712, 5126
8532, 4120, 4712, 4343, 5126
8533, 1015, 4569, 4461, 4855
8534, 5168, 5348, 4149, 5907
8535, 3580, 3686, 3174, 4508
8536, 2719, 4327, 3160, 4405
8537, 503, 4892, 4100, 6050
8538, 4206, 3900, 4689, 4715
8539, 3939, 5000, 5093, 5479
8540, 4179, 3959, 4792, 5545
8541, 4103, 4211, 4695, 5127
8542, 3929, 4231, 4300, 4841
8543, 4768, 5061, 989, 5196
8544, 4531, 5394, 4340, 5647
8545, 4485, 4542, 683, 4770
8546, 748, 4740, 5496, 5634
8547, 3926, 4232, 5168, 5242
8548, 4100, 4718, 503, 6050
8549, 4113, 3908, 4716, 5793
8550, 1041, 5333, 5265, 5493
8551, 4362, 4431, 1279, 5122
8552, 4697, 4954, 1140, 5589
8553, 3900, 4443, 4689, 5643
8554, 3930, 4549, 4167, 4659
8555, 543, 4673, 4098, 5366
8556, 3924, 4866, 4282, 5203
8557, 3845, 4349, 3897, 5780
8558, 4061, 4257, 4286, 5586
8559, 4337, 4879, 3903, 4921
8560, 2314, 4272, 4453, 4643
8561, 2673, 4242, 4532, 5485
8562, 4156, 4376, 3939, 4737
8563, 4093, 4834, 4574, 5660
8564, 2199, 2197, 4359, 4545
8565, 4102, 3945, 5152, 5749
8566, 4085, 4565, 4802, 5303
8567, 4278, 2508, 5671, 6181
8568, 3221, 4606, 2100, 5261
8569, 1140, 4954, 1139, 5589
8570, 4061, 4286, 4257, 5657
8571, 2220, 4703, 4118, 4991
8572, 4000, 4487, 5149, 5154
8573, 4089, 3916, 4511, 5678
8574, 4098, 4673, 4549, 5366
8575, 3924, 4434, 4866, 5203
8576, 1089, 4747, 4329, 4957
8577, 3939, 5006, 4738, 5475
8578, 989, 4768, 4334, 5061
8579, 4141, 4557, 690, 6180
8580, 4282, 4866, 4434, 5203
8581, 4168, 4824, 4734, 5221
8582, 3063, 5906, 5028, 6128
8583, 3945, 4102, 5152, 5559
8584, 1012, 4855, 4461, 5144
8585, 4737, 5006, 3939, 5707
8586, 3940, 4565, 4913, 5303
8587, 4056, 4864, 4504, 4952
8588, 3900, 4206, 4443, 5643
8589, 4144, 4783, 4145, 5812
8590, 4141, 690, 4780, 6180
8591, 4211, 5003, 4678, 5554
8592, 4350, 5149, 4487, 5154
8593, 4161, 3915, 4465, 4935
8594, 4545, 5497, 5240, 6024
8595, 3910, 4145, 4783, 5812
8596, 1023, 4111, 4961, 5954
8597, 3982, 4434, 4106, 6072
8598, 4416, 5188, 4667, 5751
8599, 2483, 4283, 4722, 5023
8600, 3939, 4737, 5000, 5479
8601, 1156, 4747, 1089, 4957
8602, 3073, 5240, 5497, 6024
8603, 3957, 4364, 4081, 4710
8604, 4002, 4488, 4063, 5213
8605, 1186, 4954, 4602, 5547
8606, 4679, 4975, 621, 5963
8607, 4474, 770, 4776, 6131
8608, 4079, 5547, 4954, 5860
8609, 3945, 4102, 4876, 5749
8610, 4332, 4503, 3960, 5902
8611, 4585, 5002, 3908, 6079
8612, 2565, 4616, 4269, 4789
8613, 1006, 4569, 4241, 6009
8614, 4223, 4244, 3995, 4963
8615, 3221, 2100, 2965, 5261
8616, 2181, 4560, 4207, 4800
8617, 3921, 4553, 4196, 4691
8618, 2660, 3119, 4246, 4579
8619, 670, 4507, 4398, 4873
8620, 4598, 5033, 4250, 5390
8621, 4944, 5257, 3251, 5495
8622, 603, 4460, 4179, 4791
8623, 4041, 5239, 4533, 5964
8624, 4054, 5244, 4974, 5590
8625, 1279, 5359, 4431, 5794
8626, 3919, 4974, 4432, 5244
8627, 750, 5092, 4421, 5820
8628, 4389, 4948, 3997, 5220
8629, 4041, 4533, 5239, 5553
8630, 4198, 5423, 5455, 5511
8631, 622, 4595, 4231, 5102
8632, 4457, 4914, 4004, 5736
8633, 4024, 4328, 4124, 5875
8634, 4113, 4716, 4274, 5793
8635, 4299, 4305, 3952, 4882
8636, 1095, 3825, 4500, 5508
8637, 3908, 4353, 4936, 5187
8638, 3580, 3628, 3686, 4508
8639, 5028, 5906, 4245, 6128
8640, 3922, 4103, 4813, 5744
8641, 3943, 4208, 4518, 5436
8642, 1401, 4443, 1366, 5646
8643, 1095, 4410, 3825, 5508
8644, 3981, 4864, 4504, 4996
8645, 1156, 4747, 4184, 5181
8646, 4198, 5455, 4045, 5511
8647, 1343, 4206, 4689, 4715
8648, 4206, 890, 4689, 5646
8649, 4236, 4652, 3899, 5890
8650, 4945, 5511, 4114, 5578
8651, 4588, 5028, 3063, 5906
8652, 4237, 4041, 5011, 5239
8653, 3090, 5188, 4416, 5751
8654, 3251, 5495, 5257, 6043
8655, 3955, 4774, 4064, 5095
8656, 4585, 4716, 3908, 5002
8657, 4295, 4458, 384, 4794
8658, 2641, 4688, 4256, 5986
8659, 3939, 4376, 4158, 5692
8660, 1366, 4689, 890, 5646
8661, 2314, 4453, 4272, 5075
8662, 4365, 4576, 3127, 4999
8663, 4196, 4553, 3921, 5555
8664, 2197, 4359, 4545, 5004
8665, 3952, 4305, 4299, 4947
8666, 4706, 5165, 4894, 5179
8667, 1366, 4443, 4689, 5646
8668, 3955, 4064, 4847, 5095
8669, 4269, 4657, 2567, 4789
8670, 3981, 4504, 4864, 4952
8671, 3916, 4176, 5128, 5450
8672, 4381, 4888, 2812, 5085
8673, 4722, 5410, 2738, 5669
8674, 3953, 4271, 4170, 5748
8675, 3957, 4364, 4778, 5158
8676, 3910, 4495, 4275, 4948
8677, 4301, 5469, 4729, 5600
8678, 2607, 4717, 4531, 5394
8679, 4031, 4992, 4569, 5232
8680, 3927, 4729, 4152, 5600
8681, 2855, 4107, 2856, 5659
8682, 1156, 4184, 4747, 4957
8683, 4295, 4794, 384, 5804
8684, 4545, 4028, 5240, 5497
8685, 3916, 5165, 4658, 5450
8686, 3927, 4152, 5128, 5600
8687, 2929, 3063, 5028, 6128
8688, 3908, 4117, 4588, 5527
8689, 1160, 621, 4162, 4679
8690, 4909, 5168, 4554, 5907
8691, 4085, 4913, 4565, 5303
8692, 2564, 4269, 2567, 4789
8693, 4245, 5028, 4588, 5906
8694, 4106, 4434, 3982, 5132
8695, 3897, 4349, 346, 5780
8696, 1170, 4493, 5373, 5849
8697, 4645, 4763, 4330, 5190
8698, 3900, 4715, 4206, 5438
8699, 748, 5496, 787, 5634
8700, 417, 415, 4425, 5462
8701, 1309, 4195, 5237, 5364
8702, 3940, 4802, 4565, 5303
8703, 4271, 4561, 2346, 4607
8704, 5191, 5527, 2488, 5906
8705, 4227, 4881, 4455, 5419
8706, 2566, 2567, 2564, 4269
8707, 2587, 4269, 4616, 4626
8708, 4236, 5410, 4652, 5890
8709, 3943, 4518, 4988, 5436
8710, 3953, 4170, 4271, 4965
8711, 2565, 4269, 2564, 4789
8712, 3938, 4440, 4249, 5253
8713, 3934, 4147, 5454, 5700
8714, 4553, 5139, 3921, 5555
8715, 2715, 4384, 3316, 5266
8716, 2713, 3134, 4490, 4934
8717, 4028, 4545, 5240, 6024
8718, 804, 4195, 1309, 4700
8719, 4024, 4124, 4328, 5257
8720, 4481, 5121, 4051, 5391
8721, 3921, 4553, 4260, 5139
8722, 4162, 621, 5027, 5963
8723, 4301, 4729, 3927, 5600
8724, 3972, 4496, 5279, 5887
8725, 2181, 2183, 4560, 4800
8726, 2856, 4107, 2855, 4991
8727, 4613, 5120, 4109, 5259
8728, 858, 4857, 4062, 5528
8729, 598, 5102, 4399, 5440
8730, 4374, 5152, 3945, 5749
8731, 448, 4346, 454, 5530
8732, 683, 4542, 4485, 5459
8733, 4333, 4805, 1020, 5789
8734, 485, 5471, 489, 5743
8735, 890, 1366, 1343, 4689
8736, 2187, 4973, 2188, 5351
8737, 3924, 4789, 4616, 5433
8738, 4894, 5165, 4196, 5179
8739, 4107, 4633, 2855, 4991
8740, 4056, 4462, 4804, 4864
8741, 3369, 2715, 2714, 4384
8742, 4197, 4325, 3905, 6019
8743, 2623, 3160, 2719, 4327
8744, 4562, 4968, 3660, 5133
8745, 4250, 4006, 4621, 5417
8746, 3959, 4418, 4184, 4747
8747, 5032, 5470, 4066, 5630
8748, 770, 4629, 1291, 6131
8749, 2660, 4579, 4246, 5044
8750, 4084, 4250, 5033, 5390
8751, 2543, 4275, 2544, 4586
8752, 3925, 4695, 4211, 5127
8753, 4081, 5158, 5039, 5728
8754, 4221, 803, 5576, 6030
8755, 3045, 4703, 2220, 4991
8756, 4357, 4569, 4031, 4992
8757, 3926, 5168, 4429, 5242
8758, 4250, 4006, 5417, 6104
8759, 4399, 5440, 5102, 6078
8760, 4120, 4712, 3946, 5717
8761, 4156, 5093, 3946, 6044
8762, 2883, 5332, 4303, 5708
8763, 2713, 4397, 4934, 5176
8764, 737, 5157, 4204, 5525
8765, 3882, 4775, 4469, 5572
8766, 2566, 2565, 2587, 4616
8767, 2566, 4269, 2565, 4616
8768, 4612, 5357, 4201, 6237
8769, 484, 4572, 4263, 5743
8770, 4117, 5527, 5191, 5906
8771, 4602, 4954, 4079, 5547
8772, 5029, 5322, 4517, 5434
8773, 4341, 3997, 4948, 5220
8774, 2546, 4262, 2463, 6129
8775, 1020, 4566, 4333, 5493
8776, 2803, 4755, 4279, 4774
8777, 4181, 4746, 4777, 5341
8778, 3971, 5032, 4817, 5630
8779, 4156, 3946, 4705, 6044
8780, 2673, 4242, 2627, 4532
8781, 2564, 2565, 2566, 4269
8782, 4262, 4723, 2463, 6129
8783, 858, 881, 4674, 4857
8784, 4106, 5214, 3952, 5342
8785, 4057, 4517, 5322, 5434
8786, 484, 4749, 4572, 5743
8787, 4161, 4465, 3915, 4761
8788, 4570, 4120, 5193, 5537
8789, 4294, 4383, 3984, 4697
8790, 1238, 4680, 4317, 4858
8791, 1139, 4954, 4383, 5589
8792, 4161, 4763, 3915, 5618
8793, 3954, 4958, 4325, 5250
8794, 4337, 4530, 3903, 4879
8795, 4257, 5657, 4286, 5807
8796, 4309, 5031, 1137, 5919
8797, 3168, 4657, 4242, 5995
8798, 4267, 4549, 3930, 5439
8799, 4031, 4569, 4357, 5698
8800, 622, 4360, 738, 4595
8801, 452, 444, 4678, 5307
8802, 4120, 3946, 5126, 5717
8803, 4174, 4792, 3959, 5545
8804, 3900, 4785, 4715, 5438
8805, 3939, 4158, 4737, 5692
8806, 2714, 2715, 3193, 4384
8807, 804, 4195, 4700, 5257
8808, 1026, 5333, 1041, 5493
8809, 4303, 4646, 2883, 5708
8810, 4049, 4378, 4327, 4625
8811, 4112, 3933, 4925, 5037
8812, 738, 4716, 4360, 6193
8813, 1023, 1157, 4373, 4805
8814, 3905, 4325, 4197, 5505
8815, 3946, 4712, 5093, 5276
8816, 2457, 4191, 4988, 5087
8817, 3534, 4090, 5248, 5291
8818, 3939, 4737, 4376, 5692
8819, 4559, 4908, 4406, 4918
8820, 3961, 5612, 5185, 6187
8821, 3929, 4617, 4300, 6053
8822, 452, 444, 451, 4678
8823, 4064, 4362, 4215, 4847
8824, 4057, 5132, 4434, 5322
8825, 3598, 4291, 323, 4939
8826, 2483, 4283, 3068, 4722
8827, 3168, 2627, 4242, 4657
8828, 2273, 4693, 4276, 4912
8829, 4159, 3957, 4367, 5327
8830, 3888, 4391, 5046, 5321
8831, 903, 4784, 4352, 5844
8832, 4217, 2257, 4720, 4862
8833, 4908, 5566, 2304, 5822
8834, 4278, 5433, 2508, 6181
8835, 3912, 4109, 4727, 4896
8836, 2187, 4466, 4973, 5351
8837, 3168, 2627, 4657, 5602
8838, 4570, 5193, 5108, 5537
8839, 4283, 3904, 5023, 5889
8840, 4265, 4642, 3913, 5042
8841, 4361, 4926, 3020, 5705
8842, 3067, 4381, 2812, 5085
8843, 4019, 5341, 4777, 5429
8844, 4734, 3975, 5329, 5977
8845, 980, 4661, 4355, 4739
8846, 3576, 4389, 4809, 5001
8847, 3209, 2625, 3016, 4228
8848, 3957, 4159, 4367, 4844
8849, 4549, 4659, 3930, 5439
8850, 4330, 4955, 4018, 5330
8851, 2955, 3070, 2220, 4118
8852, 3939, 5080, 4166, 5707
8853, 4337, 4694, 4185, 4921
8854, 2673, 4827, 4242, 5485
8855, 3930, 4549, 5278, 5281
8856, 4179, 4747, 3959, 5545
8857, 4215, 4362, 4064, 5164
8858, 4198, 5035, 4045, 5455
8859, 4018, 4679, 4763, 5290
8860, 5530, 5633, 4738, 6211
8861, 4390, 5002, 4916, 5793
8862, 3972, 5532, 4251, 5887
8863, 4155, 5530, 4738, 6211
8864, 417, 4425, 4599, 5462
8865, 4450, 4538, 2436, 4826
8866, 3744, 4224, 4846, 5062
8867, 4369, 5324, 4118, 5466
8868, 4263, 4727, 4144, 5471
8869, 4425, 5462, 415, 5525
8870, 4485, 5011, 4041, 5239
8871, 4260, 4553, 3921, 5840
8872, 2970, 4536, 2452, 5882
8873, 3910, 4145, 4455, 4783
8874, 4321, 5080, 5006, 5707
8875, 2100, 4606, 3543, 5261
8876, 3915, 4419, 4132, 4935
8877, 4548, 5415, 4255, 5908
8878, 3951, 4601, 4204, 5412
8879, 3954, 4268, 4744, 4958
8880, 3888, 5046, 4391, 5284
8881, 4517, 5258, 5029, 5434
8882, 679, 4570, 4194, 4920
8883, 984, 996, 997, 4899
8884, 3954, 4268, 4958, 5250
8885, 2452, 4536, 5378, 5882
8886, 984, 4899, 4123, 5718
8887, 4562, 5395, 4247, 5734
8888, 2452, 5378, 4631, 5882
8889, 4417, 4722, 2738, 5669
8890, 4096, 4406, 3964, 5566
8891, 1238, 949, 4317, 4680
8892, 3956, 4787, 5320, 5502
8893, 3160, 5561, 4327, 6028
8894, 4013, 4492, 5235, 5397
8895, 3904, 4579, 4283, 5023
8896, 3956, 5320, 5319, 5502
8897, 3973, 5108, 5193, 5717
8898, 4135, 3978, 5268, 5301
8899, 3939, 4166, 4737, 5707
8900, 3943, 4709, 4379, 5350
8901, 622, 694, 4231, 4595
8902, 3973, 4101, 5108, 5717
8903, 980, 4739, 4355, 5896
8904, 3983, 4804, 4462, 4864
8905, 3914, 5209, 4400, 5245
8906, 3484, 2100, 3543, 5261
8907, 3915, 4763, 4330, 5618
8908, 5078, 5264, 4976, 5402
8909, 2970, 2452, 4631, 5882
8910, 796, 5576, 803, 6030
8911, 3907, 5556, 4507, 5835
8912, 1079, 4471, 4396, 4904
8913, 1080, 4396, 1079, 4471
8914, 3927, 5274, 4456, 5570
8915, 4951, 5008, 4764, 5642
8916, 4690, 5185, 3961, 5612
8917, 2436, 4538, 2438, 4826
8918, 4149, 4554, 5168, 5907
8919, 764, 762, 765, 4282
8920, 3982, 4626, 5150, 5755
8921, 2855, 2856, 2857, 5659
8922, 4057, 4866, 4434, 5132
8923, 738, 4595, 4360, 4716
8924, 4103, 5517, 4813, 5744
8925, 4108, 4885, 3555, 5112
8926, 4727, 5471, 4263, 5743
8927, 4764, 4951, 3947, 5008
8928, 3845, 3276, 4349, 5780
8929, 4155, 5080, 3939, 5475
8930, 4224, 4332, 3960, 5902
8931, 2883, 2884, 5332, 5708
8932, 4474, 5027, 1348, 5539
8933, 1265, 1010, 1006, 4569
8934, 3998, 5351, 4498, 5543
8935, 3982, 4106, 4649, 6072
8936, 764, 4282, 765, 5836
8937, 3920, 4237, 5011, 5239
8938, 4274, 5421, 3653, 5623
8939, 4288, 4665, 1060, 5520
8940, 4272, 5075, 3916, 5678
8941, 1095, 5508, 4500, 5632
8942, 2716, 4384, 3193, 5266
8943, 2273, 4276, 2271, 4912
8944, 4352, 4449, 3963, 4784
8945, 3920, 5239, 4097, 5363
8946, 4133, 5084, 5162, 5885
8947, 3942, 5341, 4342, 5429
8948, 4362, 4847, 4064, 5095
8949, 4379, 4709, 4077, 5350
8950, 4068, 5469, 4301, 5600
8951, 3939, 5093, 4156, 5479
8952, 996, 4899, 984, 5718
8953, 492, 4530, 4337, 5741
8954, 4283, 5169, 3904, 5889
8955, 5007, 5653, 4315, 6213
8956, 2543, 4275, 4586, 4891
8957, 4269, 4657, 3900, 5602
8958, 2955, 3070, 4118, 4938
8959, 2965, 2100, 3484, 5261
8960, 2884, 2883, 4646, 5708
8961, 4249, 3938, 4832, 5950
8962, 2566, 4269, 2587, 5755
8963, 4361, 4609, 3020, 4926
8964, 3355, 4905, 4491, 5770
8965, 3900, 5602, 4242, 5643
8966, 448, 4155, 4764, 5642
8967, 4369, 5180, 4118, 5324
8968, 3965, 4945, 4114, 5578
8969, 4085, 4802, 4363, 5303
8970, 3981, 5221, 4168, 5990
8971, 718, 4584, 413, 5462
8972, 4395, 4915, 3693, 5286
8973, 4355, 5417, 4006, 6104
8974, 2169, 4563, 4205, 4989
8975, 4031, 4248, 4757, 5448
8976, 4194, 4920, 3973, 5243
8977, 1407, 323, 4291, 4939
8978, 3825, 5508, 4410, 5550
8979, 3944, 4346, 4155, 5530
8980, 4215, 4431, 4362, 5164
8981, 902, 5759, 4784, 5989
8982, 3924, 4647, 4434, 5203
8983, 4850, 5335, 2281, 5427
8984, 3923, 5239, 4533, 5553
8985, 3928, 4694, 4337, 4921
8986, 935, 4394, 3312, 5392
8987, 4695, 4533, 5554, 5696
8988, 4232, 3926, 4891, 5242
8989, 3952, 5214, 4452, 5342
8990, 3928, 4076, 4786, 4921
8991, 934, 3312, 935, 4394
8992, 3915, 4132, 4419, 4845
8993, 3981, 4824, 4168, 5221
8994, 5265, 5333, 4042, 5493
8995, 4269, 3900, 5150, 5602
8996, 1080, 4396, 4471, 5821
8997, 1156, 566, 4747, 5181
8998, 4006, 5030, 4208, 5350
8999, 3965, 5511, 4945, 5578
9000, 378, 5185, 5612, 5894
9001, 4031, 4913, 4248, 5448
9002, 2194, 2235, 4223, 4863
9003, 3961, 5612, 5214, 6122
9004, 642, 4324, 4602, 5092
9005, 901, 4352, 903, 5759
9006, 3955, 4064, 4774, 4847
9007, 985, 4780, 4311, 5500
9008, 4145, 4783, 4144, 4979
9009, 4185, 4879, 4337, 4921
9010, 2951, 2484, 2329, 4237
9011, 4247, 4562, 3620, 6091
9012, 3924, 4404, 4789, 5433
9013, 4021, 4227, 4783, 5419
9014, 4497, 5115, 2914, 5815
9015, 2716, 4875, 4384, 5266
9016, 4255, 4399, 3929, 5299
9017, 4041, 4237, 5011, 6047
9018, 4406, 5566, 4908, 5822
9019, 4051, 5214, 4481, 5391
9020, 4031, 4357, 5429, 5698
9021, 4004, 4090, 4914, 5248
9022, 4162, 4523, 1160, 4679
9023, 4101, 5002, 4585, 6079
9024, 4584, 5462, 718, 5809
9025, 655, 770, 1291, 6131
9026, 593, 653, 4629, 5829
9027, 1125, 4239, 855, 4662
9028, 598, 4399, 5102, 5870
9029, 2329, 2951, 4237, 4838
9030, 3943, 4629, 5529, 5829
9031, 4155, 3939, 4738, 5475
9032, 4481, 4051, 5121, 5893
9033, 4103, 4695, 3925, 5127
9034, 4384, 4875, 4641, 5266
9035, 3042, 2270, 4406, 4912
9036, 4161, 4935, 4998, 5618
9037, 1265, 4569, 1006, 6009
9038, 4018, 4330, 4763, 5190
9039, 4212, 4336, 4043, 5384
9040, 3971, 4817, 5470, 5630
9041, 1339, 4254, 5564, 5591
9042, 3982, 5150, 5175, 5755
9043, 4104, 5529, 4629, 5829
9044, 4299, 4989, 3122, 5230
9045, 4936, 5187, 4353, 5241
9046, 3939, 4156, 4737, 5479
9047, 4135, 3978, 4700, 5268
9048, 954, 4541, 4793, 5824
9049, 1013, 5144, 4461, 6218
9050, 2962, 4645, 4989, 5618
9051, 3620, 4562, 4247, 5734
9052, 3964, 4406, 4096, 5306
9053, 4077, 4379, 5350, 5354
9054, 2483, 4722, 4579, 5023
9055, 3900, 4940, 4206, 5643
9056, 3628, 3580, 3494, 4508
9057, 3612, 4503, 4200, 5133
9058, 765, 4282, 762, 4715
9059, 3916, 4152, 5075, 5128
9060, 3928, 4337, 4967, 5123
9061, 3942, 4777, 4746, 5341
9062, 613, 4749, 4284, 5997
9063, 1058, 4364, 4710, 5271
9064, 4013, 4387, 4492, 5397
9065, 4601, 5180, 4369, 5324
9066, 3917, 4087, 5465, 5652
9067, 3905, 4197, 5480, 5505
9068, 4161, 3915, 4935, 5618
9069, 2996, 2258, 4177, 4800
9070, 4031, 4757, 4248, 5993
9071, 4212, 4773, 4336, 4825
9072, 3160, 4327, 2623, 6028
9073, 4362, 4431, 4215, 5794
9074, 4292, 5132, 4106, 5205
9075, 3945, 5152, 4374, 5559
9076, 2347, 4561, 4430, 5740
9077, 4119, 5161, 4823, 5515
9078, 2764, 4626, 4616, 5427
9079, 4406, 4912, 2270, 5640
9080, 3954, 4744, 4325, 4958
9081, 715, 5666, 5204, 5908
9082, 4490, 4934, 4002, 5176
9083, 4431, 5359, 4215, 5794
9084, 4054, 4432, 4974, 5244
9085, 3961, 4233, 5214, 5612
9086, 4706, 4894, 3986, 5179
9087, 4212, 4825, 4336, 5384
9088, 3912, 4727, 4109, 6126
9089, 4461, 4569, 1015, 5232
9090, 2422, 4271, 2346, 4607
9091, 2273, 2271, 4276, 4693
9092, 1014, 1013, 4461, 6218
9093, 4257, 5586, 4061, 6049
9094, 3943, 4709, 4208, 5436
9095, 4579, 5044, 2683, 5949
9096, 2854, 2852, 2862, 4251
9097, 3516, 5078, 4976, 5402
9098, 3903, 4530, 4337, 5330
9099, 2525, 4600, 4172, 5394
9100, 679, 678, 4570, 4920
9101, 639, 4485, 4240, 5459
9102, 1023, 4373, 1157, 4961
9103, 1382, 5257, 4124, 5495
9104, 5108, 5537, 5193, 5717
9105, 3904, 4579, 5023, 5889
9106, 4024, 4944, 4124, 5257
9107, 4217, 4720, 2267, 4959
9108, 765, 4282, 4715, 5836
9109, 4002, 4490, 4489, 4934
9110, 980, 981, 4661, 4739
9111, 3920, 5011, 4485, 5239
9112, 3136, 4804, 5668, 6039
9113, 3944, 4155, 4346, 4951
9114, 709, 700, 627, 5750
9115, 2463, 2546, 2875, 4262
9116, 2255, 4134, 2537, 4813
9117, 4161, 4935, 4465, 4998
9118, 4109, 4758, 5010, 5745
9119, 4068, 4301, 5274, 5600
9120, 2273, 4119, 4693, 4912
9121, 4531, 4717, 2678, 5375
9122, 3919, 5244, 4319, 5590
9123, 2137, 3828, 2893, 4433
9124, 4031, 4357, 4992, 5429
9125, 4379, 3943, 5350, 5354
9126, 3914, 5089, 4400, 5209
9127, 5075, 5128, 4152, 5933
9128, 2267, 2257, 2256, 4720
9129, 4697, 4725, 975, 5460
9130, 2925, 4626, 4477, 5175
9131, 593, 4629, 4379, 5829
9132, 3897, 346, 1386, 5780
9133, 550, 4530, 492, 5741
9134, 941, 4460, 4535, 5211
9135, 3966, 4825, 4863, 5064
9136, 954, 4793, 692, 5824
9137, 4094, 4806, 5518, 5582
9138, 4074, 4652, 5410, 5890
9139, 1048, 1089, 4329, 4957
9140, 4242, 4657, 2627, 5602
9141, 3119, 4246, 4579, 5326
9142, 2955, 4118, 2220, 4832
9143, 2457, 4581, 4191, 5087
9144, 4269, 5150, 4626, 5755
9145, 3500, 4138, 3499, 4707
9146, 3828, 3715, 2893, 4433
9147, 4195, 5237, 5364, 5988
9148, 3982, 5175, 4626, 5755
9149, 4250, 4661, 4598, 5390
9150, 4109, 5010, 4758, 5120
9151, 4360, 5187, 4936, 5241
9152, 4221, 5131, 803, 6030
9153, 2546, 5549, 4262, 6129
9154, 2620, 4480, 4182, 5199
9155, 3985, 4478, 4243, 4843
9156, 3972, 5887, 5279, 6137
9157, 4013, 5235, 4387, 5397
9158, 3928, 4786, 4076, 5123
9159, 3972, 5532, 5887, 6137
9160, 4659, 5152, 4901, 5182
9161, 3916, 5128, 5165, 5450
9162, 4523, 4679, 4018, 5317
9163, 3930, 4901, 4659, 5152
9164, 3001, 4563, 2169, 4989
9165, 4050, 4674, 4314, 5420
9166, 3529, 3555, 4885, 5112
9167, 4398, 4507, 669, 5478
9168, 3678, 3660, 4562, 4968
9169, 384, 4458, 4295, 4714
9170, 3875, 4116, 3798, 4870
9171, 4773, 4825, 4212, 5384
9172, 3916, 5075, 4511, 5678
9173, 3966, 5064, 4863, 6162
9174, 4489, 4934, 4490, 5984
9175, 4569, 4992, 4357, 6009
9176, 4212, 4043, 4336, 5546
9177, 3927, 5570, 4692, 5655
9178, 3914, 4447, 5209, 5245
9179, 3997, 4341, 5001, 5220
9180, 2764, 2924, 4626, 5427
9181, 4043, 4863, 4825, 5064
9182, 4659, 4901, 3930, 5182
9183, 4312, 2678, 4717, 5375
9184, 3960, 4332, 4224, 5484
9185, 3972, 4496, 4251, 5729
9186, 502, 5347, 4662, 5446
9187, 4284, 5769, 4692, 5997
9188, 3997, 5001, 4389, 5220
9189, 4141, 4780, 690, 5500
9190, 4562, 3660, 5048, 5133
9191, 697, 4464, 5049, 5371
9192, 4269, 4626, 2587, 5755
9193, 2962, 4989, 3050, 5627
9194, 4699, 5118, 4322, 5652
9195, 4211, 4695, 5554, 5696
9196, 4103, 3922, 5696, 5744
9197, 2683, 4579, 2660, 5044
9198, 621, 4679, 500, 4975
9199, 4185, 4624, 3903, 4921
9200, 2591, 5173, 4457, 5619
9201, 4330, 4935, 3915, 5618
9202, 848, 1145, 4294, 4725
9203, 655, 1291, 4629, 6131
9204, 1058, 4710, 1159, 5271
9205, 1254, 1060, 4665, 5520
9206, 2591, 2575, 4457, 5173
9207, 4224, 5062, 3744, 5613
9208, 2951, 4635, 4237, 4838
9209, 4224, 4503, 4332, 5902
9210, 5214, 5612, 4233, 6122
9211, 3928, 4185, 4694, 4921
9212, 4218, 5120, 5010, 5631
9213, 1394, 819, 4334, 4768
9214, 1284, 4250, 4794, 5894
9215, 4114, 5455, 5423, 5511
9216, 1092, 4566, 4248, 4660
9217, 2107, 3163, 3547, 4890
9218, 3930, 4549, 4267, 5278
9219, 2508, 5252, 4278, 5671
9220, 4734, 5129, 3975, 5977
9221, 1382, 5495, 4124, 5725
9222, 4523, 4018, 5167, 5317
9223, 748, 4740, 4319, 5496
9224, 4310, 5235, 4513, 5578
9225, 698, 4464, 697, 5371
9226, 3998, 4543, 4498, 5351
9227, 4602, 5092, 3962, 5533
9228, 4421, 5092, 4324, 5820
9229, 4086, 3941, 4573, 4983
9230, 2802, 2803, 4774, 5599
9231, 3534, 4090, 4606, 5248
9232, 3964, 4912, 4119, 5161
9233, 941, 4535, 870, 5211
9234, 3251, 5257, 4944, 6043
9235, 585, 4287, 932, 5143
9236, 1281, 4123, 984, 5536
9237, 4376, 4737, 4156, 5238
9238, 2537, 4807, 4134, 5867
9239, 4389, 4890, 3107, 5056
9240, 3922, 4103, 4516, 4813
9241, 4548, 5263, 4037, 5415
9242, 480, 503, 4718, 6050
9243, 2866, 2852, 4607, 5729
9244, 4095, 5052, 5611, 5938
9245, 4337, 4530, 492, 5167
9246, 741, 4780, 985, 5500
9247, 3914, 4187, 4735, 5245
9248, 434, 4992, 4569, 6009
9249, 3933, 4419, 4112, 4600
9250, 2181, 4207, 2182, 4800
9251, 4975, 5027, 621, 5963
9252, 4708, 5227, 4140, 5726
9253, 2186, 4466, 4800, 4973
9254, 4224, 2642, 4688, 5613
9255, 3931, 4091, 4425, 5525
9256, 2959, 4655, 5275, 5483
9257, 4500, 5508, 3825, 5550
9258, 2459, 4788, 4509, 5247
9259, 2186, 4466, 2185, 4800
9260, 4255, 3929, 5055, 5299
9261, 3947, 4321, 5278, 5552
9262, 3934, 4476, 5672, 5700
9263, 2441, 5363, 5558, 5886
9264, 4174, 3959, 4747, 5545
9265, 4533, 5239, 5146, 5964
9266, 3925, 4211, 4695, 5003
9267, 4095, 5052, 4347, 5611
9268, 2838, 4301, 2836, 4729
9269, 2137, 3828, 4433, 4962
9270, 3127, 4365, 4999, 5535
9271, 1040, 4671, 4210, 4692
9272, 4284, 4749, 613, 6062
9273, 2812, 3067, 2808, 4381
9274, 3940, 4248, 4913, 5448
9275, 3613, 4503, 4163, 5393
9276, 2993, 4154, 2298, 4736
9277, 3298, 3897, 1386, 5780
9278, 3355, 4491, 4828, 5770
9279, 4161, 4989, 4645, 5618
9280, 4150, 5185, 5612, 6187
9281, 4279, 4755, 2803, 5681
9282, 4557, 5313, 674, 5355
9283, 3918, 5262, 4145, 5691
9284, 698, 697, 652, 5371
9285, 4227, 4881, 4021, 5219
9286, 3916, 5075, 4152, 5387
9287, 2533, 5999, 4668, 6154
9288, 2194, 4223, 4653, 4863
9289, 3798, 4296, 4870, 5038
9290, 3903, 4337, 4921, 5330
9291, 2959, 4655, 4451, 5275
9292, 3900, 4532, 5602, 5643
9293, 2996, 2184, 2258, 4800
9294, 3917, 4087, 4808, 5465
9295, 4114, 5511, 5423, 5578
9296, 4372, 4994, 4765, 6188
9297, 5235, 5423, 4513, 5578
9298, 2450, 4220, 2988, 5431
9299, 1014, 4461, 5103, 6218
9300, 3507, 4684, 4199, 5077
9301, 2537, 4682, 4134, 4807
9302, 4324, 3962, 4602, 5092
9303, 3798, 4296, 3799, 4870
9304, 3016, 4228, 2625, 5189
9305, 4337, 4879, 4185, 5741
9306, 2273, 4693, 4119, 6089
9307, 4154, 2298, 4736, 5548
9308, 4682, 4807, 2981, 5115
9309, 4265, 3913, 5017, 5042
9310, 3068, 4722, 4283, 5468
9311, 4284, 4692, 3927, 4726
9312, 3922, 4414, 4143, 4685
9313, 2264, 4154, 4635, 5040
9314, 3933, 4112, 4419, 5290
9315, 2852, 2862, 4251, 5729
9316, 4287, 4694, 932, 5143
9317, 3938, 4832, 4181, 4867
9318, 3193, 4384, 2715, 5266
9319, 4076, 4921, 3928, 5123
9320, 4091, 3931, 4425, 6161
9321, 4243, 4843, 4478, 6083
9322, 3912, 5081, 4979, 5616
9323, 3443, 5141, 5213, 6061
9324, 1009, 1006, 4241, 4787
9325, 4113, 4751, 3908, 5793
9326, 741, 690, 4780, 5500
9327, 1238, 4317, 949, 4858
9328, 4401, 4693, 2945, 5659
9329, 2866, 4607, 4496, 5729
9330, 4178, 4735, 533, 6163
9331, 4126, 5489, 4373, 5574
9332, 4107, 4991, 2856, 5659
9333, 3507, 5077, 4199, 5111
9334, 4374, 4876, 4671, 5749
9335, 2194, 4653, 4223, 4932
9336, 2545, 2543, 2544, 4586
9337, 4185, 3903, 4879, 4921
9338, 1240, 4575, 4550, 5066
9339, 1226, 5165, 4706, 5779
9340, 4255, 5415, 4801, 5908
9341, 4119, 4912, 2273, 6089
9342, 3927, 5274, 4301, 5600
9343, 448, 449, 454, 4346
9344, 1009, 4241, 1006, 4855
9345, 2676, 4224, 2642, 4688
9346, 4390, 4274, 5002, 5793
9347, 3914, 4447, 5089, 5209
9348, 2788, 4756, 5262, 6066
9349, 562, 5545, 4829, 5644
9350, 724, 4350, 726, 5149
9351, 4096, 3964, 4505, 5566
9352, 3942, 4746, 4342, 5341
9353, 3935, 4941, 4280, 5441
9354, 4429, 4891, 3926, 5242
9355, 502, 4550, 4662, 5347
9356, 2713, 4397, 2703, 4934
9357, 4134, 4682, 2537, 4813
9358, 3920, 4914, 4457, 5766
9359, 725, 726, 4350, 5149
9360, 3913, 5042, 4642, 5631
9361, 4271, 4607, 2422, 5748
9362, 3123, 4448, 3280, 5021
9363, 4144, 4727, 4263, 4979
9364, 4449, 4784, 4352, 5759
9365, 4531, 4717, 4340, 5394
9366, 4024, 4124, 4944, 5875
9367, 4015, 4828, 4491, 5770
9368, 2719, 4327, 4405, 5651
9369, 685, 5276, 4585, 5492
9370, 902, 903, 4784, 5759
9371, 3947, 5278, 4638, 5552
9372, 4363, 4802, 4085, 5587
9373, 4955, 5330, 4330, 5775
9374, 4191, 4581, 2457, 5074
9375, 4032, 4260, 5139, 5159
9376, 2925, 4477, 4626, 5335
9377, 1040, 4692, 4210, 5997
9378, 4194, 3973, 4872, 5243
9379, 3927, 4692, 4284, 5065
9380, 4727, 4896, 4109, 5259
9381, 4383, 4954, 4697, 5589
9382, 2197, 2198, 2199, 4359
9383, 1269, 4461, 1015, 5232
9384, 3209, 2625, 4228, 4762
9385, 4082, 4822, 3914, 5089
9386, 4057, 4850, 4292, 5322
9387, 306, 4445, 5495, 5725
9388, 3025, 4430, 2347, 4743
9389, 2575, 4457, 5173, 5736
9390, 3576, 4809, 3519, 5001
9391, 3956, 4556, 4393, 4990
9392, 499, 4679, 4277, 5371
9393, 3946, 4676, 4245, 4705
9394, 4668, 5999, 4625, 6154
9395, 1170, 4780, 4493, 5849
9396, 4455, 4783, 4227, 5419
9397, 334, 1074, 3704, 4752
9398, 4409, 5639, 4640, 6064
9399, 740, 4740, 4175, 5673
9400, 4259, 5282, 5161, 5460
9401, 2699, 4612, 2697, 5357
9402, 1074, 3813, 3704, 4752
9403, 2988, 4220, 4852, 5431
9404, 4738, 5475, 5006, 6071
9405, 2459, 4509, 2460, 5247
9406, 1365, 4274, 4716, 5002
9407, 503, 4311, 4718, 4892
9408, 3954, 5250, 4325, 5505
9409, 4371, 4650, 3951, 5604
9410, 4128, 4650, 4371, 5604
9411, 3108, 4586, 4316, 5173
9412, 4164, 3913, 4613, 4836
9413, 3576, 4389, 3474, 4809
9414, 4281, 5888, 4334, 5922
9415, 4450, 4538, 3909, 5070
9416, 2620, 4182, 4480, 5527
9417, 4109, 5010, 5120, 5631
9418, 2325, 4574, 2280, 5660
9419, 1160, 500, 621, 4679
9420, 4784, 5759, 4449, 5989
9421, 3930, 4167, 5281, 5513
9422, 2906, 2914, 4497, 5115
9423, 2441, 5558, 2494, 5886
9424, 4393, 4734, 5329, 5977
9425, 2802, 5599, 4774, 5778
9426, 3555, 4885, 4108, 5722
9427, 3634, 4291, 3598, 4939
9428, 4243, 5329, 3975, 5977
9429, 4963, 5359, 3979, 5946
9430, 724, 4350, 5149, 5343
9431, 3918, 4232, 4711, 5403
9432, 4336, 5496, 4740, 5634
9433, 4000, 4487, 5154, 5628
9434, 2945, 4693, 2860, 5659
9435, 2919, 5252, 4517, 5427
9436, 2855, 4633, 4107, 5086
9437, 4046, 5324, 4369, 5466
9438, 4112, 4330, 5330, 5775
9439, 3961, 4690, 5612, 6122
9440, 3931, 5253, 4091, 5525
9441, 3995, 4969, 4130, 6191
9442, 4336, 4740, 4319, 5064
9443, 3940, 4125, 4565, 5499
9444, 4703, 4991, 3045, 5729
9445, 3927, 4726, 4692, 5570
9446, 5146, 5239, 4485, 5964
9447, 3955, 4123, 4745, 5649
9448, 3921, 5139, 4260, 5159
9449, 378, 5612, 379, 5894
9450, 3957, 4693, 4170, 4844
9451, 440, 448, 4155, 4764
9452, 5541, 5931, 5076, 6010
9453, 4181, 4746, 3942, 4777
9454, 692, 4793, 4240, 5824
9455, 1281, 4598, 4123, 5536
9456, 4041, 4485, 5239, 5964
9457, 5161, 5282, 4575, 5460
9458, 983, 4598, 4250, 4661
9459, 3422, 4449, 326, 5714
9460, 3964, 4096, 4505, 5306
9461, 1170, 5373, 1205, 5849
9462, 3573, 5078, 2145, 5125
9463, 4169, 4624, 4185, 4921
9464, 4164, 4613, 3913, 4896
9465, 1092, 4248, 402, 4660
9466, 2273, 5742, 4693, 6089
9467, 3998, 4498, 5164, 5543
9468, 698, 697, 4464, 5049
9469, 4828, 5097, 4997, 5835
9470, 1125, 4550, 4239, 4662
9471, 4030, 4468, 4971, 5168
9472, 3991, 4708, 4353, 5241
9473, 3875, 3798, 4116, 5727
9474, 4002, 4063, 4482, 5231
9475, 2895, 5224, 4708, 5227
9476, 2543, 4586, 2545, 4891
9477, 4334, 4768, 819, 5049
9478, 3908, 4936, 4360, 5187
9479, 4250, 4084, 5030, 5390
9480, 2489, 3122, 4989, 5230
9481, 4102, 5115, 4876, 5924
9482, 364, 4213, 4840, 4967
9483, 3699, 3826, 2729, 4435
9484, 2525, 4717, 4172, 4854
9485, 4243, 3975, 5129, 5977
9486, 4184, 3967, 4702, 5073
9487, 4144, 3910, 4493, 4783
9488, 3920, 5011, 4754, 5348
9489, 4184, 4747, 4329, 4765
9490, 2901, 4462, 3872, 5667
9491, 4044, 5161, 4119, 5515
9492, 4006, 4518, 4481, 5121
9493, 5102, 5870, 4399, 6078
9494, 4257, 4061, 5418, 6049
9495, 4312, 4854, 2661, 5021
9496, 896, 4582, 4065, 5556
9497, 3928, 4337, 4694, 4967
9498, 2601, 2929, 3063, 5028
9499, 3771, 930, 3713, 4428
9500, 622, 694, 623, 4231
9501, 2996, 4800, 4177, 4973
9502, 335, 3697, 4410, 4880
9503, 4169, 3903, 4624, 4921
9504, 3920, 4097, 4611, 5363
9505, 4325, 5250, 4197, 5505
9506, 335, 4410, 1095, 5508
9507, 4158, 4376, 3939, 5703
9508, 3961, 5214, 4690, 6122
9509, 3686, 3664, 3174, 4508
9510, 2608, 4611, 5261, 5558
9511, 4153, 3035, 4667, 5188
9512, 1144, 4575, 1240, 5066
9513, 2981, 4807, 2904, 5115
9514, 3089, 5074, 4664, 5296
9515, 3914, 4822, 4400, 5089
9516, 4078, 5264, 5078, 5402
9517, 4370, 6118, 4884, 6144
9518, 4242, 5602, 4532, 5643
9519, 3924, 4269, 4616, 4789
9520, 1090, 4620, 4385, 5325
9521, 4156, 3939, 4376, 5672
9522, 1282, 1284, 4250, 4794
9523, 2919, 2930, 5252, 5427
9524, 3127, 4576, 4365, 6077
9525, 4572, 4749, 4263, 5743
9526, 2875, 4262, 2546, 5549
9527, 4156, 4501, 3934, 4736
9528, 4498, 4543, 3998, 5164
9529, 1048, 1156, 1089, 4957
9530, 3918, 4540, 4145, 5262
9531, 4195, 5364, 4700, 5988
9532, 4493, 5962, 4229, 6037
9533, 613, 1038, 4284, 6062
9534, 4180, 4577, 4357, 5210
9535, 4098, 5067, 3951, 5269
9536, 3349, 4065, 4582, 5082
9537, 4046, 4601, 4369, 5324
9538, 4020, 4294, 4628, 5216
9539, 4346, 4592, 1169, 4978
9540, 4198, 3968, 4513, 5035
9541, 4350, 5154, 4487, 5628
9542, 3920, 4237, 5239, 5363
9543, 3017, 5795, 4114, 5817
9544, 3901, 4308, 4810, 5838
9545, 2188, 4075, 4973, 5389
9546, 1145, 4697, 4294, 4725
9547, 2639, 4256, 2641, 5945
9548, 4773, 3979, 5359, 5946
9549, 4032, 4260, 5063, 5229
9550, 3913, 4865, 4165, 5785
9551, 3985, 4478, 4843, 5624
9552, 4145, 4540, 3918, 5812
9553, 4640, 4707, 4138, 5263
9554, 455, 4346, 1169, 4978
9555, 306, 4445, 3281, 5495
9556, 4743, 5334, 2398, 5630
9557, 2384, 4258, 2386, 5436
9558, 3918, 4145, 5812, 6215
9559, 3902, 4776, 4305, 4882
9560, 4955, 5190, 4018, 5689
9561, 4113, 4274, 4751, 5793
9562, 4145, 5262, 4756, 6066
9563, 2858, 4991, 4650, 5659
9564, 3929, 4801, 4255, 5415
9565, 4434, 5132, 4106, 5322
9566, 501, 1146, 4277, 4849
9567, 4357, 5698, 4569, 6009
9568, 4507, 4997, 5097, 5835
9569, 2924, 5335, 4626, 5427
9570, 4185, 3899, 4686, 4856
9571, 2993, 2264, 4154, 4798
9572, 4303, 4818, 4396, 4949
9573, 2808, 4381, 3067, 5085
9574, 4357, 4577, 4180, 4777
9575, 3967, 4184, 4702, 4957
9576, 4112, 4330, 5290, 5330
9577, 4369, 5386, 418, 5752
9578, 3647, 4683, 5526, 5971
9579, 3842, 4775, 3882, 5572
9580, 3940, 4565, 4125, 5448
9581, 4695, 5553, 4533, 5696
9582, 4181, 4833, 3942, 5609
9583, 3437, 3387, 4906, 6127
9584, 4204, 5412, 4601, 5693
9585, 5000, 5479, 4737, 5803
9586, 2641, 2639, 2805, 4852
9587, 707, 4603, 4555, 5635
9588, 4004, 4090, 4606, 5736
9589, 4187, 5024, 4735, 5245
9590, 4430, 4561, 2347, 4743
9591, 455, 449, 1169, 4346
9592, 2235, 4223, 4863, 5901
9593, 2374, 5034, 4677, 5406
9594, 1260, 5210, 4577, 5752
9595, 4493, 5419, 4229, 5962
9596, 3901, 4810, 4262, 5838
9597, 4018, 5290, 4330, 5330
9598, 4476, 5730, 3925, 6033
9599, 4325, 4767, 3905, 6019
9600, 603, 4179, 4460, 5399
9601, 3920, 4754, 4457, 5348
9602, 3938, 4594, 4440, 5489
9603, 804, 4700, 4328, 5257
9604, 4670, 4797, 394, 5540
9605, 4514, 4682, 2981, 5115
9606, 4112, 3933, 4600, 4925
9607, 4028, 4765, 4994, 6188
9608, 4407, 4720, 2251, 4862
9609, 983, 984, 4598, 4661
9610, 4357, 4577, 1260, 5210
9611, 2601, 3063, 4588, 5028
9612, 4098, 5269, 3951, 5604
9613, 3975, 4792, 4179, 4824
9614, 4550, 4575, 1240, 5398
9615, 4336, 4825, 4043, 5384
9616, 3905, 4197, 4767, 5195
9617, 707, 5635, 4555, 6070
9618, 2856, 4991, 2858, 5659
9619, 4553, 4691, 3921, 5840
9620, 1009, 4241, 4855, 5644
9621, 3313, 326, 3422, 4449
9622, 3443, 4886, 5141, 6061
9623, 2429, 3005, 4169, 6199
9624, 1170, 1205, 986, 5849
9625, 4281, 4334, 5344, 5922
9626, 3910, 4948, 4275, 6180
9627, 4495, 4948, 3910, 5012
9628, 4219, 4090, 4914, 5766
9629, 4711, 5403, 4232, 5911
9630, 3915, 4763, 4679, 5290
9631, 3227, 5495, 3251, 6043
9632, 4380, 3942, 4833, 5609
9633, 3387, 6095, 4906, 6127
9634, 3280, 3123, 3295, 4448
9635, 3910, 4275, 4495, 6147
9636, 646, 4957, 4702, 5645
9637, 3151, 5679, 4934, 5801
9638, 4376, 4154, 4798, 5238
9639, 3326, 3414, 912, 4436
9640, 1144, 1240, 4575, 5398
9641, 4192, 4367, 3957, 4710
9642, 941, 4535, 4460, 4791
9643, 4191, 5087, 4981, 5581
9644, 683, 4485, 639, 5459
9645, 4584, 5157, 413, 5462
9646, 4050, 4506, 4314, 4674
9647, 4027, 5234, 4532, 5485
9648, 4433, 5708, 2884, 5763
9649, 3901, 4651, 5172, 5231
9650, 3943, 4988, 4709, 5436
9651, 4206, 4940, 4443, 5643
9652, 690, 4557, 4141, 5503
9653, 2753, 4597, 4512, 4786
9654, 3981, 4504, 5221, 5990
9655, 4063, 5213, 5141, 6061
9656, 623, 4231, 694, 5338
9657, 3931, 4091, 5253, 6161
9658, 643, 4740, 4447, 5677
9659, 364, 4840, 363, 4967
9660, 4474, 4776, 4629, 6131
9661, 3123, 3202, 4448, 5021
9662, 3910, 4783, 4144, 5812
9663, 2567, 4657, 4269, 5755
9664, 1009, 4787, 4241, 5644
9665, 4241, 5320, 4787, 5502
9666, 4165, 4382, 3912, 4896
9667, 3813, 4296, 3797, 4752
9668, 4147, 6005, 3934, 6093
9669, 2220, 4118, 3070, 4991
9670, 4150, 5612, 5185, 5894
9671, 4700, 5268, 3978, 5364
9672, 4145, 4721, 4455, 4783
9673, 2788, 5262, 4145, 6066
9674, 1169, 4592, 4346, 5642
9675, 995, 4967, 5741, 6016
9676, 4089, 4511, 3916, 5202
9677, 4468, 4971, 4685, 5314
9678, 4143, 4414, 3922, 4795
9679, 3798, 4870, 4116, 5038
9680, 3952, 4947, 4299, 5230
9681, 4144, 5373, 4493, 5849
9682, 2689, 4518, 4208, 5436
9683, 3981, 4168, 4824, 5783
9684, 4297, 4972, 4325, 5534
9685, 3912, 4979, 4721, 5616
9686, 4361, 4753, 3009, 5416
9687, 2471, 4538, 4160, 5318
9688, 543, 5366, 4098, 5412
9689, 2280, 2279, 4823, 4834
9690, 3912, 4721, 4165, 5616
9691, 1394, 819, 1408, 4334
9692, 3985, 4243, 4478, 5557
9693, 562, 4829, 560, 5644
9694, 2978, 2536, 4736, 5848
9695, 4251, 4991, 4703, 5729
9696, 628, 5276, 685, 5492
9697, 4376, 4736, 4154, 5238
9698, 2194, 4223, 2235, 5901
9699, 4188, 4980, 5454, 5672
9700, 3787, 3825, 4410, 5550
9701, 4049, 4625, 4327, 6234
9702, 3940, 4913, 4565, 5448
9703, 2280, 4574, 2325, 4834
9704, 1239, 6021, 5730, 6071
9705, 3850, 2901, 3872, 5667
9706, 4138, 5415, 4548, 5908
9707, 2567, 4269, 2566, 5755
9708, 1058, 1159, 1055, 5271
9709, 4382, 4721, 2889, 5785
9710, 2680, 4664, 4299, 5230
9711, 2955, 4118, 4832, 4938
9712, 3987, 5071, 4870, 5929
9713, 4592, 5642, 736, 5784
9714, 4476, 5454, 3934, 5672
9715, 1058, 1055, 4364, 5271
9716, 4000, 4313, 4312, 5154
9717, 1282, 4250, 983, 4598
9718, 2429, 4169, 3005, 4786
9719, 4481, 5121, 4518, 5893
9720, 3355, 4491, 3460, 4828
9721, 4599, 4930, 4003, 5603
9722, 3977, 4361, 4189, 4926
9723, 3872, 4462, 2901, 6039
9724, 3930, 5281, 5278, 6109
9725, 815, 1090, 4385, 5325
9726, 3920, 4754, 4237, 5975
9727, 5006, 5707, 4737, 6001
9728, 1075, 4296, 4752, 4924
9729, 4133, 5187, 5084, 5885
9730, 2978, 4736, 4501, 5848
9731, 4040, 4642, 4265, 5042
9732, 499, 600, 4679, 5371
9733, 501, 4277, 5317, 5961
9734, 4843, 5624, 4478, 6083
9735, 4003, 4671, 4876, 5749
9736, 4090, 4004, 4606, 5248
9737, 3920, 4237, 5363, 5975
9738, 1075, 4296, 1074, 4752
9739, 4497, 2914, 5514, 5815
9740, 4053, 4373, 5489, 5574
9741, 3382, 3319, 2129, 4490
9742, 4184, 4747, 4418, 5181
9743, 2961, 4401, 2945, 5659
9744, 2536, 5238, 4736, 5848
9745, 3280, 4448, 3303, 5021
9746, 4337, 5741, 4967, 6016
9747, 4319, 4740, 4336, 5496
9748, 903, 4467, 4784, 5844
9749, 4178, 5931, 5541, 6010
9750, 2729, 3826, 3088, 4435
9751, 4062, 4674, 858, 4942
9752, 454, 4719, 4346, 4978
9753, 4712, 5276, 5201, 5816
9754, 3927, 4726, 4456, 5600
9755, 5076, 5541, 4153, 5931
9756, 4651, 5153, 4308, 5172
9757, 4309, 5337, 5031, 5919
9758, 5006, 5080, 4267, 5475
9759, 4003, 4930, 4599, 5246
9760, 4135, 4925, 3978, 5301
9761, 4100, 4685, 4468, 4971
9762, 4734, 5221, 2365, 6178
9763, 3697, 3787, 3825, 4410
9764, 725, 726, 724, 4350
9765, 3534, 4090, 3540, 5261
9766, 2642, 4224, 2676, 5613
9767, 3636, 4113, 4701, 6150
9768, 3912, 4427, 4727, 6126
9769, 3274, 4344, 3282, 5294
9770, 3940, 4125, 5499, 6136
9771, 501, 4849, 4277, 5961
9772, 4154, 5040, 2298, 5548
9773, 2855, 5086, 4107, 5659
9774, 4218, 5289, 5120, 5631
9775, 4359, 4969, 3995, 5004
9776, 2925, 4477, 2172, 5175
9777, 3547, 3163, 3474, 4389
9778, 4264, 4666, 2480, 5535
9779, 4664, 5074, 4191, 5296
9780, 4119, 4912, 4823, 5161
9781, 4120, 5193, 5537, 5717
9782, 3653, 3683, 4274, 5623
9783, 646, 1044, 4702, 4957
9784, 3922, 4516, 4103, 5696
9785, 3905, 4325, 4297, 4767
9786, 4406, 3042, 4912, 5566
9787, 3850, 2103, 2901, 5667
9788, 3613, 4503, 3612, 5133
9789, 4628, 5216, 4294, 5589
9790, 1342, 669, 4507, 5478
9791, 4065, 4507, 5556, 5835
9792, 4687, 5067, 4098, 5412
9793, 642, 5092, 4602, 5533
9794, 4187, 4032, 4632, 5063
9795, 4501, 4117, 5162, 5885
9796, 3984, 4383, 4294, 6018
9797, 4316, 4586, 3108, 6233
9798, 3620, 3618, 4968, 5734
9799, 4380, 4746, 3942, 5609
9800, 4725, 5398, 975, 5460
9801, 4184, 3959, 4747, 4765
9802, 623, 5338, 1167, 5870
9803, 4457, 4004, 5173, 5736
9804, 3913, 4642, 4865, 5785
9805, 4321, 5707, 5006, 6001
9806, 4197, 574, 4745, 4958
9807, 3951, 5067, 4687, 5412
9808, 4350, 3978, 5268, 5364
9809, 4243, 5018, 5288, 5557
9810, 4024, 5257, 4328, 5608
9811, 449, 4346, 448, 5642
9812, 3951, 4098, 4687, 5067
9813, 2257, 2251, 4720, 4862
9814, 3969, 4189, 4402, 5309
9815, 3969, 4402, 4189, 5799
9816, 5201, 5276, 4585, 5816
9817, 4302, 5227, 4708, 5726
9818, 4476, 3925, 5700, 6033
9819, 4517, 4839, 2180, 6080
9820, 985, 4311, 503, 4892
9821, 3990, 5518, 4806, 5582
9822, 4003, 5246, 4599, 5603
9823, 4189, 4361, 3977, 5590
9824, 4476, 5454, 4147, 5700
9825, 4808, 5017, 3916, 5369
9826, 3979, 4431, 4212, 4773
9827, 3912, 4165, 5081, 5616
9828, 4189, 5247, 3969, 5799
9829, 4212, 4431, 3979, 5384
9830, 4057, 4517, 4850, 5322
9831, 4150, 4794, 4458, 4946
9832, 2422, 2340, 2346, 4271
9833, 3915, 4277, 4975, 5371
9834, 4149, 4554, 789, 5516
9835, 4451, 4655, 2825, 5980
9836, 4063, 4488, 4482, 5771
9837, 855, 4662, 4239, 4868
9838, 1167, 5338, 4444, 5870
9839, 3646, 3659, 4365, 6194
9840, 5044, 5713, 3418, 5949
9841, 3360, 4242, 3361, 5995
9842, 4820, 5147, 4246, 5413
9843, 3925, 5730, 5003, 6033
9844, 5423, 5511, 4198, 5578
9845, 2716, 2519, 3193, 4384
9846, 2916, 2180, 4517, 4839
9847, 4431, 4773, 389, 5584
9848, 921, 3653, 5421, 5623
9849, 4674, 4820, 3338, 4942
9850, 2197, 4359, 5004, 5901
9851, 2838, 4301, 4729, 5353
9852, 4168, 3975, 4734, 4824
9853, 3969, 5671, 4253, 5940
9854, 503, 1113, 4892, 6050
9855, 4256, 4688, 2641, 5945
9856, 4190, 5129, 4824, 5221
9857, 824, 5666, 715, 5908
9858, 2330, 4380, 4746, 5476
9859, 4181, 3942, 4746, 5609
9860, 2845, 4279, 2803, 5681
9861, 1188, 5412, 4673, 5525
9862, 4299, 4947, 4205, 5230
9863, 3009, 4753, 4361, 5432
9864, 4157, 4930, 4599, 5603
9865, 3500, 3501, 3499, 4138
9866, 3973, 5108, 4570, 5193
9867, 4090, 4219, 5291, 5766
9868, 4297, 4325, 3905, 5534
9869, 2836, 2838, 2837, 4301
9870, 4113, 3908, 4751, 6189
9871, 598, 554, 5102, 5440
9872, 3914, 4187, 4632, 4735
9873, 4188, 5276, 4343, 5633
9874, 4481, 4518, 4006, 5099
9875, 4173, 4817, 2393, 5249
9876, 1062, 4592, 736, 5784
9877, 2789, 5225, 4412, 5485
9878, 4347, 5251, 4095, 5611
9879, 3929, 4140, 5055, 5299
9880, 4147, 3934, 4610, 6093
9881, 2489, 2169, 4205, 4989
9882, 4658, 4808, 3916, 5369
9883, 2183, 2181, 2182, 4800
9884, 1397, 4771, 4209, 5556
9885, 5071, 5151, 4870, 5929
9886, 3913, 4165, 4896, 5785
9887, 4181, 4867, 4832, 5877
9888, 1101, 5401, 4953, 5981
9889, 4157, 4003, 4930, 5603
9890, 2610, 4537, 4769, 5431
9891, 3956, 4903, 4381, 6032
9892, 4817, 5032, 4430, 5630
9893, 1079, 4396, 654, 4904
9894, 3957, 4367, 4192, 5192
9895, 3901, 5172, 4308, 5838
9896, 2580, 5189, 5053, 5226
9897, 523, 4602, 4259, 5533
9898, 4264, 4527, 3973, 4666
9899, 4506, 4674, 4050, 5713
9900, 3972, 4525, 5047, 5729
9901, 3966, 4175, 4759, 5064
9902, 4021, 5962, 4493, 6037
9903, 2916, 4839, 4517, 5252
9904, 454, 4346, 455, 4978
9905, 4228, 4762, 2625, 5189
9906, 3951, 4204, 4601, 5180
9907, 4051, 5214, 5391, 6130
9908, 1146, 4849, 719, 5371
9909, 3901, 4651, 5231, 6184
9910, 2760, 4586, 4429, 4891
9911, 3910, 4144, 4493, 5812
9912, 3945, 4102, 4807, 5115
9913, 2788, 4145, 5262, 5691
9914, 4100, 4971, 4468, 5168
9915, 4265, 4591, 4040, 5042
9916, 3950, 4908, 5020, 5871
9917, 4003, 4425, 5246, 5603
9918, 4064, 4847, 4215, 5687
9919, 4397, 4002, 4934, 5176
9920, 5120, 5289, 4613, 5631
9921, 4312, 4717, 4531, 5375
9922, 2197, 2198, 4359, 5901
9923, 3705, 303, 3824, 4534
9924, 2916, 4517, 2919, 5252
9925, 4593, 3418, 5713, 5949
9926, 3540, 4090, 5291, 5577
9927, 523, 4259, 4602, 4954
9928, 3929, 4841, 4140, 5299
9929, 3944, 4273, 4720, 5622
9930, 4395, 5286, 4858, 5852
9931, 2145, 5078, 3211, 5125
9932, 4094, 5043, 4806, 5582
9933, 2537, 4134, 2255, 5867
9934, 3909, 4450, 5070, 5449
9935, 4278, 5258, 4517, 5434
9936, 4481, 5214, 3961, 5391
9937, 4139, 4793, 3936, 5315
9938, 4759, 5064, 4175, 5634
9939, 2889, 4721, 4382, 6054
9940, 3909, 5010, 4758, 5745
9941, 2188, 5351, 4075, 5389
9942, 3901, 4262, 5172, 5838
9943, 2836, 4729, 4301, 5469
9944, 2846, 2803, 4755, 5681
9945, 3328, 2104, 3378, 4648
9946, 3088, 4435, 3826, 5114
9947, 4305, 4776, 4104, 4882
9948, 4151, 3930, 4901, 5182
9949, 3981, 4504, 4824, 5221
9950, 1169, 4346, 449, 5642
9951, 2543, 4275, 4891, 5955
9952, 3938, 4594, 4181, 4832
9953, 4434, 4647, 3924, 5434
9954, 3925, 4901, 4158, 5568
9955, 3941, 4086, 4573, 5101
9956, 4521, 5261, 4611, 5558
9957, 3570, 5263, 3587, 5437
9958, 2950, 4565, 4802, 5587
9959, 4098, 4673, 543, 5412
9960, 4245, 4676, 3946, 5717
9961, 4356, 5020, 4908, 5871
9962, 4355, 4661, 980, 6104
9963, 4340, 4551, 2504, 5036
9964, 2789, 4532, 5225, 5485
9965, 4015, 4491, 4905, 5770
9966, 4678, 5003, 3925, 5730
9967, 2895, 4708, 2356, 5227
9968, 3917, 5118, 4226, 5706
9969, 4018, 4277, 4679, 5290
9970, 2940, 2310, 2595, 4265
9971, 4670, 5540, 394, 5946
9972, 2459, 4262, 2875, 4788
9973, 4429, 5168, 4909, 5348
9974, 385, 5122, 5584, 5804
9975, 3223, 3281, 4445, 5495
9976, 4327, 4625, 4378, 6154
9977, 4276, 3957, 4693, 5039
9978, 5007, 5405, 4218, 6118
9979, 2330, 5298, 4380, 5476
9980, 4057, 5335, 4850, 5427
9981, 1085, 3824, 303, 4534
9982, 1317, 4857, 858, 5528
9983, 4044, 4119, 5161, 6111
9984, 4303, 3905, 4818, 4949
9985, 3978, 4350, 5268, 5301
9986, 4706, 5165, 4131, 5779
9987, 4693, 5086, 2860, 5659
9988, 4112, 5037, 4925, 5762
9989, 3934, 5454, 4980, 5672
9990, 4049, 5414, 4625, 6234
9991, 4295, 3998, 4598, 5122
9992, 2595, 2940, 4265, 6036
9993, 5061, 5196, 4768, 5922
9994, 3917, 4970, 4226, 5465
9995, 750, 5035, 4421, 5092
9996, 950, 4287, 585, 5697
9997, 3815, 1095, 3825, 5632
9998, 5269, 5278, 3947, 5366
9999, 4273, 5093, 5000, 5479
10000, 4683, 4039, 5526, 5971
10001, 4292, 4477, 3952, 6022
10002, 4086, 3941, 4877, 5101
10003, 3964, 5161, 4119, 6111
10004, 2398, 3025, 2347, 4743
10005, 3747, 5062, 5400, 6081
10006, 3534, 4606, 4090, 5261
10007, 750, 1206, 5035, 5092
10008, 4680, 4858, 1238, 5424
10009, 4124, 3899, 4624, 4856
10010, 3900, 4657, 4242, 5602
10011, 1234, 513, 4691, 4894
10012, 3950, 4872, 4559, 5356
10013, 2755, 5294, 2558, 5443
10014, 4312, 4717, 2661, 4854
10015, 3815, 301, 1095, 5632
10016, 4406, 4918, 4096, 5306
10017, 4167, 4659, 4549, 5969
10018, 2176, 2281, 4850, 5335
10019, 4082, 4400, 4822, 5089
10020, 4671, 4953, 4374, 5749
10021, 516, 4894, 4706, 5165
10022, 2905, 2981, 2904, 5115
10023, 2235, 4863, 4619, 5901
10024, 4218, 631, 5007, 5120
10025, 3969, 4402, 5671, 5940
10026, 4362, 5095, 4064, 5164
10027, 4043, 4212, 5384, 5546
10028, 3979, 4773, 4212, 5384
10029, 4693, 5742, 4119, 6089
10030, 2639, 2988, 4852, 5431
10031, 4276, 4693, 4401, 5039
10032, 4243, 5288, 4478, 5557
10033, 402, 4660, 4248, 5993
10034, 351, 4674, 3334, 4942
10035, 3576, 3521, 4389, 5001
10036, 4097, 5558, 5363, 5886
10037, 3925, 4158, 4798, 5568
10038, 603, 4791, 4179, 5757
10039, 4458, 4794, 4150, 5894
10040, 4002, 5213, 4063, 5231
10041, 4170, 4844, 4693, 5742
10042, 4178, 5541, 4564, 6010
10043, 934, 935, 775, 4394
10044, 607, 533, 4735, 6163
10045, 4075, 4973, 4466, 5351
10046, 3615, 4163, 3613, 5133
10047, 3722, 4492, 3869, 6074
10048, 3981, 4168, 5783, 5990
10049, 2713, 3134, 2711, 4490
10050, 3936, 4541, 4240, 4793
10051, 3416, 3315, 327, 4488
10052, 4532, 5234, 4412, 5485
10053, 4277, 4679, 3915, 4975
10054, 2386, 4258, 5025, 5436
10055, 5730, 6071, 6021, 6172
10056, 4412, 5225, 4532, 5485
10057, 4063, 5141, 4886, 6061
10058, 1101, 1104, 4953, 5401
10059, 983, 4661, 4250, 6104
10060, 642, 4602, 4324, 5547
10061, 2700, 5357, 4612, 6237
10062, 3380, 5368, 4648, 6061
10063, 3186, 4637, 2440, 4646
10064, 3925, 4695, 4103, 5346
10065, 593, 595, 4379, 4629
10066, 3956, 4381, 5320, 6032
10067, 3925, 4798, 4695, 5346
10068, 4050, 4820, 4674, 5420
10069, 4021, 5419, 4493, 5962
10070, 4081, 3957, 4710, 5039
10071, 1184, 679, 4194, 4920
10072, 3921, 4260, 4632, 5159
10073, 4227, 4382, 3912, 6054
10074, 3510, 4521, 5111, 5486
10075, 4231, 3929, 4444, 4801
10076, 484, 486, 4749, 5743
10077, 1186, 5547, 4811, 5860
10078, 4640, 4707, 3524, 5639
10079, 3636, 4113, 3674, 6108
10080, 4151, 3930, 5182, 5439
10081, 2325, 5482, 4574, 5660
10082, 3211, 5078, 4193, 5125
10083, 3188, 3295, 3123, 4448
10084, 4347, 4519, 4095, 5251
10085, 4135, 4925, 3933, 5037
10086, 4695, 4798, 4154, 5346
10087, 4334, 5061, 4768, 5922
10088, 2711, 4490, 3134, 5984
10089, 789, 4554, 4149, 4889
10090, 4664, 4882, 4191, 5074
10091, 4447, 4740, 643, 5673
10092, 3899, 4236, 5890, 5998
10093, 4124, 3899, 4856, 5725
10094, 388, 389, 4773, 5584
10095, 4065, 4582, 5082, 5385
10096, 4434, 4866, 3982, 5132
10097, 4474, 4761, 3902, 5027
10098, 3923, 5146, 4533, 5239
10099, 3005, 5060, 4169, 6199
10100, 775, 4394, 935, 5392
10101, 4006, 4481, 5099, 6090
10102, 4264, 5020, 4194, 5243
10103, 2314, 4272, 4643, 5774
10104, 3914, 5541, 4082, 6208
10105, 2700, 2697, 4612, 5357
10106, 2480, 4666, 4264, 5356
10107, 4282, 5203, 4434, 6160
10108, 4030, 4971, 4468, 5314
10109, 3964, 4119, 5192, 6111
10110, 603, 941, 4460, 4791
10111, 1038, 4726, 4692, 5892
10112, 497, 4836, 490, 5259
10113, 3912, 4721, 4145, 4783
10114, 2489, 3087, 3122, 5230
10115, 4721, 5616, 2889, 5785
10116, 4240, 4485, 639, 5146
10117, 3925, 4154, 4695, 4798
10118, 4247, 3620, 5670, 6091
10119, 4063, 4651, 4482, 5231
10120, 4353, 5411, 5241, 5982
10121, 975, 4697, 1145, 4725
10122, 4085, 4802, 4565, 5587
10123, 418, 4665, 4369, 5752
10124, 4365, 3659, 5104, 6194
10125, 363, 4967, 4840, 5935
10126, 5094, 5557, 4494, 5897
10127, 3361, 4242, 3360, 4827
10128, 3888, 3731, 5046, 5284
10129, 4255, 5204, 5666, 5908
10130, 3928, 4921, 4337, 5123
10131, 3463, 935, 3312, 5392
10132, 4283, 4579, 3904, 4722
10133, 4606, 5173, 4004, 5736
10134, 3387, 3440, 6095, 6127
10135, 4045, 5455, 4114, 5511
10136, 4311, 4780, 985, 5849
10137, 4518, 5099, 4481, 6090
10138, 3964, 4918, 4406, 5306
10139, 5153, 5172, 4651, 5565
10140, 3986, 5611, 5052, 5938
10141, 323, 1395, 3682, 4939
10142, 3918, 4979, 4145, 6215
10143, 2314, 4453, 3028, 4643
10144, 351, 858, 4674, 4942
10145, 4022, 4474, 4286, 5676
10146, 4219, 5248, 4636, 5907
10147, 580, 579, 4261, 4904
10148, 1160, 4523, 4162, 5292
10149, 4438, 5403, 4711, 5911
10150, 4214, 4694, 3928, 5328
10151, 2813, 2447, 4888, 5142
10152, 3912, 4382, 4227, 5200
10153, 4456, 5600, 4726, 5779
10154, 374, 5342, 4690, 5523
10155, 2925, 2174, 4477, 5335
10156, 2773, 4731, 2774, 5418
10157, 4056, 4504, 4996, 5668
10158, 4352, 4784, 4467, 5844
10159, 4032, 4632, 4260, 5159
10160, 5077, 5263, 3570, 5437
10161, 4749, 5769, 4284, 5997
10162, 4358, 4888, 2447, 5142
10163, 415, 417, 4425, 5525
10164, 2480, 2481, 4264, 5535
10165, 4260, 4632, 4032, 5063
10166, 5250, 5480, 4197, 5505
10167, 4295, 5122, 4598, 5804
10168, 4056, 4864, 4804, 4996
10169, 3940, 5499, 4359, 6136
10170, 4270, 5017, 3913, 5042
10171, 3992, 5241, 5411, 5982
10172, 4168, 5221, 4734, 6178
10173, 3973, 5243, 4920, 5682
10174, 2431, 4677, 4203, 5811
10175, 4199, 4684, 3507, 5486
10176, 4179, 4792, 4168, 4824
10177, 4339, 4977, 3941, 5333
10178, 4098, 5278, 5269, 5366
10179, 3914, 4822, 4082, 5541
10180, 2755, 4344, 5294, 5443
10181, 4065, 4582, 896, 5562
10182, 4373, 4805, 4111, 4961
10183, 4157, 4456, 5274, 5570
10184, 1339, 5233, 4254, 5591
10185, 4346, 4719, 454, 5530
10186, 4393, 4990, 4556, 5853
10187, 695, 5007, 631, 5120
10188, 2703, 4397, 2713, 5176
10189, 646, 1045, 1044, 4957
10190, 3016, 5189, 2969, 5226
10191, 2608, 5261, 3138, 5558
10192, 2340, 4271, 2422, 5748
10193, 4395, 5557, 5094, 5897
10194, 3974, 4132, 5344, 5464
10195, 771, 674, 4557, 5313
10196, 995, 5741, 526, 6016
10197, 2323, 2952, 4298, 5886
10198, 4376, 4736, 3934, 5700
10199, 4032, 5229, 5063, 5376
10200, 3965, 5160, 4307, 5511
10201, 546, 4238, 1049, 4816
10202, 4525, 5663, 5047, 5729
10203, 2191, 4653, 4498, 5389
10204, 4123, 3955, 4745, 5095
10205, 2782, 2781, 2689, 4208
10206, 4264, 4872, 4194, 5020
10207, 426, 4757, 1148, 5265
10208, 3986, 4706, 4333, 4894
10209, 3620, 4562, 3658, 6091
10210, 2961, 2945, 2860, 5659
10211, 4040, 4591, 4265, 6036
10212, 4553, 5202, 5139, 5555
10213, 2382, 4536, 4733, 5579
10214, 3642, 4274, 5178, 5971
10215, 3932, 4126, 4860, 5701
10216, 2484, 4237, 2593, 4754
10217, 4197, 5195, 3905, 6085
10218, 3904, 5420, 4579, 5889
10219, 1353, 4529, 5007, 5653
10220, 4133, 5201, 3946, 5276
10221, 3946, 5201, 4712, 5276
10222, 4916, 5793, 5002, 6079
10223, 4171, 5254, 5098, 6136
10224, 4259, 5460, 5161, 5610
10225, 3933, 5037, 4112, 5290
10226, 702, 4328, 804, 4700
10227, 3647, 5526, 4929, 5971
10228, 4568, 5409, 5208, 5772
10229, 3943, 5529, 4629, 5581
10230, 3925, 4103, 4567, 5346
10231, 4250, 5417, 4621, 6104
10232, 2713, 2703, 2706, 4934
10233, 3932, 4805, 4126, 5701
10234, 3043, 2365, 4734, 5221
10235, 2274, 2273, 4912, 6089
10236, 906, 4488, 3315, 5141
10237, 2884, 5708, 4646, 5763
10238, 4094, 5518, 4537, 5582
10239, 2952, 2323, 4298, 5040
10240, 989, 1394, 4334, 4768
10241, 4063, 5172, 4651, 5231
10242, 3932, 4126, 4805, 5574
10243, 3875, 3801, 3798, 5727
10244, 3956, 4787, 4241, 5320
10245, 4513, 5423, 4198, 5578
10246, 4801, 5415, 4138, 5908
10247, 2700, 4201, 5357, 6237
10248, 3917, 4808, 4970, 5465
10249, 4379, 5354, 593, 5829
10250, 3328, 2104, 4648, 5368
10251, 4538, 5070, 4450, 5449
10252, 4260, 4354, 3911, 5850
10253, 4228, 5189, 3016, 5226
10254, 4544, 4042, 5265, 5333
10255, 4513, 5564, 4254, 5591
10256, 3913, 4896, 4642, 5785
10257, 2346, 4607, 4561, 5270
10258, 4123, 4899, 4745, 5649
10259, 3941, 4977, 4571, 5333
10260, 4674, 4857, 881, 6086
10261, 3969, 4555, 4127, 4741
10262, 2323, 4298, 5040, 5886
10263, 2627, 4532, 4242, 5602
10264, 2575, 5173, 3131, 5736
10265, 4064, 4774, 4755, 5599
10266, 3928, 4694, 4214, 4967
10267, 3995, 4244, 4969, 6191
10268, 1029, 4571, 1288, 5519
10269, 364, 4213, 365, 4840
10270, 4400, 5209, 4821, 5245
10271, 3986, 5052, 5774, 5938
10272, 1288, 5519, 4571, 5573
10273, 3942, 4860, 4380, 6099
10274, 4401, 4693, 3957, 5039
10275, 4536, 5378, 4258, 5579
10276, 4199, 3582, 5111, 5486
10277, 4066, 4430, 4743, 5578
10278, 5177, 3911, 5652, 5925
10279, 519, 5840, 4698, 5850
10280, 4103, 4695, 4211, 5696
10281, 1337, 4422, 4345, 5153
10282, 3917, 4226, 4970, 5706
10283, 3005, 4786, 4169, 5060
10284, 497, 491, 490, 4836
10285, 3944, 5504, 5126, 5761
10286, 4380, 4860, 4833, 6099
10287, 4451, 2825, 5626, 5980
10288, 4180, 4577, 5210, 5752
10289, 3915, 4132, 4465, 4935
10290, 4343, 5276, 4712, 5633
10291, 3972, 5047, 4496, 5729
10292, 2708, 3382, 2129, 4490
10293, 4066, 4743, 5423, 5578
10294, 3952, 4205, 4947, 5230
10295, 3747, 5400, 5665, 6081
10296, 622, 1192, 738, 4360
10297, 738, 818, 4595, 4716
10298, 4185, 4856, 627, 5741
10299, 901, 903, 4352, 5844
10300, 4080, 5140, 4711, 5403
10301, 1167, 4444, 668, 5870
10302, 3682, 3598, 323, 4939
10303, 2384, 2385, 2386, 4258
10304, 3942, 4380, 4833, 6099
10305, 3973, 4527, 4264, 5243
10306, 4003, 4953, 4671, 5749
10307, 1145, 4294, 4697, 5589
10308, 3433, 4206, 3364, 4940
10309, 954, 4793, 4541, 5204
10310, 4248, 1148, 4757, 5265
10311, 4619, 4863, 4223, 5901
10312, 4114, 4743, 3965, 5578
10313, 1288, 4571, 1029, 5573
10314, 826, 5653, 5007, 6213
10315, 2480, 4666, 2562, 5535
10316, 437, 5359, 1279, 5794
10317, 4032, 5063, 4187, 5376
10318, 4206, 4940, 3900, 5438
10319, 3168, 2692, 4657, 5995
10320, 4453, 5128, 5075, 5933
10321, 3729, 3888, 5046, 5321
10322, 4544, 5265, 1041, 5333
10323, 4474, 5657, 4286, 5676
10324, 1073, 4308, 4651, 5153
10325, 654, 1079, 1080, 4396
10326, 3969, 5247, 4723, 5799
10327, 1126, 1125, 855, 4662
10328, 3380, 4648, 4886, 6061
10329, 4069, 5171, 5062, 5400
10330, 4240, 4793, 4541, 5824
10331, 3915, 4845, 4277, 5371
10332, 3404, 5054, 4911, 5714
10333, 3913, 5017, 4152, 6113
10334, 4160, 4538, 2471, 5134
10335, 4129, 5428, 2375, 6141
10336, 4395, 4428, 3985, 4858
10337, 4143, 4685, 4414, 5903
10338, 4020, 4968, 4562, 5133
10339, 3017, 2342, 5795, 5817
10340, 3961, 4850, 4517, 5322
10341, 4162, 3902, 4761, 5027
10342, 2759, 4586, 3108, 5173
10343, 4764, 5008, 4441, 5642
10344, 2304, 2928, 4908, 5822
10345, 3912, 4783, 4144, 5373
10346, 4027, 5234, 5485, 5802
10347, 3813, 4296, 1074, 5711
10348, 4231, 3929, 4801, 5870
10349, 783, 4513, 4310, 5058
10350, 3926, 4554, 4909, 5168
10351, 4241, 4787, 1006, 5502
10352, 4199, 5315, 4139, 5596
10353, 5177, 5652, 5465, 5925
10354, 3946, 4676, 4273, 5126
10355, 725, 5149, 4350, 5364
10356, 516, 4706, 1226, 5165
10357, 4170, 4693, 3957, 5086
10358, 1145, 4697, 847, 5589
10359, 4024, 4944, 5257, 5608
10360, 2480, 4264, 2481, 5356
10361, 4154, 3934, 4736, 5700
10362, 4829, 5545, 4174, 5644
10363, 4208, 4518, 2689, 5099
10364, 3748, 5062, 5171, 5400
10365, 2981, 4682, 2904, 4807
10366, 4385, 4620, 1090, 5424
10367, 4482, 5231, 4651, 6184
10368, 2199, 4545, 4359, 5499
10369, 3401, 4437, 3402, 4604
10370, 3965, 4198, 5160, 5511
10371, 4673, 4204, 5253, 5525
10372, 337, 3693, 4915, 5286
10373, 3940, 4757, 4248, 5448
10374, 4383, 4697, 4294, 5589
10375, 2264, 2298, 4154, 5040
10376, 3540, 5261, 4090, 5577
10377, 3940, 5448, 4125, 6136
10378, 4040, 4265, 4642, 6036
10379, 3433, 3364, 4206, 5797
10380, 4477, 5230, 3952, 6022
10381, 4902, 5915, 4281, 6232
10382, 351, 3456, 3334, 4674
10383, 4006, 4355, 5030, 5350
10384, 4220, 4079, 5273, 6102
10385, 3932, 4860, 4126, 5574
10386, 4254, 4859, 1339, 5564
10387, 3943, 4379, 4629, 5829
10388, 4033, 4793, 4139, 5315
10389, 2519, 4384, 2716, 4875
10390, 3343, 4593, 4506, 5510
10391, 4219, 4004, 5248, 5907
10392, 906, 327, 3315, 4488
10393, 2429, 4169, 4786, 5560
10394, 4374, 4671, 4876, 5401
10395, 3951, 4938, 4371, 5067
10396, 3946, 4273, 4676, 6044
10397, 3986, 4347, 5611, 6006
10398, 4219, 4914, 4090, 5248
10399, 2562, 4666, 4527, 5535
10400, 619, 5165, 1226, 5779
10401, 2544, 4586, 4275, 5056
10402, 2525, 4172, 4717, 5394
10403, 3950, 4908, 4559, 4918
10404, 4150, 3980, 4794, 4946
10405, 2108, 4344, 3274, 5294
10406, 637, 4758, 4398, 5606
10407, 3952, 4622, 4452, 5305
10408, 4184, 5073, 4702, 5645
10409, 503, 4718, 4311, 5849
10410, 2950, 4565, 2202, 4802
10411, 3747, 4479, 5062, 6081
10412, 4273, 5479, 5000, 5803
10413, 1284, 4621, 4250, 5894
10414, 4711, 5300, 2285, 5691
10415, 719, 4849, 4464, 5371
10416, 4233, 5391, 5214, 6130
10417, 3911, 4354, 4260, 5229
10418, 696, 4218, 631, 5007
10419, 4507, 4065, 4997, 5835
10420, 4599, 5246, 4425, 5603
10421, 3576, 3519, 3521, 5001
10422, 4559, 4918, 4406, 5170
10423, 3985, 5018, 4243, 5557
10424, 4234, 5109, 5095, 5649
10425, 2432, 2504, 4551, 5036
10426, 3401, 4437, 4604, 5776
10427, 4877, 5303, 4363, 5767
10428, 4081, 4592, 4441, 5008
10429, 385, 5122, 1280, 5584
10430, 4372, 4765, 4329, 6188
10431, 4466, 5351, 3998, 6034
10432, 4095, 4519, 4347, 5052
10433, 3686, 3628, 3664, 4508
10434, 4304, 5087, 4191, 5581
10435, 3573, 2145, 3493, 5125
10436, 3992, 4113, 4595, 4701
10437, 4518, 5121, 4051, 5893
10438, 4641, 4875, 4386, 5266
10439, 2273, 2275, 5742, 6089
10440, 4620, 4898, 4035, 4990
10441, 3965, 4307, 4945, 5511
10442, 1042, 718, 413, 5462
10443, 971, 4768, 989, 5196
10444, 4513, 5035, 3968, 5564
10445, 1014, 4461, 1013, 5144
10446, 2838, 2837, 4301, 5353
10447, 2660, 2683, 3119, 4579
10448, 3902, 4161, 4998, 5627
10449, 4037, 4548, 4255, 5596
10450, 2983, 4640, 3524, 5639
10451, 4073, 4898, 4620, 4990
10452, 4191, 4882, 4664, 5296
10453, 2137, 2893, 3192, 4433
10454, 2782, 4208, 2689, 5099
10455, 694, 4231, 4595, 5338
10456, 3956, 5320, 4903, 6032
10457, 679, 4194, 4570, 5083
10458, 1242, 5083, 541, 5446
10459, 3918, 5812, 4540, 6215
10460, 3931, 4673, 4204, 5253
10461, 695, 4442, 5007, 5120
10462, 4211, 4695, 5003, 5554
10463, 5351, 5543, 3998, 6034
10464, 2286, 2285, 5300, 5691
10465, 4160, 4021, 4881, 5219
10466, 782, 1339, 5564, 5591
10467, 4236, 5208, 5410, 5890
10468, 3729, 5046, 4448, 5321
10469, 585, 4287, 5143, 5697
10470, 3562, 3494, 3580, 4508
10471, 3931, 4673, 5253, 5525
10472, 4133, 4585, 5201, 5276
10473, 4250, 5030, 4661, 5390
10474, 3402, 4437, 3401, 5776
10475, 3959, 4174, 4747, 5050
10476, 4238, 1049, 4816, 5425
10477, 4281, 5344, 3974, 5922
10478, 4417, 4579, 2684, 4722
10479, 3992, 4291, 4939, 5338
10480, 3966, 4825, 4759, 6191
10481, 4223, 3995, 4969, 5004
10482, 5003, 5700, 3925, 6033
10483, 3982, 4225, 4917, 5175
10484, 4400, 4822, 2416, 5509
10485, 4248, 4757, 1148, 5993
10486, 4293, 3956, 4874, 5320
10487, 1227, 5366, 543, 5412
10488, 3985, 4494, 5094, 5557
10489, 2184, 4800, 2996, 4973
10490, 2175, 4292, 2176, 4850
10491, 3931, 4411, 4216, 5374
10492, 490, 5259, 4836, 6062
10493, 3913, 4152, 4865, 6113
10494, 4304, 2395, 5025, 5436
10495, 2528, 2661, 4854, 5021
10496, 2525, 4854, 4172, 5879
10497, 4378, 4625, 4049, 5414
10498, 3642, 5178, 3643, 5971
10499, 4381, 4874, 3956, 5320
10500, 3928, 4786, 4597, 5060
10501, 899, 3412, 3413, 5131
10502, 4305, 3952, 4882, 6008
10503, 3674, 4113, 3636, 6150
10504, 4261, 580, 4904, 5380
10505, 1368, 4195, 804, 5257
10506, 4856, 5257, 4124, 5725
10507, 3972, 4180, 4577, 4777
10508, 4596, 5538, 3965, 5738
10509, 4533, 5553, 4041, 5696
10510, 922, 1365, 4274, 4716
10511, 4189, 4974, 4054, 6075
10512, 4347, 5052, 3986, 5611
10513, 4336, 4759, 3966, 4825
10514, 2747, 3217, 2746, 5764
10515, 4726, 5600, 4131, 5779
10516, 2962, 3050, 3126, 5627
10517, 4967, 5891, 4840, 5935
10518, 535, 4735, 533, 5507
10519, 4825, 5872, 4759, 6191
10520, 4202, 4972, 3954, 5823
10521, 4073, 4990, 4620, 5842
10522, 4148, 5041, 4492, 5235
10523, 3912, 4783, 4145, 4979
10524, 4620, 4990, 4035, 5842
10525, 497, 4613, 4836, 5259
10526, 3950, 4264, 5356, 5871
10527, 3741, 4391, 3888, 5321
10528, 2649, 4732, 4335, 5661
10529, 4337, 5123, 4921, 5689
10530, 3057, 4448, 2148, 5321
10531, 4517, 4850, 2281, 5427
10532, 4322, 5118, 4699, 5576
10533, 1284, 4794, 381, 5894
10534, 2613, 4387, 2615, 4817
10535, 4406, 2304, 5566, 5822
10536, 3911, 5177, 5139, 5925
10537, 3964, 4406, 4912, 5566
10538, 4458, 4150, 5072, 5894
10539, 3744, 4846, 3745, 5062
10540, 2436, 4450, 2926, 4538
10541, 4280, 5441, 4941, 5991
10542, 3985, 4428, 4395, 5094
10543, 384, 4714, 4295, 5584
10544, 4263, 4979, 4727, 5081
10545, 2595, 4265, 4591, 6036
10546, 950, 4568, 4287, 5697
10547, 4250, 4598, 1282, 5804
10548, 605, 4602, 1186, 4954
10549, 3917, 5465, 5118, 5652
10550, 5098, 5254, 4171, 6188
10551, 3965, 4198, 5511, 5578
10552, 2181, 4207, 4560, 6090
10553, 541, 5083, 4306, 5446
10554, 5208, 5772, 5409, 5890
10555, 4058, 4901, 5152, 5182
10556, 4759, 4825, 4336, 5872
10557, 3914, 4082, 5089, 6208
10558, 4181, 4777, 4525, 5341
10559, 2471, 3144, 2472, 4160
10560, 4255, 4541, 3936, 5204
10561, 3859, 4962, 4887, 5550
10562, 803, 5131, 1355, 5650
10563, 825, 1366, 1401, 4443
10564, 4213, 4520, 3906, 5575
10565, 3068, 2483, 2158, 4283
10566, 4401, 5039, 3957, 5728
10567, 562, 1011, 645, 4174
10568, 3986, 5774, 5069, 5938
10569, 3940, 4913, 4248, 5303
10570, 3741, 2134, 4391, 5321
10571, 4253, 3969, 4723, 5671
10572, 4079, 4811, 5547, 5860
10573, 1073, 4308, 657, 4651
10574, 2992, 4677, 2431, 5811
10575, 4348, 5094, 4428, 5352
10576, 980, 650, 981, 4739
10577, 4190, 3975, 4824, 5129
10578, 3387, 3437, 3440, 6127
10579, 4894, 5165, 513, 5917
10580, 5139, 5177, 4089, 5925
10581, 4441, 4764, 3947, 5008
10582, 3921, 4632, 4260, 5124
10583, 3956, 5319, 4459, 5502
10584, 3460, 3355, 3358, 4491
10585, 2771, 5155, 4257, 6087
10586, 4559, 4872, 4072, 5356
10587, 1259, 4535, 4202, 5723
10588, 2254, 5382, 5346, 5517
10589, 4150, 4794, 3980, 4878
10590, 3926, 4909, 4429, 5168
10591, 4876, 5749, 4102, 5924
10592, 4438, 4232, 5403, 5911
10593, 2142, 4521, 3539, 5486
10594, 4214, 5143, 4694, 5328
10595, 623, 4231, 5338, 5870
10596, 3902, 4882, 4305, 5005
10597, 2639, 4852, 4256, 5431
10598, 2457, 4988, 2397, 5087
10599, 4211, 3922, 4851, 5828
10600, 4329, 4747, 4184, 4957
10601, 5319, 5320, 4070, 5502
10602, 2766, 2398, 5334, 5630
10603, 2489, 3001, 2169, 4989
10604, 985, 503, 1222, 4892
10605, 637, 4398, 4758, 5156
10606, 3950, 4264, 4872, 5356
10607, 1288, 4894, 1234, 5519
10608, 2393, 4430, 4817, 5740
10609, 3899, 4185, 4686, 4895
10610, 4870, 5071, 4439, 5151
10611, 2738, 4417, 2684, 4722
10612, 3355, 3358, 4491, 4905
10613, 3360, 4827, 4242, 5995
10614, 4229, 3997, 4557, 5313
10615, 4828, 4997, 4065, 5835
10616, 3954, 5250, 5505, 5830
10617, 2181, 6080, 4207, 6090
10618, 1036, 4692, 1038, 4726
10619, 4152, 5387, 5075, 5933
10620, 3972, 4577, 4180, 5752
10621, 2550, 3009, 4753, 5416
10622, 3371, 3316, 3369, 4384
10623, 3946, 4712, 4343, 5093
10624, 2832, 4573, 3094, 4983
10625, 2536, 2794, 4736, 5238
10626, 3969, 4741, 4127, 4964
10627, 3938, 4440, 5253, 5489
10628, 2264, 4635, 4154, 5346
10629, 395, 394, 4670, 4797
10630, 2416, 4822, 2979, 5509
10631, 3935, 4165, 4941, 5441
10632, 3945, 4876, 4374, 5749
10633, 4033, 4139, 5111, 5315
10634, 522, 496, 4610, 5967
10635, 4743, 5334, 4066, 5423
10636, 2993, 3032, 4798, 5238
10637, 4644, 5009, 4470, 5515
10638, 2258, 2996, 4177, 5942
10639, 729, 519, 4698, 5850
10640, 378, 377, 379, 5612
10641, 3951, 4687, 4601, 5412
10642, 4193, 5078, 3515, 5125
10643, 2264, 4635, 2297, 5040
10644, 829, 4385, 1090, 5424
10645, 4305, 5305, 3952, 6008
10646, 3636, 4701, 4113, 6108
10647, 3555, 3556, 4885, 5722
10648, 1062, 1169, 736, 4592
10649, 4638, 5008, 3947, 5957
10650, 4221, 5405, 5007, 6118
10651, 3951, 5067, 4371, 5269
10652, 3918, 4145, 4979, 5691
10653, 4208, 5350, 5030, 5918
10654, 3364, 4206, 5797, 5814
10655, 3748, 5400, 5171, 5746
10656, 4162, 3902, 5027, 5791
10657, 4092, 4713, 4411, 5281
10658, 4601, 5180, 4204, 5693
10659, 1184, 678, 679, 4920
10660, 4279, 4755, 4064, 4774
10661, 642, 649, 4324, 5092
10662, 4690, 5214, 4106, 6122
10663, 796, 803, 1355, 5650
10664, 2925, 2174, 2172, 4477
10665, 4060, 5398, 4725, 5460
10666, 5184, 5552, 4321, 6001
10667, 4292, 4850, 3961, 5322
10668, 4114, 5423, 4743, 5578
10669, 3908, 4585, 4360, 6193
10670, 3904, 4568, 5208, 5614
10671, 1105, 4724, 4572, 5997
10672, 4288, 1060, 4665, 5617
10673, 2384, 5378, 4258, 5436
10674, 3349, 5082, 4582, 5385
10675, 2610, 4537, 5431, 5684
10676, 2346, 4561, 4271, 5817
10677, 4211, 5744, 3922, 5828
10678, 2649, 4335, 4732, 5026
10679, 4196, 3986, 4894, 5179
10680, 4246, 5044, 4820, 5413
10681, 1368, 1309, 804, 4195
10682, 4493, 5355, 4229, 5419
10683, 2408, 4852, 2407, 6057
10684, 4009, 4884, 6118, 6144
10685, 522, 4610, 4524, 5967
10686, 713, 5782, 4889, 6068
10687, 3933, 4483, 4814, 4845
10688, 3983, 4972, 4297, 5534
10689, 2988, 2407, 4852, 6057
10690, 4797, 5540, 4244, 6191
10691, 2941, 2644, 2805, 4852
10692, 724, 5149, 4487, 5343
10693, 4676, 5126, 3946, 5717
10694, 2959, 2825, 4451, 4655
10695, 335, 4410, 1390, 4880
10696, 2678, 4312, 2663, 5375
10697, 2205, 5476, 4342, 5648
10698, 3902, 4104, 4776, 4882
10699, 2668, 4190, 2751, 4843
10700, 4197, 3905, 4767, 6019
10701, 4091, 5157, 4584, 5462
10702, 4412, 5485, 5234, 5802
10703, 4589, 5795, 2342, 5817
10704, 4130, 5540, 4797, 6191
10705, 1095, 301, 5508, 5632
10706, 3192, 4433, 2884, 5763
10707, 3969, 5309, 4127, 5522
10708, 4856, 4879, 627, 5741
10709, 2641, 4852, 2805, 5986
10710, 4306, 5504, 5761, 6219
10711, 1080, 5228, 4396, 5821
10712, 4095, 5076, 5435, 5445
10713, 4089, 5177, 5465, 5925
10714, 4305, 4882, 5305, 6008
10715, 3955, 4279, 5406, 5830
10716, 3722, 3869, 5057, 6074
10717, 1366, 4443, 825, 4689
10718, 4201, 5357, 3352, 5524
10719, 1252, 4712, 4343, 5504
10720, 4117, 4353, 5191, 5527
10721, 2760, 2759, 4429, 4586
10722, 4179, 3959, 4747, 5757
10723, 4281, 3974, 4424, 5922
10724, 3349, 4582, 4065, 5562
10725, 3936, 4541, 4255, 5299
10726, 3377, 4422, 4641, 5654
10727, 2783, 2970, 2452, 4631
10728, 3906, 4520, 4213, 4937
10729, 3414, 304, 4436, 5797
10730, 3961, 4517, 4850, 6187
10731, 4542, 5291, 4219, 5766
10732, 2803, 4279, 2845, 5406
10733, 4406, 4908, 4096, 4918
10734, 4118, 2220, 4832, 5877
10735, 2755, 5443, 2558, 6199
10736, 4643, 5469, 3028, 5626
10737, 4407, 3947, 5008, 5957
10738, 4393, 4556, 3956, 4874
10739, 2525, 2527, 4717, 4854
10740, 4123, 3998, 5095, 5122
10741, 4353, 4708, 3991, 5191
10742, 2572, 2457, 4581, 5074
10743, 3994, 4946, 4207, 5029
10744, 3636, 4701, 4939, 6150
10745, 4553, 4698, 519, 5840
10746, 3953, 4159, 4587, 4778
10747, 4044, 4644, 4470, 5515
10748, 4220, 5739, 4079, 6102
10749, 642, 4324, 649, 5547
10750, 4392, 3999, 4893, 5207
10751, 1105, 4210, 1040, 5401
10752, 4941, 5441, 4165, 5991
10753, 2952, 5040, 4298, 5227
10754, 3899, 4124, 4624, 5875
10755, 4219, 4914, 4542, 5766
10756, 3192, 4962, 4433, 5763
10757, 5257, 5495, 1211, 6043
10758, 2528, 5021, 4854, 5321
10759, 2595, 4591, 4265, 4970
10760, 4074, 4895, 4652, 5890
10761, 2803, 4774, 4279, 5406
10762, 3951, 4938, 5067, 5180
10763, 3349, 4065, 5082, 5562
10764, 4212, 4773, 388, 5496
10765, 5098, 6115, 5254, 6188
10766, 4581, 4981, 4191, 5087
10767, 2436, 2926, 2438, 4538
10768, 3934, 4501, 4156, 5162
10769, 4170, 4965, 3958, 5456
10770, 4673, 5412, 4204, 5525
10771, 3131, 5173, 4606, 5736
10772, 4312, 4313, 4000, 5934
10773, 3370, 3361, 3360, 4827
10774, 4460, 5360, 1246, 5399
10775, 2385, 2386, 4258, 5025
10776, 4347, 5611, 4068, 5690
10777, 4208, 4631, 2782, 5378
10778, 4324, 4806, 649, 5547
10779, 3284, 5326, 3301, 5413
10780, 2408, 4574, 4852, 6057
10781, 1105, 4210, 4724, 5997
10782, 3313, 916, 326, 4449
10783, 3941, 5435, 5076, 5445
10784, 3805, 3855, 3864, 6221
10785, 4720, 5622, 4273, 5803
10786, 643, 615, 4740, 5677
10787, 4046, 4587, 4364, 5861
10788, 4564, 5541, 4178, 5931
10789, 426, 4544, 4757, 5265
10790, 3747, 5665, 4479, 6081
10791, 4387, 5470, 4817, 5630
10792, 4127, 3969, 4964, 5309
10793, 2483, 2158, 4283, 5023
10794, 4404, 3924, 4789, 5916
10795, 2691, 4510, 3366, 5016
10796, 4154, 4736, 4376, 5700
10797, 4043, 4463, 4863, 5064
10798, 3956, 4459, 4787, 5502
10799, 4592, 5008, 4346, 5642
10800, 945, 1397, 4209, 5567
10801, 789, 713, 4889, 6068
10802, 4286, 4474, 4146, 5657
10803, 4176, 5017, 3913, 6096
10804, 3934, 4501, 4302, 4736
10805, 3923, 5239, 4838, 6063
10806, 4220, 4852, 4256, 6102
10807, 2450, 4769, 4220, 5431
10808, 4107, 5086, 4401, 5659
10809, 3798, 3797, 3799, 4296
10810, 3910, 4455, 4145, 4756
10811, 3364, 4940, 4206, 5814
10812, 3915, 4975, 4845, 5371
10813, 484, 4263, 4572, 5217
10814, 4140, 4841, 4708, 5726
10815, 503, 4311, 985, 5849
10816, 3492, 344, 1301, 4539
10817, 3017, 4114, 4743, 5817
10818, 4512, 4597, 3928, 4786
10819, 2771, 2773, 2774, 5418
10820, 2254, 2263, 5346, 5382
10821, 3952, 4477, 4292, 5205
10822, 3527, 4885, 4316, 5112
10823, 3960, 5484, 4224, 5902
10824, 3963, 4449, 4352, 4911
10825, 4972, 5505, 4325, 5534
10826, 1270, 4461, 1269, 5232
10827, 4113, 4939, 4701, 6150
10828, 3741, 3057, 2134, 5321
10829, 1279, 4362, 1000, 5794
10830, 3918, 4711, 5140, 5403
10831, 858, 4062, 4942, 5528
10832, 2537, 2949, 4807, 5867
10833, 3959, 4184, 4418, 6138
10834, 3902, 4761, 4474, 5676
10835, 2143, 4312, 3255, 5375
10836, 3918, 4711, 5262, 5691
10837, 1169, 736, 4592, 5642
10838, 1281, 983, 984, 4598
10839, 3925, 4695, 4154, 5700
10840, 2858, 4938, 4650, 4991
10841, 776, 4776, 4305, 5791
10842, 4917, 5175, 4225, 5832
10843, 2471, 4160, 2472, 5318
10844, 3991, 5187, 4353, 5191
10845, 2700, 4201, 2697, 5357
10846, 4056, 4996, 4804, 5668
10847, 3975, 4179, 4792, 4829
10848, 3941, 4877, 4339, 5333
10849, 3925, 4567, 4901, 5568
10850, 4292, 4850, 2175, 5316
10851, 399, 397, 4171, 5506
10852, 3931, 4216, 4411, 5206
10853, 2187, 4466, 2186, 4973
10854, 2857, 2856, 2858, 5659
10855, 4185, 4624, 3899, 4856
10856, 3646, 3659, 3655, 4365
10857, 535, 607, 533, 4735
10858, 3713, 930, 299, 4428
10859, 3077, 4290, 4932, 5004
10860, 4327, 3963, 5561, 5683
10861, 4000, 4391, 5046, 5628
10862, 4689, 5643, 5477, 5837
10863, 3917, 4226, 5118, 5465
10864, 3950, 5356, 4559, 5871
10865, 2795, 4907, 4591, 5706
10866, 4227, 3912, 4721, 6054
10867, 4231, 4801, 4444, 5870
10868, 3462, 4593, 3343, 5510
10869, 4306, 5504, 4719, 5761
10870, 1288, 4894, 5519, 5573
10871, 4462, 4704, 2899, 5811
10872, 1234, 4894, 4691, 5519
10873, 3744, 5062, 3745, 5613
10874, 1040, 1232, 4692, 5997
10875, 2753, 4512, 2797, 4786
10876, 5006, 5475, 4267, 6071
10877, 3089, 5296, 4664, 5316
10878, 3943, 5354, 4379, 5829
10879, 4906, 6095, 4352, 6127
10880, 2279, 4823, 4252, 6089
10881, 4166, 5000, 4737, 5803
10882, 804, 1309, 805, 4700
10883, 4252, 4823, 2279, 4834
10884, 3908, 4716, 4585, 6193
10885, 3944, 4719, 5504, 5761
10886, 615, 4432, 4740, 5677
10887, 3912, 4144, 4727, 5373
10888, 4418, 4747, 3959, 5757
10889, 3903, 4921, 4169, 5560
10890, 724, 726, 4487, 5149
10891, 4015, 4997, 4828, 5097
10892, 4245, 5201, 4705, 5906
10893, 4456, 4131, 5600, 5779
10894, 3938, 4833, 4584, 5386
10895, 3934, 4156, 4736, 5672
10896, 3908, 4360, 4585, 5187
10897, 4367, 4710, 4192, 5968
10898, 740, 643, 4740, 5673
10899, 4546, 5025, 2479, 6119
10900, 645, 4174, 1011, 5144
10901, 2699, 4193, 4612, 5357
10902, 4533, 4041, 5554, 5696
10903, 1291, 4629, 4474, 5367
10904, 2905, 4514, 2981, 5115
10905, 4456, 4726, 3927, 5570
10906, 789, 4889, 4149, 6068
10907, 4325, 3954, 4972, 5823
10908, 3931, 4249, 4713, 5374
10909, 3998, 4123, 4598, 5122
10910, 1317, 881, 858, 4857
10911, 649, 4806, 4324, 5820
10912, 2649, 4335, 2646, 5661
10913, 3972, 4665, 4180, 4867
10914, 3955, 5406, 5250, 5830
10915, 4496, 5047, 3972, 5279
10916, 4027, 4827, 4242, 5272
10917, 3946, 4156, 4705, 5162
10918, 598, 4399, 1093, 5440
10919, 4329, 4747, 3959, 4765
10920, 4189, 4054, 4810, 6075
10921, 1282, 381, 1284, 4794
10922, 2310, 2595, 4265, 4970
10923, 3974, 5155, 4424, 5807
10924, 3940, 4565, 4802, 5499
10925, 1023, 4805, 4111, 5789
10926, 5006, 5184, 3930, 6109
10927, 3992, 4939, 4595, 5338
10928, 4516, 5382, 2259, 5517
10929, 4449, 5569, 326, 5714
10930, 3957, 5039, 4276, 5192
10931, 2488, 5191, 2994, 5527
10932, 4169, 3903, 4551, 4624
10933, 672, 674, 4229, 6037
10934, 2463, 4262, 2875, 5247
10935, 2356, 4708, 4302, 5227
10936, 4224, 4688, 2676, 4928
10937, 3964, 4912, 4505, 5566
10938, 3974, 4731, 4987, 5464
10939, 5060, 5410, 2752, 5468
10940, 4002, 4489, 4490, 5231
10941, 4568, 5208, 4115, 5772
10942, 4104, 4981, 4629, 5529
10943, 4441, 5008, 4592, 5642
10944, 3147, 4462, 2899, 5811
10945, 4953, 5401, 4374, 5981
10946, 1252, 4343, 1245, 5504
10947, 896, 4582, 5556, 5637
10948, 4367, 4119, 5515, 6111
10949, 513, 4894, 516, 5165
10950, 4286, 4022, 5676, 6049
10951, 4144, 3912, 4727, 4979
10952, 2788, 5262, 4756, 5955
10953, 2281, 4517, 2178, 4850
10954, 3090, 3035, 2334, 5188
10955, 1270, 5103, 4461, 5232
10956, 364, 365, 4213, 5575
10957, 4197, 3905, 5480, 6085
10958, 4068, 5611, 5422, 5690
10959, 3916, 5017, 4176, 5369
10960, 593, 653, 595, 4629
10961, 4096, 3950, 4908, 5544
10962, 512, 516, 1226, 5165
10963, 4074, 5410, 5208, 5890
10964, 5126, 5504, 4120, 5761
10965, 3057, 3721, 4448, 5321
10966, 4231, 4595, 4360, 5102
10967, 4119, 4844, 4367, 5515
10968, 3964, 4406, 4276, 4912
10969, 5095, 5109, 4123, 5649
10970, 4979, 5812, 4145, 6215
10971, 3614, 3613, 3612, 5133
10972, 672, 4229, 1141, 4873
10973, 4702, 5073, 4268, 5645
10974, 4325, 5505, 3905, 5534
10975, 4489, 3134, 4934, 5984
10976, 2260, 4813, 4682, 5721
10977, 2872, 3138, 5261, 5558
10978, 3554, 4772, 5112, 5220
10979, 3935, 4572, 4263, 6125
10980, 4281, 4424, 5888, 5922
10981, 3950, 5020, 4264, 5871
10982, 3925, 4798, 4158, 5703
10983, 4461, 5144, 4329, 6218
10984, 2699, 2698, 4193, 5357
10985, 4018, 5330, 4955, 5689
10986, 3962, 5009, 4375, 5992
10987, 1282, 983, 4250, 6104
10988, 5486, 5558, 4199, 6201
10989, 3554, 3545, 4772, 5220
10990, 4051, 4481, 5214, 5316
10991, 335, 1091, 3697, 4880
10992, 3946, 4676, 4705, 6044
10993, 645, 562, 4174, 5545
10994, 4201, 4415, 4015, 6029
10995, 4555, 4603, 4127, 5635
10996, 4205, 4563, 2169, 5106
10997, 561, 4326, 560, 4829
10998, 499, 4277, 1146, 5371
10999, 3944, 4719, 4346, 5530
11000, 4370, 4437, 4007, 4604
11001, 4123, 5095, 4745, 5536
11002, 4047, 4410, 4297, 5966
11003, 3514, 4976, 3516, 5078
11004, 4662, 5347, 4055, 5446
11005, 1105, 4724, 4210, 5401
11006, 4357, 4777, 4180, 5210
11007, 848, 852, 1145, 4725
11008, 4373, 4805, 4126, 5574
11009, 4297, 4410, 4047, 4818
11010, 4060, 5161, 5460, 5610
11011, 5022, 5270, 4556, 5740
11012, 3919, 4753, 4463, 5089
11013, 4566, 4660, 1092, 5701
11014, 2429, 4169, 5560, 6199
11015, 2187, 2186, 2188, 4973
11016, 4202, 3954, 4744, 5823
11017, 3764, 4675, 4672, 5447
11018, 4632, 4735, 4187, 5507
11019, 3925, 4154, 4798, 5700
11020, 1146, 4277, 4849, 5371
11021, 563, 4179, 603, 5399
11022, 2699, 4193, 3129, 4612
11023, 4555, 5635, 4127, 6070
11024, 4159, 3953, 4587, 4799
11025, 2459, 2435, 2460, 4509
11026, 3962, 4252, 5009, 5992
11027, 4629, 5529, 4981, 5581
11028, 3912, 4227, 4721, 4783
11029, 3859, 4887, 3785, 5550
11030, 3929, 4399, 4231, 4841
11031, 4734, 5756, 5329, 6185
11032, 3929, 4399, 4255, 4801
11033, 1353, 5007, 826, 5653
11034, 4017, 4556, 5022, 5270
11035, 4157, 4692, 5570, 5655
11036, 3682, 3634, 3598, 4939
11037, 2988, 2407, 2408, 4852
11038, 1238, 949, 831, 4858
11039, 5127, 5517, 4103, 5744
11040, 572, 4958, 4268, 5923
11041, 4461, 5098, 4171, 6188
11042, 1152, 615, 4432, 4740
11043, 4470, 4044, 5488, 5533
11044, 3961, 5214, 4481, 5316
11045, 4572, 5140, 4263, 6125
11046, 3899, 4652, 4895, 5890
11047, 2661, 4312, 2678, 4717
11048, 4302, 4608, 3934, 4736
11049, 4000, 5149, 4313, 5154
11050, 2594, 3108, 4586, 6233
11051, 3301, 5326, 4246, 5413
11052, 3985, 5094, 4395, 5557
11053, 3937, 5274, 4157, 6065
11054, 1043, 572, 4268, 5923
11055, 2884, 4433, 5332, 5708
11056, 4199, 4684, 4590, 5596
11057, 1242, 4662, 5083, 5446
11058, 3857, 5236, 5079, 5620
11059, 3555, 4108, 5112, 5722
11060, 674, 5355, 4229, 6037
11061, 3142, 3202, 3123, 5021
11062, 4750, 4800, 4466, 4973
11063, 4463, 5089, 4753, 5509
11064, 792, 4927, 5702, 5722
11065, 3910, 4495, 5379, 6147
11066, 3972, 4180, 4665, 5752
11067, 3316, 4384, 3371, 5266
11068, 949, 4317, 831, 4858
11069, 4028, 5254, 6115, 6188
11070, 4310, 4513, 4198, 5578
11071, 4276, 4693, 3957, 5192
11072, 3974, 4257, 5155, 5807
11073, 776, 4305, 1320, 5791
11074, 4109, 5010, 5631, 5745
11075, 3655, 4365, 3659, 5104
11076, 2393, 4817, 4173, 5740
11077, 3855, 5136, 3864, 6221
11078, 4482, 4488, 4002, 5844
11079, 3975, 4168, 4792, 4824
11080, 4167, 3931, 5206, 5709
11081, 1198, 4975, 4146, 5027
11082, 4170, 3958, 4696, 5456
11083, 4155, 4951, 4764, 5642
11084, 2395, 4304, 4988, 5436
11085, 3819, 3697, 1091, 4880
11086, 3918, 4979, 4289, 5691
11087, 4060, 4725, 4697, 5460
11088, 1211, 5257, 1244, 5495
11089, 3784, 4500, 3825, 5550
11090, 2613, 4387, 4817, 5630
11091, 3931, 4167, 5281, 5709
11092, 2304, 4908, 2928, 5566
11093, 4239, 4550, 1125, 5398
11094, 995, 4967, 4694, 5741
11095, 1156, 4184, 568, 5181
11096, 3129, 4612, 4193, 5078
11097, 1261, 978, 4585, 5002
11098, 3775, 5079, 3857, 5236
11099, 945, 4209, 5313, 5567
11100, 4316, 4909, 4023, 5112
11101, 1085, 3824, 4534, 4752
11102, 4138, 5415, 4801, 5680
11103, 4242, 4532, 4027, 5643
11104, 4367, 5192, 4119, 6111
11105, 4351, 4010, 4615, 5965
11106, 4158, 4901, 3925, 5703
11107, 5136, 5155, 2769, 6087
11108, 409, 418, 5386, 5752
11109, 3958, 4252, 4696, 5463
11110, 3921, 5124, 4260, 5840
11111, 3915, 4465, 4132, 4987
11112, 1242, 1174, 4662, 5446
11113, 1252, 4343, 4712, 5633
11114, 4161, 3906, 4989, 5005
11115, 2608, 5261, 4611, 5736
11116, 3797, 4296, 3798, 5038
11117, 3966, 4759, 4336, 5064
11118, 559, 4326, 4829, 5735
11119, 3664, 2151, 3174, 4508
11120, 4738, 6021, 6071, 6172
11121, 950, 932, 585, 4287
11122, 4095, 4667, 5076, 5445
11123, 1261, 5002, 4585, 5816
11124, 4262, 3969, 4810, 5247
11125, 719, 4614, 4464, 4849
11126, 4177, 4800, 2258, 5942
11127, 4969, 5004, 4359, 5901
11128, 4213, 5123, 4337, 5689
11129, 4305, 4776, 776, 5305
11130, 4339, 4759, 4175, 5285
11131, 2836, 4301, 5312, 5469
11132, 4118, 4703, 2220, 5877
11133, 2393, 4430, 3025, 4817
11134, 4313, 4931, 4000, 5934
11135, 5184, 5552, 4654, 6109
11136, 2535, 4226, 2796, 6205
11137, 3981, 4996, 4528, 5808
11138, 4158, 3939, 4737, 5006
11139, 4121, 4538, 4450, 5449
11140, 1011, 4174, 562, 5644
11141, 2587, 4616, 2764, 4626
11142, 710, 5244, 4603, 6196
11143, 1023, 5789, 4111, 5954
11144, 3926, 4891, 4540, 5473
11145, 4238, 4816, 546, 5130
11146, 2649, 2646, 4335, 5026
11147, 679, 1250, 4194, 4868
11148, 4220, 5273, 4852, 6102
11149, 4814, 4845, 4483, 6232
11150, 2962, 4645, 3050, 4989
11151, 2771, 2769, 5155, 6087
11152, 4161, 3906, 4645, 4989
11153, 2145, 3211, 3097, 5125
11154, 4393, 5329, 4734, 5756
11155, 4235, 4477, 3982, 5175
11156, 4162, 4761, 4161, 4763
11157, 4392, 4853, 3989, 4904
11158, 3902, 4998, 4581, 5627
11159, 4517, 5427, 4278, 5434
11160, 4484, 5084, 4133, 5187
11161, 4158, 3930, 5006, 5184
11162, 3991, 5084, 4484, 5187
11163, 4128, 5008, 4638, 5957
11164, 1293, 4977, 4339, 5333
11165, 2929, 5028, 4666, 6128
11166, 896, 895, 5556, 5562
11167, 2264, 4154, 4798, 5346
11168, 2674, 3107, 4890, 5056
11169, 4305, 4882, 4299, 5005
11170, 3020, 4609, 4361, 5416
11171, 2941, 2646, 4335, 5661
11172, 2498, 4591, 2795, 4907
11173, 3527, 3529, 4885, 5112
11174, 1408, 989, 1394, 4334
11175, 3035, 4153, 4667, 5858
11176, 3579, 5666, 5077, 6151
11177, 3903, 4426, 4921, 5560
11178, 2796, 4226, 2535, 5706
11179, 4076, 4786, 4512, 5123
11180, 4064, 4774, 4543, 5095
11181, 4269, 3924, 4785, 4789
11182, 4276, 4693, 2271, 5833
11183, 3935, 4572, 5113, 5769
11184, 3991, 4300, 4708, 5241
11185, 4220, 4256, 5739, 6102
11186, 4229, 4771, 1141, 4873
11187, 3337, 5147, 4820, 5413
11188, 4097, 3920, 4943, 5239
11189, 4877, 4544, 5767, 5787
11190, 426, 400, 1148, 4757
11191, 2463, 4723, 4262, 5247
11192, 2840, 2415, 5218, 5991
11193, 4313, 5149, 4350, 5154
11194, 4481, 4560, 4006, 4878
11195, 4189, 4810, 3969, 5247
11196, 3028, 4643, 4453, 5469
11197, 4020, 4562, 5048, 5133
11198, 2985, 4518, 2689, 5436
11199, 4159, 4778, 3957, 5327
11200, 3613, 4163, 3615, 5393
11201, 3916, 5075, 4453, 5128
11202, 4458, 4150, 4946, 5072
11203, 4492, 4148, 5235, 5792
11204, 4877, 5333, 4544, 5787
11205, 4196, 5165, 4894, 5917
11206, 1187, 795, 4470, 4742
11207, 3952, 4305, 4622, 5305
11208, 1399, 5421, 4274, 5623
11209, 4671, 4692, 1040, 6025
11210, 4833, 4860, 4380, 5574
11211, 4336, 5064, 4759, 5634
11212, 628, 5276, 5492, 6238
11213, 4281, 5915, 4132, 6232
11214, 4146, 5657, 4474, 5676
11215, 3192, 2137, 4433, 4962
11216, 984, 4123, 4661, 5718
11217, 1192, 4360, 622, 5102
11218, 3992, 4291, 4701, 4939
11219, 4057, 4850, 4517, 5427
11220, 559, 4829, 4680, 5735
11221, 3917, 5118, 4221, 5576
11222, 3958, 5009, 4252, 5463
11223, 3683, 3653, 4274, 5421
11224, 2861, 5737, 4938, 5978
11225, 4492, 5057, 3869, 6074
11226, 2855, 4633, 2854, 4991
11227, 4434, 3924, 4866, 5434
11228, 370, 4649, 4622, 5342
11229, 4203, 4528, 4996, 5808
11230, 3951, 4204, 5067, 5412
11231, 4497, 4876, 5115, 5924
11232, 2782, 4631, 4208, 5099
11233, 796, 5650, 5576, 6030
11234, 2803, 3078, 4755, 5599
11235, 4627, 5218, 2415, 5991
11236, 4231, 4399, 3929, 5870
11237, 3888, 4391, 3740, 5284
11238, 4053, 5275, 4655, 5483
11239, 2846, 2845, 2803, 5681
11240, 4498, 4653, 2191, 4932
11241, 2188, 4973, 4609, 5389
11242, 4160, 4950, 4881, 5962
11243, 5282, 5488, 4044, 5533
11244, 623, 1167, 668, 5870
11245, 2620, 4182, 3178, 5199
11246, 3975, 4824, 4179, 5399
11247, 3080, 3028, 5469, 5626
11248, 4348, 3985, 5094, 5352
11249, 1198, 5027, 4146, 5539
11250, 1075, 4924, 4752, 5597
11251, 4176, 3913, 4836, 6096
11252, 4587, 4778, 4364, 5861
11253, 740, 643, 746, 4740
11254, 2205, 4565, 5476, 5648
11255, 949, 5360, 4317, 5399
11256, 4734, 5329, 5813, 6185
11257, 4466, 4750, 3980, 4800
11258, 3931, 4411, 4713, 5281
11259, 322, 4491, 4997, 5562
11260, 3642, 4751, 4274, 5971
11261, 674, 1141, 672, 4229
11262, 3189, 2739, 4417, 5326
11263, 5115, 5815, 4497, 5924
11264, 748, 4319, 920, 5496
11265, 415, 5462, 5157, 5525
11266, 3986, 4894, 4333, 5938
11267, 4142, 5322, 5029, 5434
11268, 4315, 5007, 4529, 5653
11269, 3900, 4985, 4532, 5643
11270, 2457, 4191, 2555, 4988
11271, 4232, 4891, 3926, 5473
11272, 2824, 5052, 4519, 5521
11273, 3902, 4161, 4761, 4998
11274, 4327, 5561, 4405, 5683
11275, 4457, 5173, 4429, 5619
11276, 3499, 4707, 4138, 4796
11277, 3288, 3245, 4195, 5869
11278, 3912, 4144, 4783, 4979
11279, 480, 4718, 5973, 6050
11280, 2271, 4912, 4276, 5640
11281, 3928, 4512, 4786, 5123
11282, 2558, 5443, 5294, 6199
11283, 689, 4557, 674, 5355
11284, 4877, 5767, 5674, 5787
11285, 3986, 4643, 4347, 6006
11286, 3930, 4654, 4377, 5152
11287, 4682, 4795, 4438, 4813
11288, 3982, 4917, 4225, 5150
11289, 4206, 4689, 4443, 5646
11290, 4290, 4545, 3995, 5004
11291, 3981, 4996, 4504, 5990
11292, 3939, 4737, 4166, 5000
11293, 2177, 2175, 2176, 4850
11294, 4434, 3982, 4922, 6072
11295, 2356, 4302, 2354, 5227
11296, 636, 4758, 637, 5606
11297, 4048, 4497, 4876, 5115
11298, 4226, 4625, 3911, 5177
11299, 4595, 4701, 4113, 4939
11300, 2941, 2649, 2646, 5661
11301, 2927, 2928, 4908, 5566
11302, 1080, 4471, 1079, 5821
11303, 3974, 4987, 4132, 5464
11304, 559, 560, 561, 4326
11305, 4744, 5645, 5073, 6138
11306, 4532, 4985, 3900, 5602
11307, 3077, 4932, 2195, 5004
11308, 4455, 4783, 4721, 5854
11309, 3903, 4169, 4551, 5560
11310, 2230, 2229, 2227, 5184
11311, 3998, 4543, 5351, 5926
11312, 386, 4714, 384, 5584
11313, 3958, 4965, 4589, 5456
11314, 4506, 4593, 3988, 5510
11315, 1280, 5122, 387, 5584
11316, 2416, 4822, 4400, 5810
11317, 573, 4325, 571, 4958
11318, 4367, 4844, 4119, 5192
11319, 4048, 4876, 4514, 5115
11320, 4409, 2664, 5639, 6064
11321, 560, 4829, 4326, 5644
11322, 1066, 4260, 5124, 5840
11323, 4821, 5209, 4036, 5245
11324, 4169, 4786, 3928, 5060
11325, 4203, 4996, 3981, 5808
11326, 3972, 4703, 4525, 5729
11327, 783, 4310, 4513, 5664
11328, 3459, 3418, 5044, 5713
11329, 4340, 4531, 3978, 4717
11330, 3295, 3188, 3896, 4448
11331, 3969, 4964, 4402, 5940
11332, 4744, 4184, 5645, 6138
11333, 4152, 5017, 3916, 5387
11334, 3534, 5248, 3535, 5291
11335, 2919, 2916, 2180, 4517
11336, 4155, 4346, 4951, 5642
11337, 2182, 2180, 4839, 6080
11338, 1365, 800, 4274, 5002
11339, 2735, 3378, 2104, 4648
11340, 4017, 4816, 4238, 6014
11341, 4057, 5427, 4517, 5434
11342, 3941, 5076, 4667, 5445
11343, 4145, 5691, 2788, 6066
11344, 4133, 3934, 4980, 5162
11345, 4290, 3995, 4545, 4994
11346, 4280, 4627, 3935, 5441
11347, 3916, 5128, 4131, 5165
11348, 304, 912, 3414, 4436
11349, 3899, 5116, 4236, 5998
11350, 2759, 2594, 3108, 4586
11351, 3915, 4230, 4845, 4975
11352, 3945, 5163, 4414, 5559
11353, 4195, 5257, 4944, 5608
11354, 3925, 4567, 4103, 5127
11355, 3937, 4157, 4599, 6065
11356, 3227, 3273, 3251, 5495
11357, 2927, 2304, 2928, 5566
11358, 4833, 5277, 4584, 5386
11359, 399, 4171, 4757, 5506
11360, 4120, 5761, 5504, 6219
11361, 3979, 5164, 4215, 6084
11362, 2591, 4429, 5173, 5619
11363, 5073, 5645, 4184, 6138
11364, 3010, 4483, 4318, 5013
11365, 4262, 4723, 3969, 5247
11366, 4017, 4238, 4816, 6169
11367, 3917, 5042, 4699, 5405
11368, 3273, 1211, 1244, 5495
11369, 3941, 4571, 4877, 5333
11370, 544, 1049, 546, 4238
11371, 4044, 4470, 5009, 5515
11372, 4347, 4643, 3031, 5626
11373, 4377, 5152, 4654, 5699
11374, 3907, 4771, 4507, 5556
11375, 4303, 4949, 4396, 5198
11376, 3447, 4529, 4437, 5131
11377, 3994, 4207, 4839, 5029
11378, 4146, 4761, 4474, 5027
11379, 3993, 4404, 4384, 5222
11380, 4146, 4474, 4286, 5539
11381, 561, 559, 4326, 4829
11382, 496, 5454, 4610, 5967
11383, 1270, 1014, 1269, 4461
11384, 601, 621, 500, 4975
11385, 3349, 5082, 3461, 5562
11386, 643, 4447, 614, 5677
11387, 2985, 4988, 4518, 5436
11388, 4210, 5113, 4572, 5769
11389, 494, 499, 4679, 5317
11390, 4316, 4586, 4023, 4909
11391, 3946, 5093, 4343, 5126
11392, 3967, 4372, 4765, 4957
11393, 4116, 4870, 3875, 5151
11394, 4250, 4878, 4794, 5894
11395, 4744, 5181, 4418, 6175
11396, 2587, 2764, 2924, 4626
11397, 3908, 4117, 5187, 6079
11398, 4225, 5175, 5150, 5755
11399, 1207, 5244, 710, 6196
11400, 1280, 5122, 385, 5804
11401, 4199, 5111, 4139, 5315
11402, 562, 4174, 5545, 5644
11403, 3515, 4193, 4976, 5078
11404, 4382, 4721, 3912, 6054
11405, 4381, 4526, 5085, 6032
11406, 4327, 3963, 4669, 5561
11407, 2266, 4438, 2265, 4813
11408, 4319, 5064, 4740, 5796
11409, 3956, 4381, 4903, 6185
11410, 4222, 4917, 3976, 5592
11411, 4981, 5581, 5087, 6049
11412, 4250, 1282, 4794, 5804
11413, 4295, 5584, 5122, 5804
11414, 4036, 4186, 4821, 5396
11415, 4744, 4418, 5808, 6175
11416, 1092, 4248, 4566, 5265
11417, 5069, 5774, 4416, 5938
11418, 3917, 4221, 5405, 5576
11419, 4371, 4650, 4128, 5737
11420, 2699, 2698, 3129, 4193
11421, 2298, 2993, 2264, 4154
11422, 3897, 3727, 346, 4349
11423, 3083, 5490, 5107, 5944
11424, 448, 450, 440, 4155
11425, 4517, 4839, 4207, 5029
11426, 385, 1280, 387, 5584
11427, 5029, 5258, 4142, 5434
11428, 4001, 4576, 4365, 4999
11429, 4319, 3919, 4740, 5244
11430, 4218, 5010, 4040, 5631
11431, 4207, 4560, 4481, 4878
11432, 3902, 4162, 5005, 5791
11433, 4345, 4422, 1337, 5580
11434, 1363, 1301, 344, 4539
11435, 3905, 4767, 4396, 5195
11436, 4015, 4415, 4201, 5770
11437, 1239, 4738, 6021, 6071
11438, 4213, 4967, 4337, 5123
11439, 3168, 3203, 2692, 5995
11440, 4117, 3946, 4705, 5162
11441, 4107, 4778, 3957, 5086
11442, 2988, 4852, 4220, 6057
11443, 3109, 2930, 2919, 5427
11444, 3919, 4740, 4447, 5089
11445, 3869, 4492, 4675, 5057
11446, 3931, 5281, 4673, 5709
11447, 3430, 5014, 3377, 6116
11448, 3934, 5162, 4156, 5672
11449, 3937, 5302, 4373, 5462
11450, 4541, 4793, 3936, 5204
11451, 3115, 2697, 4201, 5524
11452, 2559, 2752, 5060, 5410
11453, 2854, 4633, 4251, 4991
11454, 4006, 4560, 4481, 6090
11455, 4378, 4007, 5414, 6152
11456, 3975, 4179, 4829, 5399
11457, 2182, 4839, 4207, 6080
11458, 4396, 4818, 3905, 4949
11459, 3945, 4514, 4682, 5113
11460, 4931, 5021, 3286, 5452
11461, 440, 4155, 450, 5475
11462, 571, 4325, 573, 5823
11463, 4585, 5276, 4133, 5492
11464, 4700, 5268, 938, 5311
11465, 3908, 4360, 4716, 6193
11466, 4124, 3899, 5531, 5875
11467, 3598, 4291, 3633, 5117
11468, 4980, 5162, 3934, 5672
11469, 4158, 5006, 4737, 6001
11470, 2438, 4826, 4538, 5318
11471, 3953, 4170, 4633, 5748
11472, 4019, 4342, 5341, 5429
11473, 4114, 5795, 4589, 5817
11474, 4186, 4036, 4821, 5209
11475, 4011, 5172, 5153, 5565
11476, 4390, 4916, 4039, 5793
11477, 771, 674, 689, 4557
11478, 3952, 4205, 5230, 6002
11479, 3984, 4697, 4383, 4954
11480, 384, 4458, 382, 4794
11481, 4104, 4305, 4882, 5305
11482, 3964, 4276, 4406, 5913
11483, 3905, 5195, 4949, 6085
11484, 3528, 4316, 3527, 4885
11485, 4131, 3916, 5165, 5179
11486, 3950, 4239, 4868, 5020
11487, 4411, 4713, 4092, 5859
11488, 2874, 3151, 2411, 5679
11489, 3582, 3507, 4199, 5111
11490, 5121, 5293, 4583, 5529
11491, 4454, 5650, 5131, 6030
11492, 4424, 5155, 4257, 5807
11493, 3912, 4727, 4979, 5081
11494, 4690, 5342, 4106, 5523
11495, 4885, 5248, 3532, 5308
11496, 2983, 3140, 4640, 5639
11497, 5042, 5289, 4699, 5405
11498, 2922, 4439, 3821, 5136
11499, 764, 762, 4282, 6160
11500, 3976, 4532, 4412, 5225
11501, 4156, 4273, 5093, 6044
11502, 4447, 4740, 3919, 5209
11503, 4334, 4281, 5408, 5888
11504, 2227, 4654, 5552, 5859
11505, 4226, 4970, 2796, 6205
11506, 4263, 4572, 3935, 4749
11507, 3031, 4643, 4347, 5052
11508, 3997, 4389, 4495, 4948
11509, 4323, 5203, 4715, 5733
11510, 4457, 4611, 3920, 5766
11511, 3304, 892, 322, 4491
11512, 4189, 4054, 4974, 5590
11513, 2753, 4597, 4786, 5060
11514, 2194, 5004, 4223, 5901
11515, 1355, 5131, 4454, 5650
11516, 2177, 2175, 4850, 5316
11517, 4013, 4254, 4513, 5235
11518, 393, 395, 394, 4670
11519, 4314, 4674, 4062, 5420
11520, 4342, 5476, 4565, 5648
11521, 4006, 5121, 4481, 5391
11522, 2260, 4682, 2975, 5721
11523, 543, 4549, 424, 4673
11524, 2310, 4970, 4265, 5387
11525, 3319, 2129, 4490, 5176
11526, 5171, 5400, 4069, 5746
11527, 1254, 4665, 4577, 5520
11528, 3932, 4566, 4333, 4805
11529, 4046, 4364, 5158, 5861
11530, 765, 4715, 4689, 5836
11531, 4321, 5184, 5006, 6109
11532, 2558, 5294, 4652, 6199
11533, 848, 4725, 4294, 5881
11534, 3965, 4743, 4430, 5578
11535, 3019, 2766, 2398, 5334
11536, 2700, 2697, 2699, 4612
11537, 4487, 5284, 5046, 5656
11538, 3282, 4344, 5116, 5294
11539, 832, 4861, 4390, 4920
11540, 4402, 4723, 3969, 5671
11541, 3967, 4765, 4372, 4994
11542, 3428, 3402, 3401, 5776
11543, 3959, 4748, 4168, 4792
11544, 4516, 4971, 4813, 5148
11545, 4131, 5165, 5128, 5450
11546, 4185, 4879, 4856, 5741
11547, 2447, 2891, 4358, 4748
11548, 4015, 4507, 4997, 5097
11549, 4044, 5515, 4119, 6111
11550, 3938, 4180, 4833, 5386
11551, 4384, 3993, 4641, 4875
11552, 4232, 4540, 4891, 5473
11553, 3939, 4155, 4738, 6211
11554, 4684, 5077, 3570, 5437
11555, 3433, 3438, 3364, 5797
11556, 3274, 4344, 2108, 6170
11557, 3950, 4096, 4908, 4918
11558, 2482, 2562, 4666, 5028
11559, 2440, 4646, 4637, 5428
11560, 2172, 5175, 4477, 5800
11561, 4007, 4625, 4378, 5414
11562, 3764, 4672, 4915, 5447
11563, 4347, 4643, 4068, 6006
11564, 3932, 5298, 4860, 5574
11565, 3945, 4682, 4795, 5113
11566, 3916, 4131, 5128, 5179
11567, 440, 4764, 4155, 5475
11568, 4098, 3951, 4687, 5604
11569, 3930, 5513, 5281, 6109
11570, 4086, 4363, 4802, 5767
11571, 4218, 5405, 4883, 6118
11572, 3910, 5012, 4948, 6180
11573, 3767, 3869, 4492, 4675
11574, 595, 5091, 4629, 5367
11575, 523, 4259, 4697, 5460
11576, 1260, 4577, 4357, 5051
11577, 3229, 3280, 3303, 5021
11578, 4282, 4922, 4866, 5150
11579, 4006, 4208, 5099, 5121
11580, 679, 4868, 4194, 5083
11581, 2760, 2545, 4586, 4891
11582, 3865, 3776, 3774, 5236
11583, 4527, 4666, 2562, 5028
11584, 1014, 1271, 1013, 6218
11585, 561, 4680, 559, 4829
11586, 667, 4471, 4924, 5597
11587, 3646, 4365, 4683, 6194
11588, 701, 4856, 4328, 4879
11589, 693, 649, 4806, 5547
11590, 3438, 3364, 5797, 5814
11591, 4139, 3936, 4793, 5204
11592, 4149, 4889, 5782, 6068
