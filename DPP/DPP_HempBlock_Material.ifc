Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: 9702c0de-1acb-45e1-a0df-32f8f7e0f16f, VersionGUID: 4f854121-0645-4df6-8d91-fe05c251bc89, NumberOfSaves: 2], Options [Excluded Entities: IfcElement;IfcBuiltElement;IfcBeam;IfcBearing;IfcChimney;IfcColumn;IfcCourse;IfcCovering;IfcCurtainWall;IfcDeepFoundation;IfcCaissonFoundation;IfcPile;IfcDoor;IfcEarthworksElement;IfcEarthworksFill;IfcReinforcedSoil;IfcFooting;IfcKerb;IfcMember;IfcMooringDevice;IfcNavigationElement;IfcPavement;IfcPlate;IfcRail;IfcRailing;IfcRamp;IfcRampFlight;IfcRoof;IfcShadingDevice;IfcSlab;IfcStair;IfcStairFlight;IfcTrackElement;IfcWall;IfcWindow;IfcCivilElement;IfcDistributionElement;IfcDistributionControlElement;IfcActuator;IfcAlarm;IfcController;IfcFlowInstrument;IfcProtectiveDeviceTrippingUnit;IfcSensor;IfcUnitaryControlElement;IfcDistributionFlowElement;IfcDistributionChamberElement;IfcEnergyConversionDevice;IfcAirToAirHeatRecovery;IfcBoiler;IfcBurner;IfcChiller;IfcCoil;IfcCondenser;IfcCooledBeam;IfcCoolingTower;IfcElectricGenerator;IfcElectricMotor;IfcEngine;IfcEvaporativeCooler;IfcEvaporator;IfcHeatExchanger;IfcHumidifier;IfcMotorConnection;IfcSolarDevice;IfcTransformer;IfcTubeBundle;IfcUnitaryEquipment;IfcFlowController;IfcAirTerminalBox;IfcDamper;IfcDistributionBoard;IfcElectricDistributionBoard;IfcElectricTimeControl;IfcFlowMeter;IfcProtectiveDevice;IfcSwitchingDevice;IfcValve;IfcFlowFitting;IfcCableCarrierFitting;IfcCableFitting;IfcDuctFitting;IfcJunctionBox;IfcPipeFitting;IfcFlowMovingDevice;IfcCompressor;IfcFan;IfcPump;IfcFlowSegment;IfcCableCarrierSegment;IfcCableSegment;IfcConveyorSegment;IfcDuctSegment;IfcPipeSegment;IfcFlowStorageDevice;IfcElectricFlowStorageDevice;IfcTank;IfcFlowTerminal;IfcAirTerminal;IfcAudioVisualAppliance;IfcCommunicationsAppliance;IfcElectricAppliance;IfcFireSuppressionTerminal;IfcLamp;IfcLightFixture;IfcLiquidTerminal;IfcMedicalDevice;IfcMobileTelecommunicationsAppliance;IfcOutlet;IfcSanitaryTerminal;IfcSignal;IfcSpaceHeater;IfcStackTerminal;IfcWasteTerminal;IfcFlowTreatmentDevice;IfcDuctSilencer;IfcElectricFlowTreatmentDevice;IfcFilter;IfcInterceptor;IfcElementAssembly;IfcElementComponent;IfcBuildingElementPart;IfcDiscreteAccessory;IfcFastener;IfcImpactProtectionDevice;IfcMechanicalFastener;IfcReinforcingElement;IfcReinforcingBar;IfcReinforcingMesh;IfcTendon;IfcTendonAnchor;IfcTendonConduit;IfcSign;IfcVibrationDamper;IfcVibrationIsolator;IfcFeatureElement;IfcFeatureElementAddition;IfcProjectionElement;IfcFeatureElementSubtraction;IfcEarthworksCut;IfcOpeningElement;IfcVoidingFeature;IfcSurfaceFeature;IfcFurnishingElement;IfcFurniture;IfcSystemFurnitureElement;IfcGeographicElement;IfcGeotechnicalElement;IfcGeotechnicalAssembly;IfcBorehole;IfcGeomodel;IfcGeoslice;IfcGeotechnicalStratum;IfcTransportationDevice;IfcTransportElement;IfcVehicle;IfcVirtualElement;IfcLinearElement;IfcAlignmentCant;IfcAlignmentHorizontal;IfcAlignmentSegment;IfcAlignmentVertical;IfcPort;IfcDistributionPort;IfcPositioningElement;IfcGrid;IfcLinearPositioningElement;IfcAlignment;IfcReferent;IfcSpatialElement;IfcExternalSpatialStructureElement;IfcExternalSpatialElement;IfcSpatialStructureElement;IfcFacility;IfcBridge;IfcMarineFacility;IfcRailway;IfcRoad;IfcFacilityPart;IfcBridgePart;IfcFacilityPartCommon;IfcMarinePart;IfcRailwayPart;IfcRoadPart;IfcSite;IfcSpace;IfcSpatialZone;IfcStructuralActivity;IfcStructuralAction;IfcStructuralCurveAction;IfcStructuralLinearAction;IfcStructuralPointAction;IfcStructuralSurfaceAction;IfcStructuralPlanarAction;IfcStructuralReaction;IfcStructuralCurveReaction;IfcStructuralPointReaction;IfcStructuralSurfaceReaction;IfcStructuralItem;IfcStructuralConnection;IfcStructuralCurveConnection;IfcStructuralPointConnection;IfcStructuralSurfaceConnection;IfcStructuralMember;IfcStructuralCurveMember;IfcStructuralCurveMemberVarying;IfcStructuralSurfaceMember;IfcStructuralSurfaceMemberVarying;IfcElementType;IfcBuiltElementType;IfcBeamType;IfcBearingType;IfcChimneyType;IfcColumnType;IfcCourseType;IfcCoveringType;IfcCurtainWallType;IfcDeepFoundationType;IfcCaissonFoundationType;IfcPileType;IfcDoorType;IfcFootingType;IfcKerbType;IfcMemberType;IfcMooringDeviceType;IfcNavigationElementType;IfcPavementType;IfcPlateType;IfcRailType;IfcRailingType;IfcRampFlightType;IfcRampType;IfcRoofType;IfcShadingDeviceType;IfcSlabType;IfcStairFlightType;IfcStairType;IfcTrackElementType;IfcWallType;IfcWindowType;IfcCivilElementType;IfcDistributionElementType;IfcDistributionControlElementType;IfcActuatorType;IfcAlarmType;IfcControllerType;IfcFlowInstrumentType;IfcProtectiveDeviceTrippingUnitType;IfcSensorType;IfcUnitaryControlElementType;IfcDistributionFlowElementType;IfcDistributionChamberElementType;IfcEnergyConversionDeviceType;IfcAirToAirHeatRecoveryType;IfcBoilerType;IfcBurnerType;IfcChillerType;IfcCoilType;IfcCondenserType;IfcCooledBeamType;IfcCoolingTowerType;IfcElectricGeneratorType;IfcElectricMotorType;IfcEngineType;IfcEvaporativeCoolerType;IfcEvaporatorType;IfcHeatExchangerType;IfcHumidifierType;IfcMotorConnectionType;IfcSolarDeviceType;IfcTransformerType;IfcTubeBundleType;IfcUnitaryEquipmentType;IfcFlowControllerType;IfcAirTerminalBoxType;IfcDamperType;IfcDistributionBoardType;IfcElectricDistributionBoardType;IfcElectricTimeControlType;IfcFlowMeterType;IfcProtectiveDeviceType;IfcSwitchingDeviceType;IfcValveType;IfcFlowFittingType;IfcCableCarrierFittingType;IfcCableFittingType;IfcDuctFittingType;IfcJunctionBoxType;IfcPipeFittingType;IfcFlowMovingDeviceType;IfcCompressorType;IfcFanType;IfcPumpType;IfcFlowSegmentType;IfcCableCarrierSegmentType;IfcCableSegmentType;IfcConveyorSegmentType;IfcDuctSegmentType;IfcPipeSegmentType;IfcFlowStorageDeviceType;IfcElectricFlowStorageDeviceType;IfcTankType;IfcFlowTerminalType;IfcAirTerminalType;IfcAudioVisualApplianceType;IfcCommunicationsApplianceType;IfcElectricApplianceType;IfcFireSuppressionTerminalType;IfcLampType;IfcLightFixtureType;IfcLiquidTerminalType;IfcMedicalDeviceType;IfcMobileTelecommunicationsApplianceType;IfcOutletType;IfcSanitaryTerminalType;IfcSignalType;IfcSpaceHeaterType;IfcStackTerminalType;IfcWasteTerminalType;IfcFlowTreatmentDeviceType;IfcDuctSilencerType;IfcElectricFlowTreatmentDeviceType;IfcFilterType;IfcInterceptorType;IfcElementAssemblyType;IfcElementComponentType;IfcBuildingElementPartType;IfcDiscreteAccessoryType;IfcFastenerType;IfcImpactProtectionDeviceType;IfcMechanicalFastenerType;IfcReinforcingElementType;IfcReinforcingBarType;IfcReinforcingMeshType;IfcTendonAnchorType;IfcTendonConduitType;IfcTendonType;IfcSignType;IfcVibrationDamperType;IfcVibrationIsolatorType;IfcFurnishingElementType;IfcFurnitureType;IfcSystemFurnitureElementType;IfcGeographicElementType;IfcTransportationDeviceType;IfcTransportElementType;IfcVehicleType;IfcSpatialElementType;IfcSpatialStructureElementType;IfcSpaceType;IfcSpatialZoneType;], CoordinateReference [CoordinateBase: Survey Point, ProjectSite: Default Site]
File name: Pyrevit_project_workflow.ifc
Time: 2025-11-14T13:18:15+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk Revit 26.0.4.409 (ENU) - IFC 26.0.4.409

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcBuilding, Building Name
LongName: Building Name
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 2
Pset_SpaceCommon - IsExternal: no; Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here Address Line 2; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status
Identity Data - Building Name: Building Name; Organization Description: Organization Description; Organization Name: Organization Name

# IfcBuildingStorey: Level:8mm Head (2)
In: Building Name
Pset_BuildingStoreyCommon - Reference: Level:8mm Head
Pset_SpaceCommon - IsExternal: no; Reference: Level:8mm Head
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 1439238
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Extents - Scope Box: Grids and Levels
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
L1 | L1 | 0
L2 | L2 | 3600

# IfcBuildingElementProxy: DPP_HempBlock_Material, DPP_HempBlock_Material:DPP_HempBlock_Material:1664827
In: L1
Type - PredefinedType: USERDEFINED; Material: Hemp-Lime
Type - Other - Category: Generic Models; Family Name: DPP_HempBlock_Material
Type - Constraints - Default Elevation: 0 mm
Type - Construction - DPP_CIR_DeconstructabilityScore: 0.5; DPP_CIR_DisassemblyInstructions: Mechanical dismantling: Crushing and Sieving for Recycling; DPP_CIR_Disassemblypotential: 3; DPP_CIR_EndofLifeRecomendations: Composting and soil improvement; Disposal via incineration; DPP_CIR_Prefabrication: yes; DPP_CIR_PrefabricationFactor: 1; DPP_CIR_RecoveryScore: 0.5; DPP_CIR_RecyclingPotential: 100; DPP_CIR_Reusability: yes; DPP_CIR_ReusabilityPotential: 1; DPP_CIR_SecondaryUse: Reused on the construction site for applications requiring increased density, such as floor material
Type - Dimensions - DPP_DIM_Height_mm: 200 mm; DPP_DIM_Length_mm: 80 mm; DPP_DIM_Width_mm: 500 mm
Type - Fire Protection - DPP_SAD_Fire_Class: B (Very limited contribution to fire); DPP_SAD_Fire_Dsubclass: d0 (No flaming droplets or particles); DPP_SAD_Fire_Ssubclass: s1 (Little or no smoke); DPP_SAD_FireResistance: B - s1; d1
Type - Graphics - DPP_ASD_Aesthetic: 5; DPP_ASD_Aging: 4; DPP_ASD_Architectural: 4; DPP_ASD_Color: Natural Beige #D8C9A7; DPP_ASD_Odor: Mild, earthy, lime - fresh scent; DPP_ASD_Temp: Feels thermally neutral or slightly warm; DPP_ASD_Texture: Porous, fibrous, and dry to the touch
Type - Green Building Properties - DPP_ASD_AgriculturalValue: High; DPP_ASD_ClimateSuitability: Varied; DPP_ASD_ResourseAvailability: Regional
Type - Identity Data - Cost: 3.8; Description: Made from 20–55% hemp shives and 45–80% lime-based mineral binder, entirely free of cement and petrochemical additives; DPP_AUT_Manufacturer: Schönthaler Bausteinwerk GmbH; DPP_AUT_Origin: 39021 Oris (BZ); DPP_DAT_StandarCompliance: yes; DPP_END_EPD: yes; DPP_END_EPD_URL: https://www.bau-epd.at/epd/data/schoenthaler-bausteinwerk-gmbh-hanfsteine-ecoinvent-2025; DPP_SAD_Compliance: yes; DPP_SAD_HPD: NO; DPP_TMP_ServiceLife_years: 100; DPP_TMP_Soursing_km: 5000 mm; DPP_TMP_UpdateHistory: 14/11/2025 12:47 p.m.; DPP_TMP_Warranty: yes; Keynote: HKZ 335; Manufacturer: Schönthaler Bausteinwerk GmbH; Model: Hempstone; Type Comments: 8x50x20; Type Name: DPP_HempBlock_Material; URL: https://www.hanfstein.eu/en/
Type - Life Safety - DPP_SAD_Toxicity: yes
Type - Materials and Finishes - DPP_AUT_MaterialType: Type II; DPP_MAT_Composition: Made from 20–55% hemp shives and 45–80% lime-based mineral binder, entirely free of cement and petrochemical additives; DPP_MAT_Material: Hemp-Lime; DPP_SAD_Coatings: yes; DPP_SAD_CoatingType: Breathable, vapor-permeable coatings, including lime-based plaster and
Type - Structural - DPP_DAT_CompressiveStrenght_Mpa: 0.5; DPP_DAT_ShearStrenght_Mpa: 0.12; DPP_DAT_VaporAbsorption: 19; DPP_DAT_VaporDiffμ_dry: 4.3; DPP_DAT_VaporDiffμ_wet: 3.8
Type - Text - DPP_ASD_ComfortMaterial: Non-toxic, breathable, natural aesthetics, supports psychological well-being
Type - Pset_ManufacturerTypeInformation - Manufacturer: Schönthaler Bausteinwerk GmbH
Pset_BuildingElementProxyCommon - Reference: DPP_HempBlock_Material:DPP_HempBlock_Material; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: DPP_HempBlock_Material:DPP_HempBlock_Material
Other - Family: DPP_HempBlock_Material; Family and Type: DPP_HempBlock_Material: DPP_HempBlock_Material; Type: DPP_HempBlock_Material; Type Id: 1664811
Constraints - Elevation from Level: 0 mm; Host: Level : L1; Level: L1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Construction - DPP_COD_Replacement_EUR: 3.4; DPP_COD_UnitCost_EUR: 3.8
Data - DPP_DAT_DryDensity_kgm3: 335 kg/m3; DPP_DAT_EqDensity_kgm3: 405 kg/m3; DPP_DAT_Weight_kg: 2.67; DPP_DIM_Volume_m3: 0.008 m3
Dimensions - Area: 0.16 m2; Volume: 0.008 m3
Green Building Properties - DPP_CIR_CircularityIndex: 0.7; DPP_COD_CircularBenefit_EUR: 0.4 1/m2; DPP_END_AP_kgSO₂eq: 0.000249; DPP_END_BiogenicCarbon_kgCO₂eq: 0.4488; DPP_END_Ei: 0.992; DPP_END_EmbodiedCarbon_kgCO₂eq: -1.744; DPP_END_EndoflifeEmissions_kgCO₂eq: 1.7772; DPP_END_EnvironmentalScore: 0.744; DPP_END_GWP_kgCO₂eq: 1.3392; DPP_END_PENRT_MJKg: 17.03; DPP_END_PERT_MJKg: 18.41; DPP_END_w: 0.75
Identity Data - DPP_AUT_ID: Z - 17.25 - 1299; DPP_AUT_Name: Hempstone; DPP_AUT_Version: HKZ 335
Life Safety - DPP_SAD_HRP-c_CTUh: 0; DPP_SAD_HRP-nc_CTUh: 0; DPP_SAD_IRP_kBqU-235eq: 0.0162; DPP_SAD_PM_CTUh: 2.27e-07 kg/m3; DPP_SAD_SQP: 62.72
Materials and Finishes - DPP_AUT_TypeDimension: 8x50x20
Phasing - Phase Created: New Construction

# Material: Hemp-Lime
Identity - Class: Concrete
Structural - Name: Hemp-Lime; Description: Bio-based hemp–lime masonry brick composed of hemp shives, natural lime, and mineral binders. Cold-pressed; CO₂-negative; high thermal insulation and vapor permeability.; Type: Concrete; SubClass: Light-weight; Source: Schönthaler Baustoffe GmbH; Source URL: https://www.hanfstein.eu/en/; Behavior: Isotropic; TensileStrength: 60000 Pa; ConcreteCompression: 320000 Pa; ShearStrengthModification: 1; ThermallyTreated: yes
Thermal - Name: Hemp-Lime; Description: Bio-based hemp–lime masonry brick composed of hemp shives, natural lime, and mineral binders. Cold-pressed; CO₂-negative; high thermal insulation and vapor permeability.; Type: Solid; SubClass: Light-weight Concrete; Source: Schönthaler Baustoffe GmbH; Source URL: https://www.hanfstein.eu/en/; Density: 300 kg/m3; Emissivity: 0.95; Behavior: Isotropic; TransmitsLight: no; Permeability: 0 s/m; Reflectivity: 0; ElectricalResistivity: 2000000 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.75; MassDensity: 299.94 kg/m3
Pset_MaterialMechanical - YoungModulus: 319600000 kg/m/s2; ShearModulus: 150000 kg/m/s2; PoissonRatio: 0.19; ThermalExpansionCoefficient: 0.00001 1/K
Pset_MaterialSteel - YieldStress: 250000 Pa
Pset_MaterialThermal - SpecificHeatCapacity: 1499.7 m2/s2/K; ThermalConductivity: 0.07
Other - Category: Materials
Identity Data - Comments: Non-load-bearing bio-based material; Cost: 0; Description: Bio-based hemp–lime masonry brick composed of hemp shives, natural lime, and mineral binders. Cold-pressed; CO₂-negative; high thermal insulation and vapor permeability.; Keynote: HB-01; Manufacturer: Schönthaler Baustoffe GmbH; Mark: Hemp-Lime Block 300 kg/m³; Model: Hanfziegel Hemp Brick; URL: https://www.hanfstein.eu/en/
Materials and Finishes - Color: 7895160; Glow: no; Material Type: Concrete; Name: Hemp-Lime; Shininess: 64; Smoothness: 50; Transparency: 0
