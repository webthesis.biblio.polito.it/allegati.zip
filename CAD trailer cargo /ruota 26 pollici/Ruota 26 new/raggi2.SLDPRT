ISO-10303-21;
HEADER;
FILE_DESCRIPTION(('STEP AP214'),'2;1');
FILE_NAME('part.step','',(''),(''),'','','');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
ENDSEC;
DATA;
#1=APPLICATION_CONTEXT('core data for automotive mechanical design processes');
#2=APPLICATION_PROTOCOL_DEFINITION('international standard','automotive_design',2000,#1);
#3=PRODUCT_CONTEXT('',#1,'mechanical');
#4=PRODUCT('Part','Part','',(#3));
#5=PRODUCT_RELATED_PRODUCT_CATEGORY('part','',(#4));
#6=PRODUCT_DEFINITION_FORMATION('','',#4);
#7=PRODUCT_DEFINITION_CONTEXT('part definition',#1,'design');
#8=PRODUCT_DEFINITION('design','',#6,#7);
#9=PRODUCT_DEFINITION_SHAPE('','',#8);
#10=(LENGTH_UNIT() NAMED_UNIT(*) SI_UNIT(.MILLI.,.METRE.));
#11=(NAMED_UNIT(*) PLANE_ANGLE_UNIT() SI_UNIT($,.RADIAN.));
#12=(NAMED_UNIT(*) SI_UNIT($,.STERADIAN.) SOLID_ANGLE_UNIT());
#13=UNCERTAINTY_MEASURE_WITH_UNIT(LENGTH_MEASURE(1.E-05),#10,'distance_accuracy_value','');
#14=(GEOMETRIC_REPRESENTATION_CONTEXT(3) GLOBAL_UNCERTAINTY_ASSIGNED_CONTEXT((#13)) GLOBAL_UNIT_ASSIGNED_CONTEXT((#10,
#11,#12)) REPRESENTATION_CONTEXT('',''));
#15=CARTESIAN_POINT('',(0.,0.,0.));
#16=DIRECTION('',(0.,0.,1.));
#17=DIRECTION('',(1.,0.,0.));
#18=AXIS2_PLACEMENT_3D('',#15,#16,#17);
#19=CARTESIAN_POINT('',(-28.3053863085677,-0.00395858755156825,279.551912479944));
#20=DIRECTION('',(0.,0.,1.));
#21=DIRECTION('',(1.,0.,0.));
#22=AXIS2_PLACEMENT_3D('',#19,#20,#21);
#23=CIRCLE('',#22,0.749999999999999);
#24=DIRECTION('',(-0.135758314376061,0.,-0.990741984614446));
#25=VECTOR('',#24,1.);
#26=SURFACE_OF_LINEAR_EXTRUSION('',#23,#25);
#27=CARTESIAN_POINT('',(-65.6523331351406,-0.00395858755156825,7.));
#28=DIRECTION('',(0.,0.,1.));
#29=DIRECTION('',(1.,0.,0.));
#30=AXIS2_PLACEMENT_3D('',#27,#28,#29);
#31=CIRCLE('',#30,0.749999999999999);
#32=CARTESIAN_POINT('',(-64.9023331351406,-0.00395858755156825,7.));
#33=VERTEX_POINT('',#32);
#34=EDGE_CURVE('E52',#33,#33,#31,.T.);
#35=ORIENTED_EDGE('',*,*,#34,.T.);
#36=EDGE_LOOP('',(#35));
#37=FACE_BOUND('',#36,.T.);
#38=CARTESIAN_POINT('',(-27.8664584283285,-0.00395858755156825,277.281759003846));
#39=CARTESIAN_POINT('',(-27.8664602636268,0.0377467092451307,277.281759429202));
#40=CARTESIAN_POINT('',(-27.86984170287,0.0794911244247894,277.282543123587));
#41=CARTESIAN_POINT('',(-27.8832817228611,0.161810896038601,277.285658030423));
#42=CARTESIAN_POINT('',(-27.8933403359233,0.202386246814041,277.287989250363));
#43=CARTESIAN_POINT('',(-27.9198461553965,0.281222287939922,277.294132333358));
#44=CARTESIAN_POINT('',(-27.9362850343641,0.319485920592493,277.297942266417));
#45=CARTESIAN_POINT('',(-27.9750696819752,0.392610421163306,277.306931134294));
#46=CARTESIAN_POINT('',(-27.9974028356845,0.427478340971253,277.312107145431));
#47=CARTESIAN_POINT('',(-28.0473279430766,0.492854402220567,277.323677965892));
#48=CARTESIAN_POINT('',(-28.0749068805611,0.523373014328829,277.330069758534));
#49=CARTESIAN_POINT('',(-28.1345358450704,0.579227280213594,277.343889579434));
#50=CARTESIAN_POINT('',(-28.16657448853,0.604575737174883,277.351314969396));
#51=CARTESIAN_POINT('',(-28.2342237374108,0.649421493832539,277.366993599928));
#52=CARTESIAN_POINT('',(-28.2698259917047,0.668932064870232,277.375244905011));
#53=CARTESIAN_POINT('',(-28.3436205241846,0.701599137014949,277.392347788327));
#54=CARTESIAN_POINT('',(-28.3818079559823,0.714767171665851,277.401198243344));
#55=CARTESIAN_POINT('',(-28.4597350877428,0.734417439453973,277.419258912568));
#56=CARTESIAN_POINT('',(-28.499472932444,0.740907423564212,277.428468696793));
#57=CARTESIAN_POINT('',(-28.5794321755081,0.747042996881259,277.447000335361));
#58=CARTESIAN_POINT('',(-28.6196533881367,0.746691136012128,277.456322146656));
#59=CARTESIAN_POINT('',(-28.699484176744,0.739159283268459,277.474824014162));
#60=CARTESIAN_POINT('',(-28.7390937540933,0.731979306696002,277.48400407069));
#61=CARTESIAN_POINT('',(-28.8166103033965,0.710995157707532,277.501969581863));
#62=CARTESIAN_POINT('',(-28.8545172886113,0.697191036894374,277.510755039582));
#63=CARTESIAN_POINT('',(-28.9275899375518,0.663348777190905,277.527690616601));
#64=CARTESIAN_POINT('',(-28.9627556353807,0.643310715870046,277.535840743806));
#65=CARTESIAN_POINT('',(-29.0293896253324,0.59756266127577,277.551284074317));
#66=CARTESIAN_POINT('',(-29.0608579754329,0.57185275696002,277.558577291062));
#67=CARTESIAN_POINT('',(-29.1192499582476,0.515475419965406,277.572110424684));
#68=CARTESIAN_POINT('',(-29.1461736690189,0.484808072451577,277.578350359654));
#69=CARTESIAN_POINT('',(-29.1947590008484,0.419359316436216,277.589610668964));
#70=CARTESIAN_POINT('',(-29.2164207103172,0.384577977071496,277.594631063796));
#71=CARTESIAN_POINT('',(-29.253910718515,0.311848398087972,277.603319881438));
#72=CARTESIAN_POINT('',(-29.2697391026633,0.273900204852446,277.606988324046));
#73=CARTESIAN_POINT('',(-29.2951486404434,0.195861524236883,277.612877328897));
#74=CARTESIAN_POINT('',(-29.3047298625731,0.155771060351296,277.615097907016));
#75=CARTESIAN_POINT('',(-29.3173961982845,0.0745235587476138,277.618033502032));
#76=CARTESIAN_POINT('',(-29.3204813519395,0.0333665276105877,277.618748528216));
#77=CARTESIAN_POINT('',(-29.3200757153301,-0.0489133526483889,277.618654516432));
#78=CARTESIAN_POINT('',(-29.3165849300143,-0.090036201796039,277.617845479612));
#79=CARTESIAN_POINT('',(-29.3031178698832,-0.171147781835682,277.614724305857));
#80=CARTESIAN_POINT('',(-29.2931415643324,-0.211136507352049,277.612412161799));
#81=CARTESIAN_POINT('',(-29.2669627718709,-0.288906581561217,277.606344871747));
#82=CARTESIAN_POINT('',(-29.2507602242233,-0.326687908716775,277.602589711676));
#83=CARTESIAN_POINT('',(-29.2125528021495,-0.399022687207394,277.593734623642));
#84=CARTESIAN_POINT('',(-29.1905478477598,-0.433576094049352,277.588634677146));
#85=CARTESIAN_POINT('',(-29.1413163366098,-0.498513611696684,277.577224607018));
#86=CARTESIAN_POINT('',(-29.1140896942952,-0.528897654175577,277.570914463557));
#87=CARTESIAN_POINT('',(-29.0551406825992,-0.584660300223286,277.55725223094));
#88=CARTESIAN_POINT('',(-29.0234182356261,-0.61003881738533,277.5499001238));
#89=CARTESIAN_POINT('',(-28.9563322365837,-0.65508480711343,277.534352034054));
#90=CARTESIAN_POINT('',(-28.9209686252818,-0.674752186754021,277.526156037719));
#91=CARTESIAN_POINT('',(-28.8475622036481,-0.707823895548687,277.509143104353));
#92=CARTESIAN_POINT('',(-28.8095193572106,-0.721228140281306,277.500326158954));
#93=CARTESIAN_POINT('',(-28.7317972524086,-0.741394485921767,277.482313007507));
#94=CARTESIAN_POINT('',(-28.6921179790499,-0.748156525954008,277.473116797985));
#95=CARTESIAN_POINT('',(-28.6122161339731,-0.754846249587528,277.454598462179));
#96=CARTESIAN_POINT('',(-28.5719935607648,-0.754773914438916,277.445276335551));
#97=CARTESIAN_POINT('',(-28.4921150076848,-0.747796907560464,277.426763397981));
#98=CARTESIAN_POINT('',(-28.4524590266771,-0.740892249529823,277.417572586776));
#99=CARTESIAN_POINT('',(-28.3748060489925,-0.720446729544343,277.399575456476));
#100=CARTESIAN_POINT('',(-28.3368090397467,-0.706905917875975,277.390769134467));
#101=CARTESIAN_POINT('',(-28.2635154687036,-0.673570954755792,277.373782355756));
#102=CARTESIAN_POINT('',(-28.2282188737565,-0.653776880082929,277.36560189137));
#103=CARTESIAN_POINT('',(-28.1612861096615,-0.608490710450785,277.3500893159));
#104=CARTESIAN_POINT('',(-28.12964988348,-0.582998704291436,277.342757191598));
#105=CARTESIAN_POINT('',(-28.0708900773771,-0.527025745304793,277.329138809942));
#106=CARTESIAN_POINT('',(-28.0437664200602,-0.49654487805978,277.32285253465));
#107=CARTESIAN_POINT('',(-27.9947546322789,-0.431431252354936,277.311493388391));
#108=CARTESIAN_POINT('',(-27.9728664135818,-0.39679856388042,277.306420496975));
#109=CARTESIAN_POINT('',(-27.9349035013984,-0.324330861203666,277.297622077423));
#110=CARTESIAN_POINT('',(-27.9188287220873,-0.286495894287412,277.293896529396));
#111=CARTESIAN_POINT('',(-27.8930251698947,-0.208964890524322,277.287916206363));
#112=CARTESIAN_POINT('',(-27.8832418093064,-0.169288155898581,277.285648779916));
#113=CARTESIAN_POINT('',(-27.8732691986172,-0.108499861864205,277.283337492193));
#114=CARTESIAN_POINT('',(-27.8707278940475,-0.0877680815360289,277.282748510407));
#115=CARTESIAN_POINT('',(-27.8673161460629,-0.0460143898196295,277.281957791559));
#116=CARTESIAN_POINT('',(-27.8664575027482,-0.0249914633728356,277.281758789331));
#117=CARTESIAN_POINT('',(-27.8664584283285,-0.00395858755156825,277.281759003846));
#118=B_SPLINE_CURVE_WITH_KNOTS('',3,(#38,#39,#40,#41,#42,#43,#44,#45,#46,#47,#48,#49,#50,#51,
#52,#53,#54,#55,#56,#57,#58,#59,#60,#61,#62,#63,#64,#65,#66,#67,#68,#69,#70,#71,#72,#73,#74,#75,
#76,#77,#78,#79,#80,#81,#82,#83,#84,#85,#86,#87,#88,#89,#90,#91,#92,#93,#94,#95,#96,#97,#98,#99,
#100,#101,#102,#103,#104,#105,#106,#107,#108,#109,#110,#111,#112,#113,#114,#115,#116,#117),
.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,4),(0.,0.125040337552024,0.250081280244792,0.374959566927609,0.499572726243791,
0.623880627805474,0.747876856855175,0.871589023819444,0.995075369833007,1.11841822746384,
1.24171511666201,1.36501172954755,1.48830738195372,1.61160150024297,1.73489368491427,
1.85818375174633,1.98147174694778,2.10475793673027,2.22804277470088,2.35132685214464,
2.47461083681407,2.59789540573897,2.72118117733153,2.8444686480235,2.9677581388779,
3.09104975780361,3.21434338268505,3.33763866940633,3.46093508611458,3.58423184108267,
3.70752834883421,3.83082392230202,3.95411798197822,4.07741012030085,4.20070014380878,
4.32398808936639,4.44727421472779,4.56947567267876,4.63209858737925,4.69515911192608),.UNSPECIFIED.);
#119=CARTESIAN_POINT('',(-27.8664584283285,-0.00395858755156825,277.281759003846));
#120=VERTEX_POINT('',#119);
#121=EDGE_CURVE('E12',#120,#120,#118,.T.);
#122=ORIENTED_EDGE('',*,*,#121,.F.);
#123=EDGE_LOOP('',(#122));
#124=FACE_BOUND('',#123,.T.);
#125=ADVANCED_FACE('F40',(#37,#124),#26,.F.);
#126=CARTESIAN_POINT('',(-65.6523331351406,-0.00395858755156825,7.));
#127=DIRECTION('',(0.,0.,1.));
#128=DIRECTION('',(1.,0.,0.));
#129=AXIS2_PLACEMENT_3D('',#126,#127,#128);
#130=PLANE('',#129);
#131=ORIENTED_EDGE('',*,*,#34,.F.);
#132=EDGE_LOOP('',(#131));
#133=FACE_BOUND('',#132,.T.);
#134=ADVANCED_FACE('F87',(#133),#130,.F.);
#135=CARTESIAN_POINT('',(-27.8664584283285,-0.00399458570124803,277.281759003846));
#136=CARTESIAN_POINT('',(-27.8253418017632,-0.00399458570124803,277.406121194376));
#137=CARTESIAN_POINT('',(-27.7809592136758,-0.00399458570124803,277.660833678192));
#138=CARTESIAN_POINT('',(-27.7711737299627,-0.00399458570124803,278.150006963105));
#139=CARTESIAN_POINT('',(-27.8698626014705,-0.00399458570124802,278.626435490169));
#140=CARTESIAN_POINT('',(-28.0878911340868,-0.00399458570124803,279.109120659837));
#141=CARTESIAN_POINT('',(-28.4232703934228,-0.00399458570124803,279.511665097591));
#142=CARTESIAN_POINT('',(-28.7568865116009,-0.00399458570124802,279.805173152615));
#143=CARTESIAN_POINT('',(-29.175983260833,-0.00399458570124803,280.000852629512));
#144=CARTESIAN_POINT('',(-29.3680957747491,-0.00399458570124803,280.071356828596));
#145=CARTESIAN_POINT('',(-27.8664584283285,0.037721524965773,277.281759003846));
#146=CARTESIAN_POINT('',(-27.8253417820268,0.037721524965773,277.406121254071));
#147=CARTESIAN_POINT('',(-27.7809592233529,0.037721524965773,277.660833648506));
#148=CARTESIAN_POINT('',(-27.7711737276347,0.037721524965773,278.150006971731));
#149=CARTESIAN_POINT('',(-27.869862600436,0.037721524965773,278.626435487165));
#150=CARTESIAN_POINT('',(-28.0878911408366,0.037721524965773,279.109120663048));
#151=CARTESIAN_POINT('',(-28.4232703669445,0.037721524965773,279.51166508768));
#152=CARTESIAN_POINT('',(-28.7568866056012,0.037721524965773,279.805173187165));
#153=CARTESIAN_POINT('',(-29.1759830655629,0.037721524965773,280.000852557849));
#154=CARTESIAN_POINT('',(-29.3680957747491,0.037721524965773,280.071356828596));
#155=CARTESIAN_POINT('',(-27.8698489250926,0.0795443413324496,277.282544797435));
#156=CARTESIAN_POINT('',(-27.8287758746549,0.0795443413324496,277.406775186718));
#157=CARTESIAN_POINT('',(-27.7844010690789,0.0795443413324496,277.661266893893));
#158=CARTESIAN_POINT('',(-27.7746553519086,0.0795443413324496,278.149647519139));
#159=CARTESIAN_POINT('',(-27.8731899343767,0.0795443413324495,278.625378775225));
#160=CARTESIAN_POINT('',(-28.0908699066598,0.0795443413324496,279.107260136548));
#161=CARTESIAN_POINT('',(-28.4256865170467,0.0795443413324496,279.509179124747));
#162=CARTESIAN_POINT('',(-28.7589918351134,0.0795443413324495,279.802322413323));
#163=CARTESIAN_POINT('',(-29.1770298799147,0.0795443413324496,279.997544923079));
#164=CARTESIAN_POINT('',(-29.3687116539797,0.0795443413324496,280.06789104309));
#165=CARTESIAN_POINT('',(-27.8832745006035,0.161757678873394,277.285656356567));
#166=CARTESIAN_POINT('',(-27.842374621749,0.161757678873394,277.409362967533));
#167=CARTESIAN_POINT('',(-27.7980297086767,0.161757678873394,277.662983259891));
#168=CARTESIAN_POINT('',(-27.7884418350032,0.161757678873394,278.148223933852));
#169=CARTESIAN_POINT('',(-27.8863654283725,0.161757678873394,278.621194525236));
#170=CARTESIAN_POINT('',(-28.1026649379887,0.161757678873394,279.099892797673));
#171=CARTESIAN_POINT('',(-28.4352546360871,0.161757678873394,279.49933556478));
#172=CARTESIAN_POINT('',(-28.7673254651139,0.161757678873394,279.791033063592));
#173=CARTESIAN_POINT('',(-29.1811803950054,0.161757678873394,279.984449434199));
#174=CARTESIAN_POINT('',(-29.3711503919263,0.161757678873394,280.054167341741));
#175=CARTESIAN_POINT('',(-27.8933556967179,0.202429887990013,277.287992810435));
#176=CARTESIAN_POINT('',(-27.8525853943313,0.202429887990013,277.411307501764));
#177=CARTESIAN_POINT('',(-27.8082636087488,0.202429887990013,277.664271382706));
#178=CARTESIAN_POINT('',(-27.7987939808321,0.202429887990013,278.147155170737));
#179=CARTESIAN_POINT('',(-27.8962588156646,0.202429887990013,278.61805252372));
#180=CARTESIAN_POINT('',(-28.1115219228686,0.202429887990013,279.094360774814));
#181=CARTESIAN_POINT('',(-28.442438675565,0.202429887990013,279.49194385667));
#182=CARTESIAN_POINT('',(-28.7735853189382,0.202429887990013,279.782556747424));
#183=CARTESIAN_POINT('',(-29.1842924803039,0.202429887990013,279.974614441362));
#184=CARTESIAN_POINT('',(-29.3729816278009,0.202429887990013,280.043862284457));
#185=CARTESIAN_POINT('',(-27.9198308145834,0.281178703533352,277.294128777917));
#186=CARTESIAN_POINT('',(-27.8794019702477,0.281178703533352,277.416410688234));
#187=CARTESIAN_POINT('',(-27.8351391843267,0.281178703533352,277.667655989162));
#188=CARTESIAN_POINT('',(-27.82598080105,0.281178703533352,278.144347888117));
#189=CARTESIAN_POINT('',(-27.922240773723,0.281178703533352,278.609801214138));
#190=CARTESIAN_POINT('',(-28.1347816314707,0.281178703533352,279.079832451615));
#191=CARTESIAN_POINT('',(-28.4613068847925,0.281178703533352,279.472532427905));
#192=CARTESIAN_POINT('',(-28.7900192999916,0.281178703533352,279.760294297936));
#193=CARTESIAN_POINT('',(-29.1924769787152,0.281178703533352,279.948790148268));
#194=CARTESIAN_POINT('',(-29.3777907977711,0.281178703533352,280.016799265037));
#195=CARTESIAN_POINT('',(-27.9363072908579,0.319528344927461,277.297947424661));
#196=CARTESIAN_POINT('',(-27.896090220675,0.319528344927461,277.419588798539));
#197=CARTESIAN_POINT('',(-27.8518652377935,0.319528344927461,277.669761263629));
#198=CARTESIAN_POINT('',(-27.8429001108996,0.319528344927461,278.142601127252));
#199=CARTESIAN_POINT('',(-27.9384102999004,0.319528344927461,278.60466599852));
#200=CARTESIAN_POINT('',(-28.1492572839554,0.319528344927461,279.070791039773));
#201=CARTESIAN_POINT('',(-28.4730483180899,0.319528344927461,279.460451590565));
#202=CARTESIAN_POINT('',(-28.8002502493282,0.319528344927461,279.746440796136));
#203=CARTESIAN_POINT('',(-29.1975633257434,0.319528344927461,279.932716070547));
#204=CARTESIAN_POINT('',(-29.3807837277863,0.319528344927461,279.999956915189));
#205=CARTESIAN_POINT('',(-27.9750474727339,0.392568086898858,277.306925987002));
#206=CARTESIAN_POINT('',(-27.9353300226995,0.392568086898858,277.427056199549));
#207=CARTESIAN_POINT('',(-27.8911914084947,0.392568086898858,277.674713811966));
#208=CARTESIAN_POINT('',(-27.8826817005271,0.392568086898858,278.138493332091));
#209=CARTESIAN_POINT('',(-27.9764288571366,0.392568086898858,278.592592121453));
#210=CARTESIAN_POINT('',(-28.1832924646141,0.392568086898858,279.049532217306));
#211=CARTESIAN_POINT('',(-28.500657544954,0.392568086898858,279.432047471306));
#212=CARTESIAN_POINT('',(-28.8242976044427,0.392568086898858,279.713864891309));
#213=CARTESIAN_POINT('',(-29.2095393470489,0.392568086898858,279.894928186454));
#214=CARTESIAN_POINT('',(-29.3878208303316,0.392568086898858,279.960356476024));
#215=CARTESIAN_POINT('',(-27.9974315360429,0.427515762884698,277.312113797129));
#216=CARTESIAN_POINT('',(-27.9580017691677,0.427515762884698,277.431373877303));
#217=CARTESIAN_POINT('',(-27.9139145449045,0.427515762884698,277.677573892794));
#218=CARTESIAN_POINT('',(-27.9056673711155,0.427515762884699,278.136120285287));
#219=CARTESIAN_POINT('',(-27.9983959142018,0.427515762884698,278.585615687976));
#220=CARTESIAN_POINT('',(-28.2029583190557,0.427515762884698,279.037249038832));
#221=CARTESIAN_POINT('',(-28.5166088157168,0.427515762884698,279.415635083161));
#222=CARTESIAN_POINT('',(-28.838196881819,0.427515762884698,279.695044281471));
#223=CARTESIAN_POINT('',(-29.2164492742619,0.427515762884698,279.873090758916));
#224=CARTESIAN_POINT('',(-29.3918868656794,0.427515762884698,279.937475356359));
#225=CARTESIAN_POINT('',(-28.0472993130239,0.49281707197745,277.323671330489));
#226=CARTESIAN_POINT('',(-28.0085126199912,0.49281707197745,277.440986356353));
#227=CARTESIAN_POINT('',(-27.9645366554596,0.49281707197745,277.683948910534));
#228=CARTESIAN_POINT('',(-27.9568756790211,0.49281707197745,278.13083260534));
#229=CARTESIAN_POINT('',(-28.047334789106,0.49281707197745,278.570073744899));
#230=CARTESIAN_POINT('',(-28.2467696562702,0.49281707197745,279.009883911738));
#231=CARTESIAN_POINT('',(-28.5521483820162,0.49281707197745,279.379072248668));
#232=CARTESIAN_POINT('',(-28.8691516538058,0.49281707197745,279.653111437915));
#233=CARTESIAN_POINT('',(-29.2318649590919,0.49281707197745,279.824448709027));
#234=CARTESIAN_POINT('',(-29.400945281085,0.49281707197745,279.886500224777));
#235=CARTESIAN_POINT('',(-28.0749411369335,0.523405107216007,277.330077697913));
#236=CARTESIAN_POINT('',(-28.0365096666107,0.523405107216007,277.446318309896));
#237=CARTESIAN_POINT('',(-27.9925972136065,0.523405107216007,277.687480740652));
#238=CARTESIAN_POINT('',(-27.9852604164907,0.523405107216007,278.127902171655));
#239=CARTESIAN_POINT('',(-28.0744616565011,0.523405107216007,278.561458622335));
#240=CARTESIAN_POINT('',(-28.271054800917,0.523405107216007,278.994715558438));
#241=CARTESIAN_POINT('',(-28.5718464005461,0.523405107216007,279.358804769236));
#242=CARTESIAN_POINT('',(-28.8863157957745,0.523405107216007,279.629870112594));
#243=CARTESIAN_POINT('',(-29.240397776321,0.523405107216007,279.79748185593));
#244=CARTESIAN_POINT('',(-29.4059663816574,0.523405107216007,279.858244591656));
#245=CARTESIAN_POINT('',(-28.1345016745877,0.5791952677917,277.343881659962));
#246=CARTESIAN_POINT('',(-28.0968381860733,0.5791952677917,277.457799418444));
#247=CARTESIAN_POINT('',(-28.0530587463591,0.5791952677917,277.695094736635));
#248=CARTESIAN_POINT('',(-28.0464220320008,0.5791952677917,278.121586766676));
#249=CARTESIAN_POINT('',(-28.1329127410699,0.5791952677917,278.54289579219));
#250=CARTESIAN_POINT('',(-28.3233817293881,0.5791952677917,278.962031502144));
#251=CARTESIAN_POINT('',(-28.6142937000664,0.5791952677917,279.315135220828));
#252=CARTESIAN_POINT('',(-28.9232874514367,0.5791952677917,279.579786899394));
#253=CARTESIAN_POINT('',(-29.2588093200677,0.5791952677917,279.739385114421));
#254=CARTESIAN_POINT('',(-29.416785474156,0.5791952677917,279.797361463756));
#255=CARTESIAN_POINT('',(-28.1666133408332,0.604601461708894,277.351323973944));
#256=CARTESIAN_POINT('',(-28.1293624645847,0.604601461708894,277.463993736918));
#257=CARTESIAN_POINT('',(-28.0856568842168,0.604601461708894,277.699197605881));
#258=CARTESIAN_POINT('',(-28.0793967385634,0.604601461708894,278.118182487504));
#259=CARTESIAN_POINT('',(-28.1644261786325,0.604601461708894,278.532887547441));
#260=CARTESIAN_POINT('',(-28.3515939320732,0.604601461708894,278.944410344281));
#261=CARTESIAN_POINT('',(-28.6371769613065,0.604601461708894,279.291590357723));
#262=CARTESIAN_POINT('',(-28.943227278075,0.604601461708894,279.552787370696));
#263=CARTESIAN_POINT('',(-29.2687216440291,0.604601461708894,279.708057455921));
#264=CARTESIAN_POINT('',(-29.4226185156475,0.604601461708894,279.764536731809));
#265=CARTESIAN_POINT('',(-28.234184974114,0.649395828230682,277.366984616008));
#266=CARTESIAN_POINT('',(-28.197805251637,0.649395828230682,277.47701946945));
#267=CARTESIAN_POINT('',(-28.1542507606975,0.649395828230682,277.707835523593));
#268=CARTESIAN_POINT('',(-28.1487847844088,0.649395828230682,278.111017692889));
#269=CARTESIAN_POINT('',(-28.2307391312574,0.649395828230682,278.5118279359));
#270=CARTESIAN_POINT('',(-28.4109590374687,0.649395828230682,278.907330185168));
#271=CARTESIAN_POINT('',(-28.6853334620193,0.649395828230682,279.242047066054));
#272=CARTESIAN_POINT('',(-28.985172122552,0.649395828230682,279.495967932285));
#273=CARTESIAN_POINT('',(-29.2896088243413,0.649395828230682,279.642146218506));
#274=CARTESIAN_POINT('',(-29.4348928130186,0.649395828230682,279.69546461538));
#275=CARTESIAN_POINT('',(-28.2698683527404,0.668950802730688,277.375254722756));
#276=CARTESIAN_POINT('',(-28.2339470641337,0.668950802730688,277.483902987727));
#277=CARTESIAN_POINT('',(-28.1904747557793,0.668950802730688,277.712394637452));
#278=CARTESIAN_POINT('',(-28.1854271883815,0.668950802730688,278.107234794406));
#279=CARTESIAN_POINT('',(-28.2657577399204,0.668950802730688,278.500706485158));
#280=CARTESIAN_POINT('',(-28.4423092397,0.668950802730688,278.887749072014));
#281=CARTESIAN_POINT('',(-28.7107619152109,0.668950802730688,279.21588333347));
#282=CARTESIAN_POINT('',(-29.0073300431335,0.668950802730688,279.465965387784));
#283=CARTESIAN_POINT('',(-29.3006231984273,0.668950802730688,279.607333876231));
#284=CARTESIAN_POINT('',(-29.4413746513166,0.668950802730688,279.658988858271));
#285=CARTESIAN_POINT('',(-28.3435782404736,0.701580433358093,277.392337988504));
#286=CARTESIAN_POINT('',(-28.3086070746809,0.701580433358093,277.498112492559));
#287=CARTESIAN_POINT('',(-28.2652998302405,0.701580433358093,277.721816978306));
#288=CARTESIAN_POINT('',(-28.2611184721125,0.701580433358093,278.099419217519));
#289=CARTESIAN_POINT('',(-28.3380946028131,0.701580433358093,278.477733779794));
#290=CARTESIAN_POINT('',(-28.5070671545375,0.701580433358093,278.847300546834));
#291=CARTESIAN_POINT('',(-28.7632928207065,0.701580433358093,279.16183943216));
#292=CARTESIAN_POINT('',(-29.0530857743786,0.701580433358093,279.403984647969));
#293=CARTESIAN_POINT('',(-29.3234065638041,0.701580433358093,279.535434767782));
#294=CARTESIAN_POINT('',(-29.4547639544501,0.701580433358093,279.58364218245));
#295=CARTESIAN_POINT('',(-28.3818526659733,0.714778435617899,277.40120860549));
#296=CARTESIAN_POINT('',(-28.3473731267478,0.714778435617899,277.505496125765));
#297=CARTESIAN_POINT('',(-28.3041541743078,0.714778435617899,277.726706996128));
#298=CARTESIAN_POINT('',(-28.3004215481517,0.714778435617899,278.095361676062));
#299=CARTESIAN_POINT('',(-28.3756559848179,0.714778435617899,278.465804762779));
#300=CARTESIAN_POINT('',(-28.540693787867,0.714778435617899,278.826297619831));
#301=CARTESIAN_POINT('',(-28.7905675878076,0.714778435617899,279.133775856762));
#302=CARTESIAN_POINT('',(-29.0768529871671,0.714778435617899,279.371803685792));
#303=CARTESIAN_POINT('',(-29.3352199717012,0.714778435617899,279.498094353566));
#304=CARTESIAN_POINT('',(-29.4617164529688,0.714778435617899,279.544517842161));
#305=CARTESIAN_POINT('',(-28.4596904297038,0.734406188590387,277.419248562462));
#306=CARTESIAN_POINT('',(-28.4262140082715,0.734406188590387,277.520502032121));
#307=CARTESIAN_POINT('',(-28.3831696818837,0.734406188590387,277.736656682669));
#308=CARTESIAN_POINT('',(-28.3803516436254,0.734406188590387,278.087108507006));
#309=CARTESIAN_POINT('',(-28.4520438229284,0.734406188590387,278.441545516074));
#310=CARTESIAN_POINT('',(-28.6090783183668,0.734406188590387,278.783583941937));
#311=CARTESIAN_POINT('',(-28.8460400552688,0.734406188590387,279.076705311317));
#312=CARTESIAN_POINT('',(-29.125172023919,0.734406188590387,279.306352255759));
#313=CARTESIAN_POINT('',(-29.3592773557323,0.734406188590387,279.422168083023));
#314=CARTESIAN_POINT('',(-29.4758555792905,0.734406188590387,279.464951627495));
#315=CARTESIAN_POINT('',(-28.4995187897226,0.740910938697204,277.428479324839));
#316=CARTESIAN_POINT('',(-28.4665538357141,0.740910938697204,277.528185799657));
#317=CARTESIAN_POINT('',(-28.4236015634659,0.740910938697203,277.741745055185));
#318=CARTESIAN_POINT('',(-28.4212504030845,0.740910938697204,278.082886282147));
#319=CARTESIAN_POINT('',(-28.4911301840537,0.740910938697203,278.429132165174));
#320=CARTESIAN_POINT('',(-28.6440702263862,0.740910938697204,278.761728319013));
#321=CARTESIAN_POINT('',(-28.8744220170976,0.740910938697204,279.047502301689));
#322=CARTESIAN_POINT('',(-29.14990473394,0.740910938697204,279.272864955739));
#323=CARTESIAN_POINT('',(-29.3715692373486,0.740910938697204,279.383311233504));
#324=CARTESIAN_POINT('',(-29.4830903479491,0.740910938697204,279.424238846305));
#325=CARTESIAN_POINT('',(-28.57938633532,0.747039483058316,277.446989711276));
#326=CARTESIAN_POINT('',(-28.5474503975646,0.747039483058316,277.543583802466));
#327=CARTESIAN_POINT('',(-28.5046776922657,0.747039483058316,277.751953809503));
#328=CARTESIAN_POINT('',(-28.5032648124859,0.747039483058316,278.074418008412));
#329=CARTESIAN_POINT('',(-28.5695099774358,0.747039483058316,278.404240267351));
#330=CARTESIAN_POINT('',(-28.7142381269876,0.747039483058316,278.717900839709));
#331=CARTESIAN_POINT('',(-28.9313406499438,0.747039483058316,278.98894337543));
#332=CARTESIAN_POINT('',(-29.1994851914368,0.747039483058316,279.205707258216));
#333=CARTESIAN_POINT('',(-29.3962510571135,0.747039483058316,279.305403959059));
#334=CARTESIAN_POINT('',(-29.4975981814491,0.747039483058316,279.342597776813));
#335=CARTESIAN_POINT('',(-28.6196991501169,0.7466868231282,277.456332752616));
#336=CARTESIAN_POINT('',(-28.5882807588477,0.7466868231282,277.551361462107));
#337=CARTESIAN_POINT('',(-28.545601439092,0.7466868231282,277.757103860788));
#338=CARTESIAN_POINT('',(-28.5446610307018,0.746686823128201,278.070144488727));
#339=CARTESIAN_POINT('',(-28.6090717571248,0.7466868231282,278.391675902975));
#340=CARTESIAN_POINT('',(-28.7496557230653,0.746686823128201,278.695779402494));
#341=CARTESIAN_POINT('',(-28.9600675967407,0.7466868231282,278.959385063372));
#342=CARTESIAN_POINT('',(-29.2245195939238,0.7466868231282,279.171812947307));
#343=CARTESIAN_POINT('',(-29.4086906766172,0.7466868231282,279.266073820305));
#344=CARTESIAN_POINT('',(-29.5049209506742,0.7466868231282,279.301389783132));
#345=CARTESIAN_POINT('',(-28.6994384148664,0.739163596142722,277.474813408226));
#346=CARTESIAN_POINT('',(-28.6690470839695,0.739163596142722,277.566735649888));
#347=CARTESIAN_POINT('',(-28.6265474935066,0.739163596142722,277.767295761862));
#348=CARTESIAN_POINT('',(-28.6265436789479,0.739163596142722,278.061689950301));
#349=CARTESIAN_POINT('',(-28.6873256291343,0.739163596142722,278.366823934416));
#350=CARTESIAN_POINT('',(-28.8197110805379,0.739163596142722,278.652022386997));
#351=CARTESIAN_POINT('',(-29.0168941932812,0.739163596142722,278.900919963909));
#352=CARTESIAN_POINT('',(-29.2740225997146,0.739163596142722,279.104763918386));
#353=CARTESIAN_POINT('',(-29.4333283187568,0.739163596142722,279.18829001407));
#354=CARTESIAN_POINT('',(-29.5194054821286,0.739163596142722,279.219879843068));
#355=CARTESIAN_POINT('',(-28.7391381204333,0.731967310972703,277.48401435319));
#356=CARTESIAN_POINT('',(-28.7092563034575,0.731967310972702,277.574395508615));
#357=CARTESIAN_POINT('',(-28.6668489179197,0.731967310972703,277.772367244195));
#358=CARTESIAN_POINT('',(-28.667310294454,0.731967310972703,278.05748149722));
#359=CARTESIAN_POINT('',(-28.7262857026178,0.731967310972703,278.354450630312));
#360=CARTESIAN_POINT('',(-28.8545901147445,0.731967310972703,278.630237431728));
#361=CARTESIAN_POINT('',(-29.0451838621746,0.731967310972703,278.871811058606));
#362=CARTESIAN_POINT('',(-29.2986775919369,0.731967310972703,279.071385588561));
#363=CARTESIAN_POINT('',(-29.4455759782649,0.731967310972703,279.149557023241));
#364=CARTESIAN_POINT('',(-29.526616880877,0.731967310972703,279.179298573207));
#365=CARTESIAN_POINT('',(-28.8165659374021,0.711007153337385,277.501959299442));
#366=CARTESIAN_POINT('',(-28.787681070974,0.711007153337385,277.589325057828));
#367=CARTESIAN_POINT('',(-28.7454487058794,0.711007153337385,277.782263197767));
#368=CARTESIAN_POINT('',(-28.7468193327885,0.711007153337385,278.049272186377));
#369=CARTESIAN_POINT('',(-28.80227113144,0.711007153337385,278.330318995516));
#370=CARTESIAN_POINT('',(-28.9226149902067,0.711007153337385,278.587748931273));
#371=CARTESIAN_POINT('',(-29.1003622175073,0.711007153337385,278.81504035897));
#372=CARTESIAN_POINT('',(-29.3467490871832,0.711007153337385,279.006281419515));
#373=CARTESIAN_POINT('',(-29.4694922449614,0.711007153337385,279.074025342106));
#374=CARTESIAN_POINT('',(-29.5406815409144,0.711007153337385,279.100151408504));
#375=CARTESIAN_POINT('',(-28.8545589868062,0.69717174783851,277.510764703704));
#376=CARTESIAN_POINT('',(-28.8261615573045,0.69717174783851,277.596656150383));
#377=CARTESIAN_POINT('',(-28.7840176900994,0.69717174783851,277.787116399967));
#378=CARTESIAN_POINT('',(-28.7858334125742,0.69717174783851,278.045244729232));
#379=CARTESIAN_POINT('',(-28.8395563108924,0.69717174783851,278.318477573559));
#380=CARTESIAN_POINT('',(-28.9559947600926,0.69717174783851,278.566900555936));
#381=CARTESIAN_POINT('',(-29.1274351394746,0.69717174783851,278.787182599129));
#382=CARTESIAN_POINT('',(-29.3703463043648,0.69717174783851,278.974338774519));
#383=CARTESIAN_POINT('',(-29.4812089807858,0.69717174783851,279.036955831734));
#384=CARTESIAN_POINT('',(-29.5475829278393,0.69717174783851,279.061314692496));
#385=CARTESIAN_POINT('',(-28.9275482398757,0.663368066006764,277.5276809526));
#386=CARTESIAN_POINT('',(-28.9000902543941,0.663368066006764,277.610730937661));
#387=CARTESIAN_POINT('',(-28.8581119002265,0.663368066006764,277.796444528615));
#388=CARTESIAN_POINT('',(-28.8607845580551,0.663368066006764,278.037506181447));
#389=CARTESIAN_POINT('',(-28.9111857670109,0.663368066006764,278.295729207337));
#390=CARTESIAN_POINT('',(-29.020120508915,0.663368066006764,278.526847881034));
#391=CARTESIAN_POINT('',(-29.1794488025747,0.663368066006764,278.733665705946));
#392=CARTESIAN_POINT('',(-29.4156677036521,0.663368066006764,278.912968774271));
#393=CARTESIAN_POINT('',(-29.5037425877047,0.663368066006764,278.965749740706));
#394=CARTESIAN_POINT('',(-29.5608413286439,0.663368066006764,278.986704653619));
#395=CARTESIAN_POINT('',(-28.9627935076193,0.643284744868276,277.535849521211));
#396=CARTESIAN_POINT('',(-28.9357875299833,0.643284744868276,277.617532354088));
#397=CARTESIAN_POINT('',(-28.893891532172,0.643284744868276,277.800946465297));
#398=CARTESIAN_POINT('',(-28.8969770042683,0.643284744868276,278.033770084937));
#399=CARTESIAN_POINT('',(-28.9457743002938,0.643284744868276,278.284744150343));
#400=CARTESIAN_POINT('',(-29.0510864003399,0.643284744868276,278.507507428828));
#401=CARTESIAN_POINT('',(-29.2045627412905,0.643284744868276,278.70782234873));
#402=CARTESIAN_POINT('',(-29.4375617700418,0.643284744868276,278.88333760246));
#403=CARTESIAN_POINT('',(-29.5146047085005,0.643284744868276,278.931358568067));
#404=CARTESIAN_POINT('',(-29.5672435846825,0.643284744868276,278.950676736001));
#405=CARTESIAN_POINT('',(-29.0293517536877,0.597588631870238,277.55127529705));
#406=CARTESIAN_POINT('',(-29.0032020956605,0.597588631870238,277.630368088107));
#407=CARTESIAN_POINT('',(-28.9614575407317,0.597588631870238,277.809452170667));
#408=CARTESIAN_POINT('',(-28.9653242793062,0.597588631870238,278.026713539965));
#409=CARTESIAN_POINT('',(-29.0110923932415,0.597588631870238,278.264000011195));
#410=CARTESIAN_POINT('',(-29.1095627867225,0.597588631870238,278.470984019811));
#411=CARTESIAN_POINT('',(-29.2519908911457,0.597588631870238,278.659019799585));
#412=CARTESIAN_POINT('',(-29.478899317794,0.597588631870238,278.827378288524));
#413=CARTESIAN_POINT('',(-29.5351334414076,0.597588631870238,278.86641922927));
#414=CARTESIAN_POINT('',(-29.5793338016133,0.597588631870238,278.882640509873));
#415=CARTESIAN_POINT('',(-29.0608910107673,0.571820898375333,277.558584947448));
#416=CARTESIAN_POINT('',(-29.0351456657649,0.571820898375333,277.636454845052));
#417=CARTESIAN_POINT('',(-28.9934750490745,0.571820898375333,277.813480479462));
#418=CARTESIAN_POINT('',(-28.9977111255416,0.571820898375333,278.023370373012));
#419=CARTESIAN_POINT('',(-29.0420438640362,0.571820898375333,278.254169962447));
#420=CARTESIAN_POINT('',(-29.1372730755396,0.571820898375333,278.453677366021));
#421=CARTESIAN_POINT('',(-29.2744624558956,0.571820898375333,278.635893237576));
#422=CARTESIAN_POINT('',(-29.4984971389555,0.571820898375333,278.800864974708));
#423=CARTESIAN_POINT('',(-29.5448411694818,0.571820898375333,278.835639764322));
#424=CARTESIAN_POINT('',(-29.5850628657407,0.571820898375333,278.850400897904));
#425=CARTESIAN_POINT('',(-29.1192169234807,0.515507278002845,277.572102768429));
#426=CARTESIAN_POINT('',(-29.0942216649693,0.515507278002845,277.647703939075));
#427=CARTESIAN_POINT('',(-29.0526842149506,0.515507278002845,277.820933661193));
#428=CARTESIAN_POINT('',(-29.0576048243463,0.515507278002845,278.01718679073));
#429=CARTESIAN_POINT('',(-29.0992827150508,0.515507278002845,278.235991434243));
#430=CARTESIAN_POINT('',(-29.1885179366269,0.515507278002845,278.421671846942));
#431=CARTESIAN_POINT('',(-29.3160198402119,0.515507278002845,278.593125211272));
#432=CARTESIAN_POINT('',(-29.5347379643375,0.515507278002845,278.751832984414));
#433=CARTESIAN_POINT('',(-29.5627972179842,0.515507278002845,278.778720204517));
#434=CARTESIAN_POINT('',(-29.5956576902598,0.515507278002845,278.790779810797));
#435=CARTESIAN_POINT('',(-29.1462010272777,0.484771260759288,277.578356700301));
#436=CARTESIAN_POINT('',(-29.1215515439151,0.484771260759288,277.652912032352));
#437=CARTESIAN_POINT('',(-29.0800775550095,0.484771260759287,277.82437994841));
#438=CARTESIAN_POINT('',(-29.0853141326301,0.484771260759288,278.01432655126));
#439=CARTESIAN_POINT('',(-29.1257637323291,0.484771260759287,278.227581030268));
#440=CARTESIAN_POINT('',(-29.2122268464457,0.484771260759288,278.406865045036));
#441=CARTESIAN_POINT('',(-29.3352429654935,0.484771260759288,278.573337702133));
#442=CARTESIAN_POINT('',(-29.5515156407387,0.484771260759287,278.729152728244));
#443=CARTESIAN_POINT('',(-29.5710814217422,0.484771260759288,278.752378283286));
#444=CARTESIAN_POINT('',(-29.600559316848,0.484771260759288,278.763196502999));
#445=CARTESIAN_POINT('',(-29.1947316430493,0.419396127509962,277.589604328423));
#446=CARTESIAN_POINT('',(-29.1707060174536,0.419396127509962,277.6622727275));
#447=CARTESIAN_POINT('',(-29.1293431808046,0.419396127509962,277.830581035137));
#448=CARTESIAN_POINT('',(-29.1351493450845,0.419396127509962,278.009181607409));
#449=CARTESIAN_POINT('',(-29.1733893073914,0.419396127509962,278.212455184622));
#450=CARTESIAN_POINT('',(-29.2548677278686,0.419396127509962,278.380235344253));
#451=CARTESIAN_POINT('',(-29.3698130857385,0.419396127509962,278.53774919969));
#452=CARTESIAN_POINT('',(-29.5816988071758,0.419396127509962,278.688365722523));
#453=CARTESIAN_POINT('',(-29.5859624075649,0.419396127509962,278.704995996421));
#454=CARTESIAN_POINT('',(-29.6093748386973,0.419396127509962,278.71358822538));
#455=CARTESIAN_POINT('',(-29.2164417303385,0.384537245209217,277.594635935471));
#456=CARTESIAN_POINT('',(-29.1926941892506,0.384537245209217,277.666463234452));
#457=CARTESIAN_POINT('',(-29.1513825495571,0.384537245209217,277.833353575987));
#458=CARTESIAN_POINT('',(-29.1574429731175,0.384537245209217,278.006880479564));
#459=CARTESIAN_POINT('',(-29.1946942832223,0.384537245209217,278.205688441855));
#460=CARTESIAN_POINT('',(-29.2739441286859,0.384537245209217,278.368323025536));
#461=CARTESIAN_POINT('',(-29.3852738319166,0.384537245209217,278.52182721626));
#462=CARTESIAN_POINT('',(-29.5952158633909,0.384537245209217,278.670125111838));
#463=CARTESIAN_POINT('',(-29.5925889223982,0.384537245209217,278.683788430315));
#464=CARTESIAN_POINT('',(-29.6133184471969,0.384537245209217,278.691396047922));
#465=CARTESIAN_POINT('',(-29.2538896988015,0.311889129353778,277.603315009835));
#466=CARTESIAN_POINT('',(-29.2306233687728,0.311889129353778,277.673686827994));
#467=CARTESIAN_POINT('',(-29.189397702528,0.311889129353778,277.838138263277));
#468=CARTESIAN_POINT('',(-29.1958978376195,0.311889129353778,278.002910623924));
#469=CARTESIAN_POINT('',(-29.2314429375706,0.311889129353778,278.194016422002));
#470=CARTESIAN_POINT('',(-29.3068510596421,0.311889129353778,278.347775952845));
#471=CARTESIAN_POINT('',(-29.4119353047273,0.311889129353778,278.494360680589));
#472=CARTESIAN_POINT('',(-29.6185561507925,0.311889129353778,278.638670694114));
#473=CARTESIAN_POINT('',(-29.6039680448757,0.311889129353778,278.647188539966));
#474=CARTESIAN_POINT('',(-29.6201208208933,0.311889129353778,278.653116516821));
#475=CARTESIAN_POINT('',(-29.2697533006091,0.273856648882463,277.606991614613));
#476=CARTESIAN_POINT('',(-29.2466900989401,0.273856648882463,277.676749046576));
#477=CARTESIAN_POINT('',(-29.2055019031535,0.273856648882463,277.840164045882));
#478=CARTESIAN_POINT('',(-29.2121879832519,0.273856648882463,278.001229273236));
#479=CARTESIAN_POINT('',(-29.2470099101338,0.273856648882463,278.189071715999));
#480=CARTESIAN_POINT('',(-29.3207925949741,0.273856648882463,278.339072472551));
#481=CARTESIAN_POINT('',(-29.4232234587577,0.273856648882463,278.482723138021));
#482=CARTESIAN_POINT('',(-29.6284651275202,0.273856648882463,278.62535400344));
#483=CARTESIAN_POINT('',(-29.6087435085404,0.273856648882463,278.631667710344));
#484=CARTESIAN_POINT('',(-29.6230024230762,0.273856648882463,278.636900650816));
#485=CARTESIAN_POINT('',(-29.2951344426532,0.195905079729282,277.612874038367));
#486=CARTESIAN_POINT('',(-29.2723972941607,0.195905079729282,277.681645283217));
#487=CARTESIAN_POINT('',(-29.2312674175561,0.195905079729282,277.843406785169));
#488=CARTESIAN_POINT('',(-29.2382519268255,0.195905079729282,277.998538798566));
#489=CARTESIAN_POINT('',(-29.2719156469699,0.195905079729282,278.181160223025));
#490=CARTESIAN_POINT('',(-29.343101478582,0.195905079729282,278.325148296376));
#491=CARTESIAN_POINT('',(-29.4412727812203,0.195905079729282,278.464099395217));
#492=CARTESIAN_POINT('',(-29.6443590656834,0.195905079729282,278.604062482992));
#493=CARTESIAN_POINT('',(-29.6163010619336,0.195905079729282,278.606804529278));
#494=CARTESIAN_POINT('',(-29.6276128737926,0.195905079729282,278.610955899842));
#495=CARTESIAN_POINT('',(-29.3047369245515,0.155725812643358,277.615099543725));
#496=CARTESIAN_POINT('',(-29.2821227023059,0.155725812643358,277.683498983332));
#497=CARTESIAN_POINT('',(-29.2410154942601,0.155725812643358,277.84463295528));
#498=CARTESIAN_POINT('',(-29.2481128207451,0.155725812643358,277.997521145984));
#499=CARTESIAN_POINT('',(-29.2813377134205,0.155725812643358,278.178166796402));
#500=CARTESIAN_POINT('',(-29.3515438261321,0.155725812643358,278.319881166333));
#501=CARTESIAN_POINT('',(-29.4480930192305,0.155725812643358,278.457050367274));
#502=CARTESIAN_POINT('',(-29.6504019590561,0.155725812643358,278.596018140729));
#503=CARTESIAN_POINT('',(-29.6190985961923,0.155725812643358,278.597375355473));
#504=CARTESIAN_POINT('',(-29.629357151866,0.155725812643358,278.601140187013));
#505=CARTESIAN_POINT('',(-29.3173891363497,0.0745688061764249,277.618031865332));
#506=CARTESIAN_POINT('',(-29.2949374165279,0.0745688061764249,277.685939796781));
#507=CARTESIAN_POINT('',(-29.2538592544061,0.074568806176425,277.84624935033));
#508=CARTESIAN_POINT('',(-29.2611056731473,0.0745688061764249,277.996180089657));
#509=CARTESIAN_POINT('',(-29.2937518731824,0.074568806176425,278.174222610677));
#510=CARTESIAN_POINT('',(-29.3626686704136,0.0745688061764249,278.312941634877));
#511=CARTESIAN_POINT('',(-29.4570747130229,0.0745688061764249,278.44776088437));
#512=CARTESIAN_POINT('',(-29.6583804940753,0.0745688061764249,278.585424959125));
#513=CARTESIAN_POINT('',(-29.6227504973219,0.0745688061764249,278.584938970531));
#514=CARTESIAN_POINT('',(-29.6316554093222,0.0745688061764249,278.588207022547));
#515=CARTESIAN_POINT('',(-29.3204811259484,0.0333207382764462,277.618748475839));
#516=CARTESIAN_POINT('',(-29.2980689831142,0.0333207382764462,277.686536701921));
#517=CARTESIAN_POINT('',(-29.2569981036032,0.0333207382764462,277.84664415923));
#518=CARTESIAN_POINT('',(-29.2642809631465,0.0333207382764462,277.995852442768));
#519=CARTESIAN_POINT('',(-29.2967854105204,0.0333207382764462,278.173258597976));
#520=CARTESIAN_POINT('',(-29.3653884803685,0.0333207382764462,278.3112461318));
#521=CARTESIAN_POINT('',(-29.4592655567513,0.0333207382764462,278.445489171716));
#522=CARTESIAN_POINT('',(-29.6603449577588,0.0333207382764462,278.582841536344));
#523=CARTESIAN_POINT('',(-29.6236125479341,0.0333207382764462,278.581888563971));
#524=CARTESIAN_POINT('',(-29.632217065123,0.0333207382764462,278.585046372802));
#525=CARTESIAN_POINT('',(-29.320075941321,-0.0488675633487051,277.618654568809));
#526=CARTESIAN_POINT('',(-29.2976585947124,-0.0488675633487051,277.686458534333));
#527=CARTESIAN_POINT('',(-29.2565867857033,-0.0488675633487051,277.846592395432));
#528=CARTESIAN_POINT('',(-29.2638648650759,-0.0488675633487051,277.995895388027));
#529=CARTESIAN_POINT('',(-29.2963878670283,-0.048867563348705,278.173384916249));
#530=CARTESIAN_POINT('',(-29.3650321416744,-0.0488675633487051,278.311468344085));
#531=CARTESIAN_POINT('',(-29.4589781776968,-0.0488675633487051,278.445786760271));
#532=CARTESIAN_POINT('',(-29.6600885328094,-0.0488675633487051,278.583180445527));
#533=CARTESIAN_POINT('',(-29.6234974947022,-0.0488675633487051,278.582287533411));
#534=CARTESIAN_POINT('',(-29.632143463874,-0.0488675633487051,278.585460554884));
#535=CARTESIAN_POINT('',(-29.3165774209635,-0.0900813776589527,277.617843739287));
#536=CARTESIAN_POINT('',(-29.294115293647,-0.0900813776589527,277.685783149458));
#537=CARTESIAN_POINT('',(-29.2530352435743,-0.0900813776589527,277.846145676837));
#538=CARTESIAN_POINT('',(-29.2602720967428,-0.0900813776589527,277.9962661153));
#539=CARTESIAN_POINT('',(-29.292955466052,-0.0900813776589527,278.174475669412));
#540=CARTESIAN_POINT('',(-29.3619548044354,-0.0900813776589527,278.313386795311));
#541=CARTESIAN_POINT('',(-29.4564990188841,-0.0900813776589527,278.448357057189));
#542=CARTESIAN_POINT('',(-29.6578667257742,-0.0900813776589526,278.58610387899));
#543=CARTESIAN_POINT('',(-29.6225201467486,-0.0900813776589527,278.585738285587));
#544=CARTESIAN_POINT('',(-29.6315079623012,-0.0900813776589527,278.589036762735));
#545=CARTESIAN_POINT('',(-29.3031253789696,-0.171102605758675,277.61472604619));
#546=CARTESIAN_POINT('',(-29.2804904749282,-0.171102605758675,277.683188040379));
#547=CARTESIAN_POINT('',(-29.2393795403659,-0.171102605758675,277.844427094901));
#548=CARTESIAN_POINT('',(-29.246457897098,-0.171102605758675,277.99769195566));
#549=CARTESIAN_POINT('',(-29.2797564580023,-0.171102605758675,278.178669168509));
#550=CARTESIAN_POINT('',(-29.3501269430696,-0.171102605758675,278.32076511533));
#551=CARTESIAN_POINT('',(-29.4469485495562,-0.171102605758675,278.458233429086));
#552=CARTESIAN_POINT('',(-29.6493872978923,-0.171102605758675,278.59736800417));
#553=CARTESIAN_POINT('',(-29.6186301500769,-0.171102605758675,278.598958201799));
#554=CARTESIAN_POINT('',(-29.6290644167531,-0.171102605758675,278.602787518277));
#555=CARTESIAN_POINT('',(-29.2931269341915,-0.211179920410293,277.612408771066));
#556=CARTESIAN_POINT('',(-29.2703640334253,-0.211179920410293,277.68125790677));
#557=CARTESIAN_POINT('',(-29.2292294929079,-0.211179920410293,277.843150358923));
#558=CARTESIAN_POINT('',(-29.2361904032932,-0.211179920410293,277.998751579252));
#559=CARTESIAN_POINT('',(-29.2699457948734,-0.211179920410293,278.181786003381));
#560=CARTESIAN_POINT('',(-29.3413367539859,-0.211179920410293,278.326249541762));
#561=CARTESIAN_POINT('',(-29.4398459990779,-0.211179920410293,278.465572731859));
#562=CARTESIAN_POINT('',(-29.6430990378571,-0.211179920410293,278.605745458741));
#563=CARTESIAN_POINT('',(-29.615709334643,-0.211179920410293,278.608773284153));
#564=CARTESIAN_POINT('',(-29.6272482125488,-0.211179920410293,278.613007986664));
#565=CARTESIAN_POINT('',(-29.2669774021545,-0.288863168079469,277.606348262514));
#566=CARTESIAN_POINT('',(-29.2438785719819,-0.288863168079469,277.676213457178));
#567=CARTESIAN_POINT('',(-29.2026839463909,-0.288863168079469,277.839809437829));
#568=CARTESIAN_POINT('',(-29.2093374291811,-0.288863168079469,278.001523519264));
#569=CARTESIAN_POINT('',(-29.2442859392689,-0.288863168079469,278.189936964111));
#570=CARTESIAN_POINT('',(-29.318352957815,-0.288863168079469,278.340595431007));
#571=CARTESIAN_POINT('',(-29.421248468708,-0.288863168079469,278.484759636845));
#572=CARTESIAN_POINT('',(-29.626730238802,-0.288863168079469,278.627683876619));
#573=CARTESIAN_POINT('',(-29.6079098714152,-0.288863168079469,278.634384362378));
#574=CARTESIAN_POINT('',(-29.6224981848116,-0.288863168079469,278.639738190356));
#575=CARTESIAN_POINT('',(-29.2507387972311,-0.326728428396875,277.60258474568));
#576=CARTESIAN_POINT('',(-29.2274320330342,-0.326728428396875,277.673078861852));
#577=CARTESIAN_POINT('',(-29.186199053105,-0.326728428396875,277.837735760069));
#578=CARTESIAN_POINT('',(-29.1926622115746,-0.326728428396875,278.003244622873));
#579=CARTESIAN_POINT('',(-29.2283509183401,-0.326728428396875,278.194998537533));
#580=CARTESIAN_POINT('',(-29.304082076925,-0.326728428396875,278.349504736156));
#581=CARTESIAN_POINT('',(-29.4096926280319,-0.326728428396875,278.496671972191));
#582=CARTESIAN_POINT('',(-29.6165900103182,-0.326728428396875,278.641316460268));
#583=CARTESIAN_POINT('',(-29.6030153120395,-0.326728428396875,278.650269814135));
#584=CARTESIAN_POINT('',(-29.6195484638112,-0.326728428396875,278.656337386727));
#585=CARTESIAN_POINT('',(-29.2125742294369,-0.39898216696886,277.593739589706));
#586=CARTESIAN_POINT('',(-29.1887770353444,-0.39898216696886,277.665717070182));
#587=CARTESIAN_POINT('',(-29.1474564465238,-0.39898216696886,277.83285949579));
#588=CARTESIAN_POINT('',(-29.1534715009056,-0.39898216696886,278.007290457862));
#589=CARTESIAN_POINT('',(-29.1908989600711,-0.39898216696886,278.206893878442));
#590=CARTESIAN_POINT('',(-29.2705457782985,-0.39898216696886,278.370445118211));
#591=CARTESIAN_POINT('',(-29.3825196884854,-0.39898216696886,278.524663635312));
#592=CARTESIAN_POINT('',(-29.5928076085241,-0.39898216696886,278.673374445197));
#593=CARTESIAN_POINT('',(-29.5914090475239,-0.39898216696886,278.68756662805));
#594=CARTESIAN_POINT('',(-29.6126159207987,-0.39898216696886,278.695349429831));
#595=CARTESIAN_POINT('',(-29.190520118542,-0.433612627528457,277.588628250524));
#596=CARTESIAN_POINT('',(-29.1664404268343,-0.433612627528457,277.66146017907));
#597=CARTESIAN_POINT('',(-29.1250678373328,-0.433612627528457,277.830043009969));
#598=CARTESIAN_POINT('',(-29.1308246097374,-0.433612627528457,278.009628055813));
#599=CARTESIAN_POINT('',(-29.169256348153,-0.433612627528457,278.213767836146));
#600=CARTESIAN_POINT('',(-29.2511672120646,-0.433612627528457,278.382546248376));
#601=CARTESIAN_POINT('',(-29.3668134743299,-0.433612627528457,278.540837748907));
#602=CARTESIAN_POINT('',(-29.579078033601,-0.433612627528457,278.691904716383));
#603=CARTESIAN_POINT('',(-29.5846740461296,-0.433612627528457,278.709108977135));
#604=CARTESIAN_POINT('',(-29.6086098208684,-0.433612627528457,278.717893270219));
#605=CARTESIAN_POINT('',(-29.141344066282,-0.49847707761895,277.577231033746));
#606=CARTESIAN_POINT('',(-29.1166322041036,-0.49847707761895,277.651975038041));
#607=CARTESIAN_POINT('',(-29.0751470041968,-0.49847707761895,277.823759426698));
#608=CARTESIAN_POINT('',(-29.0803266206039,-0.49847707761895,278.014841436558));
#609=CARTESIAN_POINT('',(-29.1209973250753,-0.49847707761895,278.229094829321));
#610=CARTESIAN_POINT('',(-29.2079594129208,-0.49847707761895,278.409530182329));
#611=CARTESIAN_POINT('',(-29.331782870227,-0.49847707761895,278.576899300329));
#612=CARTESIAN_POINT('',(-29.5484959809014,-0.49847707761895,278.733235102979));
#613=CARTESIAN_POINT('',(-29.569589880236,-0.49847707761895,278.757119494399));
#614=CARTESIAN_POINT('',(-29.5996770563389,-0.49847707761895,278.768161316769));
#615=CARTESIAN_POINT('',(-29.114056335009,-0.528929173693141,277.57090673209));
#616=CARTESIAN_POINT('',(-29.0889947981237,-0.528929173693141,277.646708369663));
#617=CARTESIAN_POINT('',(-29.0474454351212,-0.528929173693141,277.82027434781));
#618=CARTESIAN_POINT('',(-29.0523055280244,-0.528929173693141,278.017733865141));
#619=CARTESIAN_POINT('',(-29.0942183240248,-0.528929173693141,278.237599860448));
#620=CARTESIAN_POINT('',(-29.1839837953935,-0.528929173693141,278.424503616573));
#621=CARTESIAN_POINT('',(-29.3123431891159,-0.528929173693141,278.596909366362));
#622=CARTESIAN_POINT('',(-29.5315304261596,-0.528929173693141,278.756170891706));
#623=CARTESIAN_POINT('',(-29.5612105811069,-0.528929173693141,278.783757126971));
#624=CARTESIAN_POINT('',(-29.5947202762232,-0.528929173693141,278.796054994339));
#625=CARTESIAN_POINT('',(-29.0551740424612,-0.584628780161672,277.55725996254));
#626=CARTESIAN_POINT('',(-29.0293552440507,-0.584628780161672,277.635352028825));
#627=CARTESIAN_POINT('',(-28.9876714719663,-0.584628780161672,277.812750038569));
#628=CARTESIAN_POINT('',(-28.9918404981181,-0.584628780161672,278.023976444594));
#629=CARTESIAN_POINT('',(-29.0364334369123,-0.584628780161672,278.255951784275));
#630=CARTESIAN_POINT('',(-29.1322502043134,-0.584628780161672,278.456814479605));
#631=CARTESIAN_POINT('',(-29.2703889909349,-0.584628780161672,278.640085219524));
#632=CARTESIAN_POINT('',(-29.4949452816081,-0.584628780161672,278.805671114986));
#633=CARTESIAN_POINT('',(-29.5430803649778,-0.584628780161672,278.841218593472));
#634=CARTESIAN_POINT('',(-29.5840243860467,-0.584628780161672,278.856244816147));
#635=CARTESIAN_POINT('',(-29.0233800972487,-0.61006439603559,277.549891284714));
#636=CARTESIAN_POINT('',(-28.9971537103513,-0.61006439603559,277.629216151483));
#637=CARTESIAN_POINT('',(-28.9553954180584,-0.61006439603559,277.808689184036));
#638=CARTESIAN_POINT('',(-28.959192120212,-0.61006439603559,278.027346613948));
#639=CARTESIAN_POINT('',(-29.0052320153833,-0.61006439603559,278.265861208604));
#640=CARTESIAN_POINT('',(-29.1043161840021,-0.61006439603559,278.474260903211));
#641=CARTESIAN_POINT('',(-29.2477358220529,-0.61006439603559,278.663398483333));
#642=CARTESIAN_POINT('',(-29.4751896991422,-0.61006439603559,278.832398713295));
#643=CARTESIAN_POINT('',(-29.5332932131706,-0.61006439603559,278.872246232589));
#644=CARTESIAN_POINT('',(-29.5782490581586,-0.61006439603559,278.888744771806));
#645=CARTESIAN_POINT('',(-28.9563703755817,-0.655059228047004,277.534360873284));
#646=CARTESIAN_POINT('',(-28.9292818381605,-0.655059228047004,277.616293418178));
#647=CARTESIAN_POINT('',(-28.8873711081693,-0.655059228047004,277.80012574911));
#648=CARTESIAN_POINT('',(-28.8903812349848,-0.655059228047004,278.034451035624));
#649=CARTESIAN_POINT('',(-28.9394708449549,-0.655059228047004,278.286746050554));
#650=CARTESIAN_POINT('',(-29.0454431998547,-0.655059228047004,278.511032078396));
#651=CARTESIAN_POINT('',(-29.1999857402976,-0.655059228047004,278.712531987689));
#652=CARTESIAN_POINT('',(-29.4335725277787,-0.655059228047004,278.888737893299));
#653=CARTESIAN_POINT('',(-29.5126236190687,-0.655059228047004,278.937625474294));
#654=CARTESIAN_POINT('',(-29.5660768312853,-0.655059228047004,278.957242498916));
#655=CARTESIAN_POINT('',(-28.9209267282659,-0.674771040271489,277.526146327518));
#656=CARTESIAN_POINT('',(-28.8933836275419,-0.674771040271489,277.609453753884));
#657=CARTESIAN_POINT('',(-28.8513900942053,-0.674771040271489,277.795598455953));
#658=CARTESIAN_POINT('',(-28.8539850777696,-0.674771040271489,278.038208166284));
#659=CARTESIAN_POINT('',(-28.9046876235505,-0.674771040271489,278.297792934092));
#660=CARTESIAN_POINT('',(-29.0143030363999,-0.674771040271489,278.53048139729));
#661=CARTESIAN_POINT('',(-29.1747303666742,-0.674771040271489,278.738520775939));
#662=CARTESIAN_POINT('',(-29.4115555131172,-0.674771040271489,278.918535949551));
#663=CARTESIAN_POINT('',(-29.501699771567,-0.674771040271489,278.972210003116));
#664=CARTESIAN_POINT('',(-29.5596385398612,-0.674771040271489,278.993473201287));
#665=CARTESIAN_POINT('',(-28.8476041012287,-0.707805041777099,277.509152814686));
#666=CARTESIAN_POINT('',(-28.8191172425724,-0.707805041777099,277.595314750617));
#667=CARTESIAN_POINT('',(-28.7769574741479,-0.707805041777098,277.7862276868));
#668=CARTESIAN_POINT('',(-28.7786915964709,-0.707805041777099,278.045982070115));
#669=CARTESIAN_POINT('',(-28.8327309964891,-0.707805041777099,278.320645196175));
#670=CARTESIAN_POINT('',(-28.9498844302688,-0.707805041777099,278.570717023366));
#671=CARTESIAN_POINT('',(-29.1224790071935,-0.707805041777099,278.792282057385));
#672=CARTESIAN_POINT('',(-29.366027561787,-0.707805041777098,278.980186418997));
#673=CARTESIAN_POINT('',(-29.4790623076577,-0.707805041777099,279.04374098008));
#674=CARTESIAN_POINT('',(-29.5463195821184,-0.707805041777099,279.068424016972));
#675=CARTESIAN_POINT('',(-28.809474868075,-0.72123967007688,277.500315847994));
#676=CARTESIAN_POINT('',(-28.7804988140237,-0.72123967007688,277.587957414332));
#677=CARTESIAN_POINT('',(-28.7382502471577,-0.72123967007688,277.781357071573));
#678=CARTESIAN_POINT('',(-28.7395376723511,-0.72123967007688,278.05002396857));
#679=CARTESIAN_POINT('',(-28.795312167818,-0.72123967007688,278.332529060459));
#680=CARTESIAN_POINT('',(-28.9163850249608,-0.72123967007688,278.591640133361));
#681=CARTESIAN_POINT('',(-29.0953089966702,-0.72123967007688,278.820239654173));
#682=CARTESIAN_POINT('',(-29.3423459296354,-0.721239670076879,279.012243622054));
#683=CARTESIAN_POINT('',(-29.4673032253679,-0.72123967007688,279.080943235917));
#684=CARTESIAN_POINT('',(-29.5393934575964,-0.72123967007688,279.107399940801));
#685=CARTESIAN_POINT('',(-28.731841741952,-0.741382956020525,277.482323318562));
#686=CARTESIAN_POINT('',(-28.7018660716827,-0.741382956020525,277.57298834458));
#687=CARTESIAN_POINT('',(-28.6594420530602,-0.741382956020525,277.771434844318));
#688=CARTESIAN_POINT('',(-28.6598178044636,-0.741382956020525,278.058255057363));
#689=CARTESIAN_POINT('',(-28.7191252501699,-0.741382956020525,278.356724678648));
#690=CARTESIAN_POINT('',(-28.8481797931816,-0.741382956020525,278.63424130527));
#691=CARTESIAN_POINT('',(-29.0399842529885,-0.741382956020525,278.877160859912));
#692=CARTESIAN_POINT('',(-29.2941472376399,-0.741382956020525,279.077520521987));
#693=CARTESIAN_POINT('',(-29.4433229797632,-0.741382956020525,279.156674992104));
#694=CARTESIAN_POINT('',(-29.525291503424,-0.741382956020525,279.186756973715));
#695=CARTESIAN_POINT('',(-28.6920721722491,-0.748160356393263,277.473106181637));
#696=CARTESIAN_POINT('',(-28.6615860808436,-0.748160356393263,277.565315037874));
#697=CARTESIAN_POINT('',(-28.6190697107092,-0.748160356393263,277.766354421199));
#698=CARTESIAN_POINT('',(-28.6189794462712,-0.748160356393263,278.062470921255));
#699=CARTESIAN_POINT('',(-28.6800966126065,-0.748160356393263,278.3691197555));
#700=CARTESIAN_POINT('',(-28.813239385817,-0.748160356393264,278.65606460117));
#701=CARTESIAN_POINT('',(-29.0116447705776,-0.748160356393263,278.906320980779));
#702=CARTESIAN_POINT('',(-29.2694489598102,-0.748160356393263,279.110957629185));
#703=CARTESIAN_POINT('',(-29.431053553489,-0.748160356393263,279.195476067604));
#704=CARTESIAN_POINT('',(-29.5180674139482,-0.748160356393263,279.227409659102));
#705=CARTESIAN_POINT('',(-28.6122619408995,-0.754842419137764,277.454609078555));
#706=CARTESIAN_POINT('',(-28.5807478549528,-0.754842419137764,277.549927228128));
#707=CARTESIAN_POINT('',(-28.5380516254354,-0.754842419137764,277.756153419235));
#708=CARTESIAN_POINT('',(-28.5370239218336,-0.754842419137764,278.070932992994));
#709=CARTESIAN_POINT('',(-28.6017730935437,-0.754842419137764,278.393993838328));
#710=CARTESIAN_POINT('',(-28.7431216924261,-0.754842419137764,278.699860564887));
#711=CARTESIAN_POINT('',(-28.9547675521945,-0.754842419137764,278.9648380957));
#712=CARTESIAN_POINT('',(-29.2199020643551,-0.754842419137764,279.178066392016));
#713=CARTESIAN_POINT('',(-29.406393637008,-0.754842419137764,279.273328972674));
#714=CARTESIAN_POINT('',(-29.5035699915052,-0.754842419137764,279.308992141637));
#715=CARTESIAN_POINT('',(-28.5719477679877,-0.754769919930253,277.445265722454));
#716=CARTESIAN_POINT('',(-28.5399161086028,-0.754769919930254,277.542149335244));
#717=CARTESIAN_POINT('',(-28.4971265045525,-0.754769919930253,277.751003180126));
#718=CARTESIAN_POINT('',(-28.4956263079787,-0.754769919930253,278.075206660846));
#719=CARTESIAN_POINT('',(-28.5622099801654,-0.754769919930253,278.406558624403));
#720=CARTESIAN_POINT('',(-28.7077029078591,-0.754769919930253,278.721982749442));
#721=CARTESIAN_POINT('',(-28.9260396192979,-0.754769919930254,278.994397396749));
#722=CARTESIAN_POINT('',(-29.1948668834216,-0.754769919930253,279.211961868664));
#723=CARTESIAN_POINT('',(-29.3939534635095,-0.754769919930253,279.312660386925));
#724=CARTESIAN_POINT('',(-29.4962469755803,-0.754769919930253,279.350201523591));
#725=CARTESIAN_POINT('',(-28.4921608003701,-0.747800902061117,277.426774011056));
#726=CARTESIAN_POINT('',(-28.4591011458705,-0.747800902061117,277.526766918918));
#727=CARTESIAN_POINT('',(-28.4161321813871,-0.747800902061117,277.740804699743));
#728=CARTESIAN_POINT('',(-28.4136946406211,-0.747800902061117,278.083666398465));
#729=CARTESIAN_POINT('',(-28.4839092624487,-0.747800902061117,278.431425406158));
#730=CARTESIAN_POINT('',(-28.6376058068157,-0.747800902061117,278.765766014803));
#731=CARTESIAN_POINT('',(-28.8691783821423,-0.747800902061117,279.052897232293));
#732=CARTESIAN_POINT('',(-29.145336551176,-0.747800902061117,279.279051849239));
#733=CARTESIAN_POINT('',(-29.3692963295601,-0.747800902061117,279.390488981991));
#734=CARTESIAN_POINT('',(-29.4817537789633,-0.747800902061117,279.431760225804));
#735=CARTESIAN_POINT('',(-28.4524145785636,-0.740880558648503,277.417562285323));
#736=CARTESIAN_POINT('',(-28.4188445023591,-0.740880558648503,277.519099025124));
#737=CARTESIAN_POINT('',(-28.3757836871119,-0.740880558648503,277.735726807339));
#738=CARTESIAN_POINT('',(-28.3728802258083,-0.740880558648503,278.087879919786));
#739=CARTESIAN_POINT('',(-28.4449035087714,-0.740880558648503,278.443813155542));
#740=CARTESIAN_POINT('',(-28.6026860661102,-0.740880558648503,278.787576566337));
#741=CARTESIAN_POINT('',(-28.8408549394933,-0.740880558648503,279.082040011531));
#742=CARTESIAN_POINT('',(-29.1206548939389,-0.740880558648503,279.312470105298));
#743=CARTESIAN_POINT('',(-29.3570297011592,-0.740880558648503,279.429265661475));
#744=CARTESIAN_POINT('',(-29.4745339306018,-0.740880558648503,279.472389044835));
#745=CARTESIAN_POINT('',(-28.3748504967692,-0.720458420337075,277.399585757851));
#746=CARTESIAN_POINT('',(-28.3402808177191,-0.720458420337075,277.504145916884));
#747=CARTESIAN_POINT('',(-28.2970460084054,-0.720458420337075,277.725812086297));
#748=CARTESIAN_POINT('',(-28.2932311675975,-0.720458420337075,278.096104075511));
#749=CARTESIAN_POINT('',(-28.3687842539642,-0.720458420337075,278.467987103548));
#750=CARTESIAN_POINT('',(-28.5345419835023,-0.720458420337075,278.830140062484));
#751=CARTESIAN_POINT('',(-28.7855775004257,-0.720458420337075,279.138909887786));
#752=CARTESIAN_POINT('',(-29.072505806105,-0.720458420337075,279.377691425197));
#753=CARTESIAN_POINT('',(-29.3330567869117,-0.720458420337075,279.504924927941));
#754=CARTESIAN_POINT('',(-29.46044451824,-0.720458420337075,279.551675500235));
#755=CARTESIAN_POINT('',(-28.3367672099766,-0.706886922474307,277.390759439851));
#756=CARTESIAN_POINT('',(-28.3017083495048,-0.706886922474307,277.496799187028));
#757=CARTESIAN_POINT('',(-28.2583857040044,-0.706886922474307,277.720946473721));
#758=CARTESIAN_POINT('',(-28.2541243660457,-0.706886922474307,278.100141358364));
#759=CARTESIAN_POINT('',(-28.3314104493543,-0.706886922474307,278.479856546737));
#760=CARTESIAN_POINT('',(-28.5010832813705,-0.706886922474307,278.851038104452));
#761=CARTESIAN_POINT('',(-28.7584389286006,-0.706886922474308,279.166833311872));
#762=CARTESIAN_POINT('',(-29.0488573278294,-0.706886922474307,279.409711694775));
#763=CARTESIAN_POINT('',(-29.32130228386,-0.706886922474307,279.542078834726));
#764=CARTESIAN_POINT('',(-29.4535267398134,-0.706886922474307,279.590604457426));
#765=CARTESIAN_POINT('',(-28.2635572979601,-0.673589949924239,277.373792050253));
#766=CARTESIAN_POINT('',(-28.2275547539826,-0.673589949924239,277.482686081882));
#767=CARTESIAN_POINT('',(-28.1840681722537,-0.673589949924239,277.711588036693));
#768=CARTESIAN_POINT('',(-28.1789464971941,-0.673589949924239,278.107903924368));
#769=CARTESIAN_POINT('',(-28.2595642488394,-0.673589949924239,278.50267342701));
#770=CARTESIAN_POINT('',(-28.4367646219037,-0.673589949924239,278.891212267031));
#771=CARTESIAN_POINT('',(-28.7062643370387,-0.673589949924239,279.220510630632));
#772=CARTESIAN_POINT('',(-29.0034119739624,-0.673589949924239,279.471272023555));
#773=CARTESIAN_POINT('',(-29.298673426759,-0.673589949924239,279.613490238353));
#774=CARTESIAN_POINT('',(-29.4402282566043,-0.673589949924239,279.665440055162));
#775=CARTESIAN_POINT('',(-28.2281808229585,-0.653751139998612,277.365593072581));
#776=CARTESIAN_POINT('',(-28.1917237761703,-0.653751139998612,277.475861802717));
#777=CARTESIAN_POINT('',(-28.1481557363009,-0.653751139998612,277.707068116843));
#778=CARTESIAN_POINT('',(-28.1426192437536,-0.653751139998612,278.111654292259));
#779=CARTESIAN_POINT('',(-28.2248468257859,-0.653751139998612,278.513699223242));
#780=CARTESIAN_POINT('',(-28.4056840583291,-0.653751139998612,278.910624969785));
#781=CARTESIAN_POINT('',(-28.6810545733997,-0.653751139998612,279.246449330353));
#782=CARTESIAN_POINT('',(-28.981444677986,-0.653751139998612,279.501016542213));
#783=CARTESIAN_POINT('',(-29.2877536806429,-0.653751139998612,279.648003130453));
#784=CARTESIAN_POINT('',(-29.4338021669417,-0.653751139998612,279.701602093602));
#785=CARTESIAN_POINT('',(-28.1613241598666,-0.60851645013398,277.350098134551));
#786=CARTESIAN_POINT('',(-28.1240051784675,-0.60851645013398,277.462973889758));
#787=CARTESIAN_POINT('',(-28.08028764554,-0.60851645013398,277.698521598603));
#788=CARTESIAN_POINT('',(-28.0739653875411,-0.60851645013398,278.118743276041));
#789=CARTESIAN_POINT('',(-28.1592355256565,-0.60851645013398,278.534536004992));
#790=CARTESIAN_POINT('',(-28.3469470890844,-0.60851645013398,278.947312786049));
#791=CARTESIAN_POINT('',(-28.6334076182855,-0.60851645013398,279.295468410314));
#792=CARTESIAN_POINT('',(-28.939943629441,-0.60851645013398,279.557234771521));
#793=CARTESIAN_POINT('',(-29.2670875458404,-0.60851645013398,279.713216980834));
#794=CARTESIAN_POINT('',(-29.4216577429552,-0.60851645013398,279.769943363347));
#795=CARTESIAN_POINT('',(-28.1296166415173,-0.582967168131605,277.342749487322));
#796=CARTESIAN_POINT('',(-28.0918902270804,-0.582967168131605,277.456857572838));
#797=CARTESIAN_POINT('',(-28.0480997849332,-0.582967168131605,277.694470346116));
#798=CARTESIAN_POINT('',(-28.0414056891897,-0.582967168131605,278.122104715982));
#799=CARTESIAN_POINT('',(-28.1281187062465,-0.582967168131605,278.544418286886));
#800=CARTESIAN_POINT('',(-28.319089961105,-0.582967168131605,278.964712171342));
#801=CARTESIAN_POINT('',(-28.6108123420609,-0.582967168131605,279.31871693842));
#802=CARTESIAN_POINT('',(-28.9202548196023,-0.582967168131605,279.583894514247));
#803=CARTESIAN_POINT('',(-29.2572998506735,-0.582967168131605,279.744150312936));
#804=CARTESIAN_POINT('',(-29.4158981143918,-0.582967168131605,279.802354972964));
#805=CARTESIAN_POINT('',(-28.0709233187695,-0.527057280923689,277.329146514085));
#806=CARTESIAN_POINT('',(-28.0324401122932,-0.527057280923689,277.445543608297));
#807=CARTESIAN_POINT('',(-27.9885185819772,-0.527057280923689,277.686967223345));
#808=CARTESIAN_POINT('',(-27.9811346015132,-0.527057280923689,278.128328163818));
#809=CARTESIAN_POINT('',(-28.0705186832838,-0.527057280923689,278.562710839273));
#810=CARTESIAN_POINT('',(-28.2675249212008,-0.527057280923689,278.996920338861));
#811=CARTESIAN_POINT('',(-28.5689830979015,-0.527057280923689,279.361750653196));
#812=CARTESIAN_POINT('',(-28.8838214332171,-0.527057280923689,279.633248487482));
#813=CARTESIAN_POINT('',(-29.2391564795468,-0.527057280923689,279.801401188111));
#814=CARTESIAN_POINT('',(-29.4052365503283,-0.527057280923689,279.862351628744));
#815=CARTESIAN_POINT('',(-28.0437387873836,-0.496507875172349,277.322846130402));
#816=CARTESIAN_POINT('',(-28.0049062202383,-0.496507875172349,277.440299908047));
#817=CARTESIAN_POINT('',(-27.9609222508408,-0.496507875172349,277.683493800122));
#818=CARTESIAN_POINT('',(-27.9532194452186,-0.496507875172349,278.13121012424));
#819=CARTESIAN_POINT('',(-28.043840588538,-0.496507875172349,278.571183435361));
#820=CARTESIAN_POINT('',(-28.2436415425584,-0.496507875172349,279.011837756772));
#821=CARTESIAN_POINT('',(-28.5496109350579,-0.496507875172349,279.381682830646));
#822=CARTESIAN_POINT('',(-28.8669413118866,-0.496507875172349,279.65610534406));
#823=CARTESIAN_POINT('',(-29.2307646886054,-0.496507875172349,279.827921865015));
#824=CARTESIAN_POINT('',(-29.400298516335,-0.496507875172349,279.890139814789));
#825=CARTESIAN_POINT('',(-27.9947822644898,-0.431468254618714,277.311499792531));
#826=CARTESIAN_POINT('',(-27.9553183854678,-0.431468254618714,277.430863049003));
#827=CARTESIAN_POINT('',(-27.9112251733194,-0.431468254618714,277.677235291936));
#828=CARTESIAN_POINT('',(-27.9029468887123,-0.431468254618714,278.136401175531));
#829=CARTESIAN_POINT('',(-27.9957959941937,-0.431468254618714,278.586441375904));
#830=CARTESIAN_POINT('',(-28.2006307835319,-0.431468254618714,279.038702827899));
#831=CARTESIAN_POINT('',(-28.5147208137709,-0.431468254618714,279.417577543678));
#832=CARTESIAN_POINT('',(-28.8365521317616,-0.431468254618714,279.697271910752));
#833=CARTESIAN_POINT('',(-29.2156308197011,-0.431468254618714,279.87567510265));
#834=CARTESIAN_POINT('',(-29.3914056290231,-0.431468254618714,279.940183457144));
#835=CARTESIAN_POINT('',(-27.9728452339471,-0.396759364046279,277.306415588308));
#836=CARTESIAN_POINT('',(-27.9330994018296,-0.396759364046279,277.426631645885));
#837=CARTESIAN_POINT('',(-27.8889558488016,-0.396759364046279,277.674432306905));
#838=CARTESIAN_POINT('',(-27.8804202637958,-0.396759364046279,278.138726836818));
#839=CARTESIAN_POINT('',(-27.9742676410895,-0.396759364046279,278.593278480519));
#840=CARTESIAN_POINT('',(-28.1813576815027,-0.396759364046279,279.050740701096));
#841=CARTESIAN_POINT('',(-28.499088086374,-0.396759364046279,279.433662152093));
#842=CARTESIAN_POINT('',(-28.822930507961,-0.396759364046279,279.715716679645));
#843=CARTESIAN_POINT('',(-29.20885874395,-0.396759364046279,279.897076360392));
#844=CARTESIAN_POINT('',(-29.3874207965831,-0.396759364046279,279.962607617316));
#845=CARTESIAN_POINT('',(-27.9349246807204,-0.324370060459069,277.297626986018));
#846=CARTESIAN_POINT('',(-27.8946898136691,-0.324370060459069,277.419322188669));
#847=CARTESIAN_POINT('',(-27.8504616973422,-0.324370060459069,277.669584562105));
#848=CARTESIAN_POINT('',(-27.8414803376751,-0.324370060459069,278.142747716642));
#849=CARTESIAN_POINT('',(-27.9370534458623,-0.324370060459069,278.605096912011));
#850=CARTESIAN_POINT('',(-28.1480425802403,-0.324370060459069,279.071549746752));
#851=CARTESIAN_POINT('',(-28.4720630102622,-0.324370060459069,279.461465331135));
#852=CARTESIAN_POINT('',(-28.7993918516963,-0.324370060459069,279.747603347141));
#853=CARTESIAN_POINT('',(-29.197136251096,-0.324370060459069,279.934064819065));
#854=CARTESIAN_POINT('',(-29.3805325784925,-0.324370060459069,280.00137022731));
#855=CARTESIAN_POINT('',(-27.9188138322123,-0.286447231559944,277.293893078465));
#856=CARTESIAN_POINT('',(-27.878371881501,-0.286447231559944,277.416214630594));
#857=CARTESIAN_POINT('',(-27.8341068143798,-0.286447231559944,277.667525992081));
#858=CARTESIAN_POINT('',(-27.8249364814046,-0.286447231559944,278.144455719235));
#859=CARTESIAN_POINT('',(-27.9212427354972,-0.286447231559944,278.610118171234));
#860=CARTESIAN_POINT('',(-28.133888158464,-0.286447231559944,279.080390523007));
#861=CARTESIAN_POINT('',(-28.4605821180561,-0.286447231559944,279.473278079445));
#862=CARTESIAN_POINT('',(-28.7893879782884,-0.286447231559944,279.761149442765));
#863=CARTESIAN_POINT('',(-29.1921626874172,-0.286447231559944,279.949782166585));
#864=CARTESIAN_POINT('',(-29.3776060642751,-0.286447231559944,280.01783883033));
#865=CARTESIAN_POINT('',(-27.8930399287691,-0.209013125118661,277.287919626932));
#866=CARTESIAN_POINT('',(-27.8522655653786,-0.209013125118661,277.411246601256));
#867=CARTESIAN_POINT('',(-27.8079430588868,-0.209013125118661,277.664231031987));
#868=CARTESIAN_POINT('',(-27.7984697257919,-0.209013125118661,278.147188648063));
#869=CARTESIAN_POINT('',(-27.8959489302296,-0.209013125118661,278.618150938606));
#870=CARTESIAN_POINT('',(-28.1112445010367,-0.209013125118661,279.094534051807));
#871=CARTESIAN_POINT('',(-28.4422136505788,-0.209013125118661,279.492175382042));
#872=CARTESIAN_POINT('',(-28.7733892559934,-0.209013125118661,279.782822250662));
#873=CARTESIAN_POINT('',(-29.1841949789885,-0.209013125118661,279.974922489131));
#874=CARTESIAN_POINT('',(-29.3729242689727,-0.209013125118661,280.04418506429));
#875=CARTESIAN_POINT('',(-27.883236345782,-0.169264888567315,277.28564751367));
#876=CARTESIAN_POINT('',(-27.8423359450185,-0.169264888567315,277.409355703213));
#877=CARTESIAN_POINT('',(-27.7979909913508,-0.169264888567315,277.662978337296));
#878=CARTESIAN_POINT('',(-27.7884026509891,-0.169264888567315,278.148227992619));
#879=CARTESIAN_POINT('',(-27.8863279827111,-0.169264888567315,278.621206412137));
#880=CARTESIAN_POINT('',(-28.1026314272687,-0.169264888567315,279.099913740128));
#881=CARTESIAN_POINT('',(-28.4352274040483,-0.169264888567315,279.499363524749));
#882=CARTESIAN_POINT('',(-28.7673019230608,-0.169264888567315,279.791065199452));
#883=CARTESIAN_POINT('',(-29.1811683050654,-0.169264888567315,279.984486542894));
#884=CARTESIAN_POINT('',(-29.3711434611537,-0.169264888567315,280.054206343821));
#885=CARTESIAN_POINT('',(-27.8732719984351,-0.108511785356164,277.283338141088));
#886=CARTESIAN_POINT('',(-27.832243114275,-0.108511785356164,277.407434944143));
#887=CARTESIAN_POINT('',(-27.7878759104562,-0.108511785356164,277.661704529912));
#888=CARTESIAN_POINT('',(-27.7781704462004,-0.108511785356164,278.149284546622));
#889=CARTESIAN_POINT('',(-27.8765492459829,-0.108511785356164,278.624311933256));
#890=CARTESIAN_POINT('',(-28.093877241146,-0.108511785356164,279.105381709038));
#891=CARTESIAN_POINT('',(-28.4281260856767,-0.108511785356164,279.50666935241));
#892=CARTESIAN_POINT('',(-28.7611165690558,-0.108511785356164,279.799443982914));
#893=CARTESIAN_POINT('',(-29.1780882542672,-0.108511785356164,279.994206059111));
#894=CARTESIAN_POINT('',(-29.3693334507025,-0.108511785356164,280.064391957616));
#895=CARTESIAN_POINT('',(-27.8707276346428,-0.0877651883695988,277.282748450286));
#896=CARTESIAN_POINT('',(-27.8296660065458,-0.0877651883695988,277.406944291323));
#897=CARTESIAN_POINT('',(-27.7852930260195,-0.0877651883695988,277.66137936341));
#898=CARTESIAN_POINT('',(-27.7755576934127,-0.0877651883695988,278.149554306341));
#899=CARTESIAN_POINT('',(-27.874052280614,-0.0877651883695988,278.625104927732));
#900=CARTESIAN_POINT('',(-28.0916418662319,-0.0877651883695988,279.10677792677));
#901=CARTESIAN_POINT('',(-28.4263128728319,-0.0877651883695988,279.508534903926));
#902=CARTESIAN_POINT('',(-28.7595368544366,-0.0877651883695988,279.80158336618));
#903=CARTESIAN_POINT('',(-29.177302405883,-0.0877651883695988,279.996688138229));
#904=CARTESIAN_POINT('',(-29.3688712704015,-0.0877651883695988,280.066992821079));
#905=CARTESIAN_POINT('',(-27.8673164072804,-0.046017303203549,277.2819578521));
#906=CARTESIAN_POINT('',(-27.8262108367338,-0.046017303203549,277.406286602369));
#907=CARTESIAN_POINT('',(-27.7818301749681,-0.046017303203549,277.660943348653));
#908=CARTESIAN_POINT('',(-27.7720547719205,-0.046017303203549,278.14991599172));
#909=CARTESIAN_POINT('',(-27.8707045980672,-0.046017303203549,278.626168088567));
#910=CARTESIAN_POINT('',(-28.0886449146779,-0.046017303203549,279.108649842172));
#911=CARTESIAN_POINT('',(-28.4238818420785,-0.046017303203549,279.511036026599));
#912=CARTESIAN_POINT('',(-28.7574191345886,-0.046017303203549,279.804451710882));
#913=CARTESIAN_POINT('',(-29.176248398006,-0.046017303203549,280.000015705939));
#914=CARTESIAN_POINT('',(-29.3682516254853,-0.046017303203549,280.070479797523));
#915=CARTESIAN_POINT('',(-27.8664584283285,-0.0249787624005116,277.281759003846));
#916=CARTESIAN_POINT('',(-27.8253418116911,-0.0249787624005116,277.406121164348));
#917=CARTESIAN_POINT('',(-27.7809592088081,-0.0249787624005116,277.660833693124));
#918=CARTESIAN_POINT('',(-27.7711737311337,-0.0249787624005116,278.150006958766));
#919=CARTESIAN_POINT('',(-27.8698626019909,-0.0249787624005116,278.62643549168));
#920=CARTESIAN_POINT('',(-28.0878911306916,-0.0249787624005116,279.109120658221));
#921=CARTESIAN_POINT('',(-28.423270406742,-0.0249787624005116,279.511665102577));
#922=CARTESIAN_POINT('',(-28.7568864643165,-0.0249787624005116,279.805173135236));
#923=CARTESIAN_POINT('',(-29.1759833590585,-0.0249787624005116,280.00085266556));
#924=CARTESIAN_POINT('',(-29.3680957747491,-0.0249787624005116,280.071356828596));
#925=CARTESIAN_POINT('',(-27.8664584283285,-0.00399458570124803,277.281759003846));
#926=CARTESIAN_POINT('',(-27.8253418017632,-0.00399458570124803,277.406121194376));
#927=CARTESIAN_POINT('',(-27.7809592136758,-0.00399458570124803,277.660833678192));
#928=CARTESIAN_POINT('',(-27.7711737299627,-0.00399458570124803,278.150006963105));
#929=CARTESIAN_POINT('',(-27.8698626014705,-0.00399458570124802,278.626435490169));
#930=CARTESIAN_POINT('',(-28.0878911340868,-0.00399458570124803,279.109120659837));
#931=CARTESIAN_POINT('',(-28.4232703934228,-0.00399458570124803,279.511665097591));
#932=CARTESIAN_POINT('',(-28.7568865116009,-0.00399458570124802,279.805173152615));
#933=CARTESIAN_POINT('',(-29.175983260833,-0.00399458570124803,280.000852629512));
#934=CARTESIAN_POINT('',(-29.3680957747491,-0.00399458570124803,280.071356828596));
#935=B_SPLINE_SURFACE_WITH_KNOTS('',3,3,((#135,#136,#137,#138,#139,#140,#141,#142,#143,#144),
(#145,#146,#147,#148,#149,#150,#151,#152,#153,#154),(#155,#156,#157,#158,#159,#160,#161,#162,
#163,#164),(#165,#166,#167,#168,#169,#170,#171,#172,#173,#174),(#175,#176,#177,#178,#179,#180,
#181,#182,#183,#184),(#185,#186,#187,#188,#189,#190,#191,#192,#193,#194),(#195,#196,#197,#198,
#199,#200,#201,#202,#203,#204),(#205,#206,#207,#208,#209,#210,#211,#212,#213,#214),(#215,#216,
#217,#218,#219,#220,#221,#222,#223,#224),(#225,#226,#227,#228,#229,#230,#231,#232,#233,#234),
(#235,#236,#237,#238,#239,#240,#241,#242,#243,#244),(#245,#246,#247,#248,#249,#250,#251,#252,
#253,#254),(#255,#256,#257,#258,#259,#260,#261,#262,#263,#264),(#265,#266,#267,#268,#269,#270,
#271,#272,#273,#274),(#275,#276,#277,#278,#279,#280,#281,#282,#283,#284),(#285,#286,#287,#288,
#289,#290,#291,#292,#293,#294),(#295,#296,#297,#298,#299,#300,#301,#302,#303,#304),(#305,#306,
#307,#308,#309,#310,#311,#312,#313,#314),(#315,#316,#317,#318,#319,#320,#321,#322,#323,#324),
(#325,#326,#327,#328,#329,#330,#331,#332,#333,#334),(#335,#336,#337,#338,#339,#340,#341,#342,
#343,#344),(#345,#346,#347,#348,#349,#350,#351,#352,#353,#354),(#355,#356,#357,#358,#359,#360,
#361,#362,#363,#364),(#365,#366,#367,#368,#369,#370,#371,#372,#373,#374),(#375,#376,#377,#378,
#379,#380,#381,#382,#383,#384),(#385,#386,#387,#388,#389,#390,#391,#392,#393,#394),(#395,#396,
#397,#398,#399,#400,#401,#402,#403,#404),(#405,#406,#407,#408,#409,#410,#411,#412,#413,#414),
(#415,#416,#417,#418,#419,#420,#421,#422,#423,#424),(#425,#426,#427,#428,#429,#430,#431,#432,
#433,#434),(#435,#436,#437,#438,#439,#440,#441,#442,#443,#444),(#445,#446,#447,#448,#449,#450,
#451,#452,#453,#454),(#455,#456,#457,#458,#459,#460,#461,#462,#463,#464),(#465,#466,#467,#468,
#469,#470,#471,#472,#473,#474),(#475,#476,#477,#478,#479,#480,#481,#482,#483,#484),(#485,#486,
#487,#488,#489,#490,#491,#492,#493,#494),(#495,#496,#497,#498,#499,#500,#501,#502,#503,#504),
(#505,#506,#507,#508,#509,#510,#511,#512,#513,#514),(#515,#516,#517,#518,#519,#520,#521,#522,
#523,#524),(#525,#526,#527,#528,#529,#530,#531,#532,#533,#534),(#535,#536,#537,#538,#539,#540,
#541,#542,#543,#544),(#545,#546,#547,#548,#549,#550,#551,#552,#553,#554),(#555,#556,#557,#558,
#559,#560,#561,#562,#563,#564),(#565,#566,#567,#568,#569,#570,#571,#572,#573,#574),(#575,#576,
#577,#578,#579,#580,#581,#582,#583,#584),(#585,#586,#587,#588,#589,#590,#591,#592,#593,#594),
(#595,#596,#597,#598,#599,#600,#601,#602,#603,#604),(#605,#606,#607,#608,#609,#610,#611,#612,
#613,#614),(#615,#616,#617,#618,#619,#620,#621,#622,#623,#624),(#625,#626,#627,#628,#629,#630,
#631,#632,#633,#634),(#635,#636,#637,#638,#639,#640,#641,#642,#643,#644),(#645,#646,#647,#648,
#649,#650,#651,#652,#653,#654),(#655,#656,#657,#658,#659,#660,#661,#662,#663,#664),(#665,#666,
#667,#668,#669,#670,#671,#672,#673,#674),(#675,#676,#677,#678,#679,#680,#681,#682,#683,#684),
(#685,#686,#687,#688,#689,#690,#691,#692,#693,#694),(#695,#696,#697,#698,#699,#700,#701,#702,
#703,#704),(#705,#706,#707,#708,#709,#710,#711,#712,#713,#714),(#715,#716,#717,#718,#719,#720,
#721,#722,#723,#724),(#725,#726,#727,#728,#729,#730,#731,#732,#733,#734),(#735,#736,#737,#738,
#739,#740,#741,#742,#743,#744),(#745,#746,#747,#748,#749,#750,#751,#752,#753,#754),(#755,#756,
#757,#758,#759,#760,#761,#762,#763,#764),(#765,#766,#767,#768,#769,#770,#771,#772,#773,#774),
(#775,#776,#777,#778,#779,#780,#781,#782,#783,#784),(#785,#786,#787,#788,#789,#790,#791,#792,
#793,#794),(#795,#796,#797,#798,#799,#800,#801,#802,#803,#804),(#805,#806,#807,#808,#809,#810,
#811,#812,#813,#814),(#815,#816,#817,#818,#819,#820,#821,#822,#823,#824),(#825,#826,#827,#828,
#829,#830,#831,#832,#833,#834),(#835,#836,#837,#838,#839,#840,#841,#842,#843,#844),(#845,#846,
#847,#848,#849,#850,#851,#852,#853,#854),(#855,#856,#857,#858,#859,#860,#861,#862,#863,#864),
(#865,#866,#867,#868,#869,#870,#871,#872,#873,#874),(#875,#876,#877,#878,#879,#880,#881,#882,
#883,#884),(#885,#886,#887,#888,#889,#890,#891,#892,#893,#894),(#895,#896,#897,#898,#899,#900,
#901,#902,#903,#904),(#905,#906,#907,#908,#909,#910,#911,#912,#913,#914),(#915,#916,#917,#918,
#919,#920,#921,#922,#923,#924),(#925,#926,#927,#928,#929,#930,#931,#932,#933,#934)),
.UNSPECIFIED.,.T.,.F.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,4),(4,1,1,1,1,1,1,4),(0.,0.0266348894440021,0.0532700108246565,0.0798704374059114,
0.106414259481978,0.132892909687705,0.159305018942029,0.185656482376742,0.211959734460337,
0.238232352812299,0.264495157268066,0.290757846623389,0.317020179224355,0.343281954452814,
0.369543034898715,0.395803360403781,0.422062952821431,0.448321911728348,0.474580402354162,
0.500838637559642,0.527096855864303,0.553355297476843,0.579614180197644,0.605873677055464,
0.632133897618359,0.658394874981209,0.684656560303664,0.710918826270962,0.737181479882505,
0.763444255685229,0.789706926708342,0.8159692501896,0.842231023360282,0.868492105902354,
0.894752434355685,0.921012027259863,0.947270981214913,0.97329719219047,0.986602029347378,1.),
(0.,0.130582366573738,0.270081040195266,0.41414845375694,0.560832499900795,0.71215414006426,
0.858692423653574,1.),.UNSPECIFIED.);
#936=CARTESIAN_POINT('',(-29.3680957747491,-0.00399458570124801,280.071356828596));
#937=CARTESIAN_POINT('',(-29.3680957747491,-0.0249787624005116,280.071356828596));
#938=CARTESIAN_POINT('',(-29.3682516254853,-0.046017303203549,280.070479797523));
#939=CARTESIAN_POINT('',(-29.3688712704015,-0.0877651883695988,280.066992821079));
#940=CARTESIAN_POINT('',(-29.3693334507025,-0.108511785356164,280.064391957616));
#941=CARTESIAN_POINT('',(-29.3711434611537,-0.169264888567315,280.054206343821));
#942=CARTESIAN_POINT('',(-29.3729242689727,-0.209013125118661,280.04418506429));
#943=CARTESIAN_POINT('',(-29.3776060642751,-0.286447231559944,280.01783883033));
#944=CARTESIAN_POINT('',(-29.3805325784925,-0.324370060459069,280.00137022731));
#945=CARTESIAN_POINT('',(-29.3874207965831,-0.396759364046279,279.962607617316));
#946=CARTESIAN_POINT('',(-29.3914056290231,-0.431468254618714,279.940183457144));
#947=CARTESIAN_POINT('',(-29.400298516335,-0.496507875172349,279.890139814789));
#948=CARTESIAN_POINT('',(-29.4052365503283,-0.527057280923689,279.862351628744));
#949=CARTESIAN_POINT('',(-29.4158981143918,-0.582967168131605,279.802354972964));
#950=CARTESIAN_POINT('',(-29.4216577429552,-0.60851645013398,279.769943363347));
#951=CARTESIAN_POINT('',(-29.4338021669417,-0.653751139998612,279.701602093602));
#952=CARTESIAN_POINT('',(-29.4402282566043,-0.673589949924239,279.665440055162));
#953=CARTESIAN_POINT('',(-29.4535267398134,-0.706886922474307,279.590604457426));
#954=CARTESIAN_POINT('',(-29.4604445182399,-0.720458420337075,279.551675500235));
#955=CARTESIAN_POINT('',(-29.4745339306018,-0.740880558648503,279.472389044835));
#956=CARTESIAN_POINT('',(-29.4817537789633,-0.747800902061117,279.431760225804));
#957=CARTESIAN_POINT('',(-29.4962469755803,-0.754769919930253,279.350201523591));
#958=CARTESIAN_POINT('',(-29.5035699915052,-0.754842419137764,279.308992141637));
#959=CARTESIAN_POINT('',(-29.5180674139482,-0.748160356393263,279.227409659102));
#960=CARTESIAN_POINT('',(-29.525291503424,-0.741382956020525,279.186756973715));
#961=CARTESIAN_POINT('',(-29.5393934575964,-0.72123967007688,279.107399940801));
#962=CARTESIAN_POINT('',(-29.5463195821184,-0.707805041777099,279.068424016972));
#963=CARTESIAN_POINT('',(-29.5596385398612,-0.674771040271489,278.993473201287));
#964=CARTESIAN_POINT('',(-29.5660768312853,-0.655059228047004,278.957242498916));
#965=CARTESIAN_POINT('',(-29.5782490581586,-0.61006439603559,278.888744771806));
#966=CARTESIAN_POINT('',(-29.5840243860467,-0.584628780161672,278.856244816147));
#967=CARTESIAN_POINT('',(-29.5947202762232,-0.528929173693141,278.796054994339));
#968=CARTESIAN_POINT('',(-29.5996770563389,-0.49847707761895,278.768161316769));
#969=CARTESIAN_POINT('',(-29.6086098208684,-0.433612627528457,278.717893270219));
#970=CARTESIAN_POINT('',(-29.6126159207987,-0.39898216696886,278.695349429831));
#971=CARTESIAN_POINT('',(-29.6195484638112,-0.326728428396875,278.656337386727));
#972=CARTESIAN_POINT('',(-29.6224981848116,-0.288863168079469,278.639738190356));
#973=CARTESIAN_POINT('',(-29.6272482125488,-0.211179920410293,278.613007986664));
#974=CARTESIAN_POINT('',(-29.6290644167531,-0.171102605758675,278.602787518277));
#975=CARTESIAN_POINT('',(-29.6315079623012,-0.0900813776589527,278.589036762735));
#976=CARTESIAN_POINT('',(-29.632143463874,-0.0488675633487051,278.585460554884));
#977=CARTESIAN_POINT('',(-29.632217065123,0.0333207382764462,278.585046372802));
#978=CARTESIAN_POINT('',(-29.6316554093222,0.0745688061764249,278.588207022547));
#979=CARTESIAN_POINT('',(-29.629357151866,0.155725812643358,278.601140187013));
#980=CARTESIAN_POINT('',(-29.6276128737926,0.195905079729282,278.610955899842));
#981=CARTESIAN_POINT('',(-29.6230024230762,0.273856648882463,278.636900650816));
#982=CARTESIAN_POINT('',(-29.6201208208933,0.311889129353778,278.653116516821));
#983=CARTESIAN_POINT('',(-29.6133184471969,0.384537245209217,278.691396047922));
#984=CARTESIAN_POINT('',(-29.6093748386973,0.419396127509962,278.71358822538));
#985=CARTESIAN_POINT('',(-29.600559316848,0.484771260759288,278.763196502999));
#986=CARTESIAN_POINT('',(-29.5956576902598,0.515507278002845,278.790779810797));
#987=CARTESIAN_POINT('',(-29.5850628657407,0.571820898375333,278.850400897904));
#988=CARTESIAN_POINT('',(-29.5793338016133,0.597588631870238,278.882640509873));
#989=CARTESIAN_POINT('',(-29.5672435846825,0.643284744868276,278.950676736001));
#990=CARTESIAN_POINT('',(-29.5608413286439,0.663368066006764,278.986704653619));
#991=CARTESIAN_POINT('',(-29.5475829278392,0.69717174783851,279.061314692496));
#992=CARTESIAN_POINT('',(-29.5406815409144,0.711007153337385,279.100151408504));
#993=CARTESIAN_POINT('',(-29.526616880877,0.731967310972703,279.179298573207));
#994=CARTESIAN_POINT('',(-29.5194054821286,0.739163596142722,279.219879843068));
#995=CARTESIAN_POINT('',(-29.5049209506742,0.7466868231282,279.301389783132));
#996=CARTESIAN_POINT('',(-29.497598181449,0.747039483058316,279.342597776813));
#997=CARTESIAN_POINT('',(-29.4830903479491,0.740910938697204,279.424238846305));
#998=CARTESIAN_POINT('',(-29.4758555792905,0.734406188590387,279.464951627495));
#999=CARTESIAN_POINT('',(-29.4617164529688,0.714778435617899,279.544517842161));
#1000=CARTESIAN_POINT('',(-29.4547639544501,0.701580433358093,279.58364218245));
#1001=CARTESIAN_POINT('',(-29.4413746513166,0.668950802730688,279.658988858271));
#1002=CARTESIAN_POINT('',(-29.4348928130186,0.649395828230682,279.69546461538));
#1003=CARTESIAN_POINT('',(-29.4226185156475,0.604601461708894,279.764536731809));
#1004=CARTESIAN_POINT('',(-29.416785474156,0.5791952677917,279.797361463756));
#1005=CARTESIAN_POINT('',(-29.4059663816574,0.523405107216007,279.858244591656));
#1006=CARTESIAN_POINT('',(-29.400945281085,0.49281707197745,279.886500224777));
#1007=CARTESIAN_POINT('',(-29.3918868656794,0.427515762884698,279.937475356359));
#1008=CARTESIAN_POINT('',(-29.3878208303316,0.392568086898858,279.960356476024));
#1009=CARTESIAN_POINT('',(-29.3807837277862,0.319528344927461,279.999956915189));
#1010=CARTESIAN_POINT('',(-29.3777907977711,0.281178703533352,280.016799265037));
#1011=CARTESIAN_POINT('',(-29.3729816278009,0.202429887990013,280.043862284457));
#1012=CARTESIAN_POINT('',(-29.3711503919263,0.161757678873394,280.054167341741));
#1013=CARTESIAN_POINT('',(-29.3687116539797,0.0795443413324496,280.06789104309));
#1014=CARTESIAN_POINT('',(-29.3680957747491,0.037721524965773,280.071356828596));
#1015=CARTESIAN_POINT('',(-29.3680957747491,-0.00399458570124801,280.071356828596));
#1016=B_SPLINE_CURVE_WITH_KNOTS('',3,(#936,#937,#938,#939,#940,#941,#942,#943,#944,#945,#946,
#947,#948,#949,#950,#951,#952,#953,#954,#955,#956,#957,#958,#959,#960,#961,#962,#963,#964,#965,
#966,#967,#968,#969,#970,#971,#972,#973,#974,#975,#976,#977,#978,#979,#980,#981,#982,#983,#984,
#985,#986,#987,#988,#989,#990,#991,#992,#993,#994,#995,#996,#997,#998,#999,#1000,#1001,#1002,
#1003,#1004,#1005,#1006,#1007,#1008,#1009,#1010,#1011,#1012,#1013,#1014,#1015),.UNSPECIFIED.,
.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,
0.0133979706526223,0.0267028078095297,0.0527290187850871,0.0789879727401366,0.105247565644315,
0.131507894097646,0.157768976639718,0.1840307498104,0.210293073291658,0.236555744314771,
0.262818520117495,0.289081173729038,0.315343439696336,0.341605125018791,0.367866102381641,
0.394126322944536,0.420385819802356,0.446644702523157,0.472903144135697,0.499161362440358,
0.525419597645838,0.551678088271652,0.577937047178569,0.604196639596219,0.630456965101285,
0.656718045547186,0.682979820775645,0.709242153376611,0.735504842731934,0.761767647187701,
0.788040265539663,0.814343517623258,0.840694981057971,0.867107090312295,0.893585740518022,
0.920129562594089,0.946729989175343,0.973365110555998,1.),.UNSPECIFIED.);
#1017=CARTESIAN_POINT('',(-29.3680957747491,-0.00399458570124801,280.071356828596));
#1018=VERTEX_POINT('',#1017);
#1019=EDGE_CURVE('E64',#1018,#1018,#1016,.T.);
#1020=ORIENTED_EDGE('',*,*,#121,.T.);
#1021=EDGE_LOOP('',(#1020));
#1022=FACE_BOUND('',#1021,.T.);
#1023=ORIENTED_EDGE('',*,*,#1019,.T.);
#1024=EDGE_LOOP('',(#1023));
#1025=FACE_BOUND('',#1024,.T.);
#1026=ADVANCED_FACE('F89',(#1022,#1025),#935,.T.);
#1027=CARTESIAN_POINT('',(-29.3680957747491,-0.00399458570124801,280.071356828596));
#1028=CARTESIAN_POINT('',(-33.0000000000053,-0.00399458570124801,280.071356828596));
#1029=CARTESIAN_POINT('',(-29.3680957747491,-0.0249787624005116,280.071356828596));
#1030=CARTESIAN_POINT('',(-33.0000000000053,-0.0249787624005116,280.071356828596));
#1031=CARTESIAN_POINT('',(-29.3682516254853,-0.046017303203549,280.070479797523));
#1032=CARTESIAN_POINT('',(-33.0000000000053,-0.046017303203549,280.070479797523));
#1033=CARTESIAN_POINT('',(-29.3688712704015,-0.0877651883695988,280.066992821079));
#1034=CARTESIAN_POINT('',(-33.0000000000053,-0.0877651883695988,280.066992821079));
#1035=CARTESIAN_POINT('',(-29.3693334507025,-0.108511785356164,280.064391957616));
#1036=CARTESIAN_POINT('',(-33.0000000000053,-0.108511785356164,280.064391957616));
#1037=CARTESIAN_POINT('',(-29.3711434611537,-0.169264888567315,280.054206343821));
#1038=CARTESIAN_POINT('',(-33.0000000000053,-0.169264888567315,280.054206343821));
#1039=CARTESIAN_POINT('',(-29.3729242689727,-0.209013125118661,280.04418506429));
#1040=CARTESIAN_POINT('',(-33.0000000000053,-0.209013125118661,280.04418506429));
#1041=CARTESIAN_POINT('',(-29.3776060642751,-0.286447231559944,280.01783883033));
#1042=CARTESIAN_POINT('',(-33.0000000000053,-0.286447231559944,280.01783883033));
#1043=CARTESIAN_POINT('',(-29.3805325784925,-0.324370060459069,280.00137022731));
#1044=CARTESIAN_POINT('',(-33.0000000000053,-0.324370060459069,280.00137022731));
#1045=CARTESIAN_POINT('',(-29.3874207965831,-0.396759364046279,279.962607617316));
#1046=CARTESIAN_POINT('',(-33.0000000000053,-0.396759364046279,279.962607617316));
#1047=CARTESIAN_POINT('',(-29.3914056290231,-0.431468254618714,279.940183457144));
#1048=CARTESIAN_POINT('',(-33.0000000000053,-0.431468254618714,279.940183457144));
#1049=CARTESIAN_POINT('',(-29.400298516335,-0.496507875172349,279.890139814789));
#1050=CARTESIAN_POINT('',(-33.0000000000053,-0.496507875172349,279.890139814789));
#1051=CARTESIAN_POINT('',(-29.4052365503283,-0.527057280923689,279.862351628744));
#1052=CARTESIAN_POINT('',(-33.0000000000053,-0.527057280923689,279.862351628744));
#1053=CARTESIAN_POINT('',(-29.4158981143918,-0.582967168131605,279.802354972964));
#1054=CARTESIAN_POINT('',(-33.0000000000053,-0.582967168131605,279.802354972964));
#1055=CARTESIAN_POINT('',(-29.4216577429552,-0.60851645013398,279.769943363347));
#1056=CARTESIAN_POINT('',(-33.0000000000053,-0.60851645013398,279.769943363347));
#1057=CARTESIAN_POINT('',(-29.4338021669417,-0.653751139998612,279.701602093602));
#1058=CARTESIAN_POINT('',(-33.0000000000053,-0.653751139998612,279.701602093602));
#1059=CARTESIAN_POINT('',(-29.4402282566043,-0.673589949924239,279.665440055162));
#1060=CARTESIAN_POINT('',(-33.0000000000053,-0.673589949924239,279.665440055162));
#1061=CARTESIAN_POINT('',(-29.4535267398134,-0.706886922474307,279.590604457426));
#1062=CARTESIAN_POINT('',(-33.0000000000053,-0.706886922474307,279.590604457426));
#1063=CARTESIAN_POINT('',(-29.4604445182399,-0.720458420337075,279.551675500235));
#1064=CARTESIAN_POINT('',(-33.0000000000053,-0.720458420337075,279.551675500235));
#1065=CARTESIAN_POINT('',(-29.4745339306018,-0.740880558648503,279.472389044835));
#1066=CARTESIAN_POINT('',(-33.0000000000053,-0.740880558648503,279.472389044835));
#1067=CARTESIAN_POINT('',(-29.4817537789633,-0.747800902061117,279.431760225804));
#1068=CARTESIAN_POINT('',(-33.0000000000053,-0.747800902061117,279.431760225804));
#1069=CARTESIAN_POINT('',(-29.4962469755803,-0.754769919930253,279.350201523591));
#1070=CARTESIAN_POINT('',(-33.0000000000053,-0.754769919930253,279.350201523591));
#1071=CARTESIAN_POINT('',(-29.5035699915052,-0.754842419137764,279.308992141637));
#1072=CARTESIAN_POINT('',(-33.0000000000053,-0.754842419137764,279.308992141637));
#1073=CARTESIAN_POINT('',(-29.5180674139482,-0.748160356393263,279.227409659102));
#1074=CARTESIAN_POINT('',(-33.0000000000053,-0.748160356393263,279.227409659102));
#1075=CARTESIAN_POINT('',(-29.525291503424,-0.741382956020525,279.186756973715));
#1076=CARTESIAN_POINT('',(-33.0000000000053,-0.741382956020525,279.186756973715));
#1077=CARTESIAN_POINT('',(-29.5393934575964,-0.72123967007688,279.107399940801));
#1078=CARTESIAN_POINT('',(-33.0000000000053,-0.72123967007688,279.107399940801));
#1079=CARTESIAN_POINT('',(-29.5463195821184,-0.707805041777099,279.068424016972));
#1080=CARTESIAN_POINT('',(-33.0000000000053,-0.707805041777099,279.068424016972));
#1081=CARTESIAN_POINT('',(-29.5596385398612,-0.674771040271489,278.993473201287));
#1082=CARTESIAN_POINT('',(-33.0000000000053,-0.674771040271489,278.993473201287));
#1083=CARTESIAN_POINT('',(-29.5660768312853,-0.655059228047004,278.957242498916));
#1084=CARTESIAN_POINT('',(-33.0000000000053,-0.655059228047004,278.957242498916));
#1085=CARTESIAN_POINT('',(-29.5782490581586,-0.61006439603559,278.888744771806));
#1086=CARTESIAN_POINT('',(-33.0000000000053,-0.61006439603559,278.888744771806));
#1087=CARTESIAN_POINT('',(-29.5840243860467,-0.584628780161672,278.856244816147));
#1088=CARTESIAN_POINT('',(-33.0000000000053,-0.584628780161672,278.856244816147));
#1089=CARTESIAN_POINT('',(-29.5947202762232,-0.528929173693141,278.796054994339));
#1090=CARTESIAN_POINT('',(-33.0000000000053,-0.528929173693141,278.796054994339));
#1091=CARTESIAN_POINT('',(-29.5996770563389,-0.49847707761895,278.768161316769));
#1092=CARTESIAN_POINT('',(-33.0000000000053,-0.49847707761895,278.768161316769));
#1093=CARTESIAN_POINT('',(-29.6086098208684,-0.433612627528457,278.717893270219));
#1094=CARTESIAN_POINT('',(-33.0000000000053,-0.433612627528457,278.717893270219));
#1095=CARTESIAN_POINT('',(-29.6126159207987,-0.39898216696886,278.695349429831));
#1096=CARTESIAN_POINT('',(-33.0000000000053,-0.39898216696886,278.695349429831));
#1097=CARTESIAN_POINT('',(-29.6195484638112,-0.326728428396875,278.656337386727));
#1098=CARTESIAN_POINT('',(-33.0000000000053,-0.326728428396875,278.656337386727));
#1099=CARTESIAN_POINT('',(-29.6224981848116,-0.288863168079469,278.639738190356));
#1100=CARTESIAN_POINT('',(-33.0000000000053,-0.288863168079469,278.639738190356));
#1101=CARTESIAN_POINT('',(-29.6272482125488,-0.211179920410293,278.613007986664));
#1102=CARTESIAN_POINT('',(-33.0000000000053,-0.211179920410293,278.613007986664));
#1103=CARTESIAN_POINT('',(-29.6290644167531,-0.171102605758675,278.602787518277));
#1104=CARTESIAN_POINT('',(-33.0000000000053,-0.171102605758675,278.602787518277));
#1105=CARTESIAN_POINT('',(-29.6315079623012,-0.0900813776589527,278.589036762735));
#1106=CARTESIAN_POINT('',(-33.0000000000053,-0.0900813776589527,278.589036762735));
#1107=CARTESIAN_POINT('',(-29.632143463874,-0.0488675633487051,278.585460554884));
#1108=CARTESIAN_POINT('',(-33.0000000000053,-0.0488675633487051,278.585460554884));
#1109=CARTESIAN_POINT('',(-29.632217065123,0.0333207382764462,278.585046372802));
#1110=CARTESIAN_POINT('',(-33.0000000000053,0.0333207382764462,278.585046372802));
#1111=CARTESIAN_POINT('',(-29.6316554093222,0.0745688061764249,278.588207022547));
#1112=CARTESIAN_POINT('',(-33.0000000000053,0.0745688061764249,278.588207022547));
#1113=CARTESIAN_POINT('',(-29.629357151866,0.155725812643358,278.601140187013));
#1114=CARTESIAN_POINT('',(-33.0000000000053,0.155725812643358,278.601140187013));
#1115=CARTESIAN_POINT('',(-29.6276128737926,0.195905079729282,278.610955899842));
#1116=CARTESIAN_POINT('',(-33.0000000000053,0.195905079729282,278.610955899842));
#1117=CARTESIAN_POINT('',(-29.6230024230762,0.273856648882463,278.636900650816));
#1118=CARTESIAN_POINT('',(-33.0000000000053,0.273856648882463,278.636900650816));
#1119=CARTESIAN_POINT('',(-29.6201208208933,0.311889129353778,278.653116516821));
#1120=CARTESIAN_POINT('',(-33.0000000000053,0.311889129353778,278.653116516821));
#1121=CARTESIAN_POINT('',(-29.6133184471969,0.384537245209217,278.691396047922));
#1122=CARTESIAN_POINT('',(-33.0000000000053,0.384537245209217,278.691396047922));
#1123=CARTESIAN_POINT('',(-29.6093748386973,0.419396127509962,278.71358822538));
#1124=CARTESIAN_POINT('',(-33.0000000000053,0.419396127509962,278.71358822538));
#1125=CARTESIAN_POINT('',(-29.600559316848,0.484771260759288,278.763196502999));
#1126=CARTESIAN_POINT('',(-33.0000000000053,0.484771260759288,278.763196502999));
#1127=CARTESIAN_POINT('',(-29.5956576902598,0.515507278002845,278.790779810797));
#1128=CARTESIAN_POINT('',(-33.0000000000053,0.515507278002845,278.790779810797));
#1129=CARTESIAN_POINT('',(-29.5850628657407,0.571820898375333,278.850400897904));
#1130=CARTESIAN_POINT('',(-33.0000000000053,0.571820898375333,278.850400897904));
#1131=CARTESIAN_POINT('',(-29.5793338016133,0.597588631870238,278.882640509873));
#1132=CARTESIAN_POINT('',(-33.0000000000053,0.597588631870238,278.882640509873));
#1133=CARTESIAN_POINT('',(-29.5672435846825,0.643284744868276,278.950676736001));
#1134=CARTESIAN_POINT('',(-33.0000000000053,0.643284744868276,278.950676736001));
#1135=CARTESIAN_POINT('',(-29.5608413286439,0.663368066006764,278.986704653619));
#1136=CARTESIAN_POINT('',(-33.0000000000053,0.663368066006764,278.986704653619));
#1137=CARTESIAN_POINT('',(-29.5475829278392,0.69717174783851,279.061314692496));
#1138=CARTESIAN_POINT('',(-33.0000000000053,0.69717174783851,279.061314692496));
#1139=CARTESIAN_POINT('',(-29.5406815409144,0.711007153337385,279.100151408504));
#1140=CARTESIAN_POINT('',(-33.0000000000053,0.711007153337385,279.100151408504));
#1141=CARTESIAN_POINT('',(-29.526616880877,0.731967310972703,279.179298573207));
#1142=CARTESIAN_POINT('',(-33.0000000000053,0.731967310972703,279.179298573207));
#1143=CARTESIAN_POINT('',(-29.5194054821286,0.739163596142722,279.219879843068));
#1144=CARTESIAN_POINT('',(-33.0000000000053,0.739163596142722,279.219879843068));
#1145=CARTESIAN_POINT('',(-29.5049209506742,0.7466868231282,279.301389783132));
#1146=CARTESIAN_POINT('',(-33.0000000000053,0.7466868231282,279.301389783132));
#1147=CARTESIAN_POINT('',(-29.497598181449,0.747039483058316,279.342597776813));
#1148=CARTESIAN_POINT('',(-33.0000000000053,0.747039483058316,279.342597776813));
#1149=CARTESIAN_POINT('',(-29.4830903479491,0.740910938697204,279.424238846305));
#1150=CARTESIAN_POINT('',(-33.0000000000053,0.740910938697204,279.424238846305));
#1151=CARTESIAN_POINT('',(-29.4758555792905,0.734406188590387,279.464951627495));
#1152=CARTESIAN_POINT('',(-33.0000000000053,0.734406188590387,279.464951627495));
#1153=CARTESIAN_POINT('',(-29.4617164529688,0.714778435617899,279.544517842161));
#1154=CARTESIAN_POINT('',(-33.0000000000053,0.714778435617899,279.544517842161));
#1155=CARTESIAN_POINT('',(-29.4547639544501,0.701580433358093,279.58364218245));
#1156=CARTESIAN_POINT('',(-33.0000000000053,0.701580433358093,279.58364218245));
#1157=CARTESIAN_POINT('',(-29.4413746513166,0.668950802730688,279.658988858271));
#1158=CARTESIAN_POINT('',(-33.0000000000053,0.668950802730688,279.658988858271));
#1159=CARTESIAN_POINT('',(-29.4348928130186,0.649395828230682,279.69546461538));
#1160=CARTESIAN_POINT('',(-33.0000000000053,0.649395828230682,279.69546461538));
#1161=CARTESIAN_POINT('',(-29.4226185156475,0.604601461708894,279.764536731809));
#1162=CARTESIAN_POINT('',(-33.0000000000053,0.604601461708894,279.764536731809));
#1163=CARTESIAN_POINT('',(-29.416785474156,0.5791952677917,279.797361463756));
#1164=CARTESIAN_POINT('',(-33.0000000000053,0.5791952677917,279.797361463756));
#1165=CARTESIAN_POINT('',(-29.4059663816574,0.523405107216007,279.858244591656));
#1166=CARTESIAN_POINT('',(-33.0000000000053,0.523405107216007,279.858244591656));
#1167=CARTESIAN_POINT('',(-29.400945281085,0.49281707197745,279.886500224777));
#1168=CARTESIAN_POINT('',(-33.0000000000053,0.49281707197745,279.886500224777));
#1169=CARTESIAN_POINT('',(-29.3918868656794,0.427515762884698,279.937475356359));
#1170=CARTESIAN_POINT('',(-33.0000000000053,0.427515762884698,279.937475356359));
#1171=CARTESIAN_POINT('',(-29.3878208303316,0.392568086898858,279.960356476024));
#1172=CARTESIAN_POINT('',(-33.0000000000053,0.392568086898858,279.960356476024));
#1173=CARTESIAN_POINT('',(-29.3807837277862,0.319528344927461,279.999956915189));
#1174=CARTESIAN_POINT('',(-33.0000000000053,0.319528344927461,279.999956915189));
#1175=CARTESIAN_POINT('',(-29.3777907977711,0.281178703533352,280.016799265037));
#1176=CARTESIAN_POINT('',(-33.0000000000053,0.281178703533352,280.016799265037));
#1177=CARTESIAN_POINT('',(-29.3729816278009,0.202429887990013,280.043862284457));
#1178=CARTESIAN_POINT('',(-33.0000000000053,0.202429887990013,280.043862284457));
#1179=CARTESIAN_POINT('',(-29.3711503919263,0.161757678873394,280.054167341741));
#1180=CARTESIAN_POINT('',(-33.0000000000053,0.161757678873394,280.054167341741));
#1181=CARTESIAN_POINT('',(-29.3687116539797,0.0795443413324496,280.06789104309));
#1182=CARTESIAN_POINT('',(-33.0000000000053,0.0795443413324496,280.06789104309));
#1183=CARTESIAN_POINT('',(-29.3680957747491,0.037721524965773,280.071356828596));
#1184=CARTESIAN_POINT('',(-33.0000000000053,0.037721524965773,280.071356828596));
#1185=CARTESIAN_POINT('',(-29.3680957747491,-0.00399458570124801,280.071356828596));
#1186=CARTESIAN_POINT('',(-33.0000000000053,-0.00399458570124801,280.071356828596));
#1187=B_SPLINE_SURFACE_WITH_KNOTS('',3,1,((#1027,#1028),(#1029,#1030),(#1031,#1032),(#1033,
#1034),(#1035,#1036),(#1037,#1038),(#1039,#1040),(#1041,#1042),(#1043,#1044),(#1045,#1046),
(#1047,#1048),(#1049,#1050),(#1051,#1052),(#1053,#1054),(#1055,#1056),(#1057,#1058),(#1059,
#1060),(#1061,#1062),(#1063,#1064),(#1065,#1066),(#1067,#1068),(#1069,#1070),(#1071,#1072),
(#1073,#1074),(#1075,#1076),(#1077,#1078),(#1079,#1080),(#1081,#1082),(#1083,#1084),(#1085,
#1086),(#1087,#1088),(#1089,#1090),(#1091,#1092),(#1093,#1094),(#1095,#1096),(#1097,#1098),
(#1099,#1100),(#1101,#1102),(#1103,#1104),(#1105,#1106),(#1107,#1108),(#1109,#1110),(#1111,
#1112),(#1113,#1114),(#1115,#1116),(#1117,#1118),(#1119,#1120),(#1121,#1122),(#1123,#1124),
(#1125,#1126),(#1127,#1128),(#1129,#1130),(#1131,#1132),(#1133,#1134),(#1135,#1136),(#1137,
#1138),(#1139,#1140),(#1141,#1142),(#1143,#1144),(#1145,#1146),(#1147,#1148),(#1149,#1150),
(#1151,#1152),(#1153,#1154),(#1155,#1156),(#1157,#1158),(#1159,#1160),(#1161,#1162),(#1163,
#1164),(#1165,#1166),(#1167,#1168),(#1169,#1170),(#1171,#1172),(#1173,#1174),(#1175,#1176),
(#1177,#1178),(#1179,#1180),(#1181,#1182),(#1183,#1184),(#1185,#1186)),.UNSPECIFIED.,.T.,.F.,
.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(2,2),(0.,
0.0133979706526223,0.0267028078095297,0.0527290187850871,0.0789879727401366,0.105247565644315,
0.131507894097646,0.157768976639718,0.1840307498104,0.210293073291658,0.236555744314771,
0.262818520117495,0.289081173729038,0.315343439696336,0.341605125018791,0.367866102381641,
0.394126322944536,0.420385819802356,0.446644702523157,0.472903144135697,0.499161362440358,
0.525419597645838,0.551678088271652,0.577937047178569,0.604196639596219,0.630456965101285,
0.656718045547186,0.682979820775645,0.709242153376611,0.735504842731934,0.761767647187701,
0.788040265539663,0.814343517623258,0.840694981057971,0.867107090312295,0.893585740518022,
0.920129562594089,0.946729989175343,0.973365110555998,1.),(0.,1.),.UNSPECIFIED.);
#1188=CARTESIAN_POINT('',(-33.0000000000053,-0.00399458570124801,280.071356828596));
#1189=CARTESIAN_POINT('',(-33.0000000000053,-0.0249787624005116,280.071356828596));
#1190=CARTESIAN_POINT('',(-33.0000000000053,-0.046017303203549,280.070479797523));
#1191=CARTESIAN_POINT('',(-33.0000000000053,-0.0877651883695988,280.066992821079));
#1192=CARTESIAN_POINT('',(-33.0000000000053,-0.108511785356164,280.064391957616));
#1193=CARTESIAN_POINT('',(-33.0000000000053,-0.169264888567315,280.054206343821));
#1194=CARTESIAN_POINT('',(-33.0000000000053,-0.209013125118661,280.04418506429));
#1195=CARTESIAN_POINT('',(-33.0000000000053,-0.286447231559944,280.01783883033));
#1196=CARTESIAN_POINT('',(-33.0000000000053,-0.324370060459069,280.00137022731));
#1197=CARTESIAN_POINT('',(-33.0000000000053,-0.396759364046279,279.962607617316));
#1198=CARTESIAN_POINT('',(-33.0000000000053,-0.431468254618714,279.940183457144));
#1199=CARTESIAN_POINT('',(-33.0000000000053,-0.496507875172349,279.890139814789));
#1200=CARTESIAN_POINT('',(-33.0000000000053,-0.527057280923689,279.862351628744));
#1201=CARTESIAN_POINT('',(-33.0000000000053,-0.582967168131605,279.802354972964));
#1202=CARTESIAN_POINT('',(-33.0000000000053,-0.60851645013398,279.769943363347));
#1203=CARTESIAN_POINT('',(-33.0000000000053,-0.653751139998612,279.701602093602));
#1204=CARTESIAN_POINT('',(-33.0000000000053,-0.673589949924239,279.665440055162));
#1205=CARTESIAN_POINT('',(-33.0000000000053,-0.706886922474307,279.590604457426));
#1206=CARTESIAN_POINT('',(-33.0000000000053,-0.720458420337075,279.551675500235));
#1207=CARTESIAN_POINT('',(-33.0000000000053,-0.740880558648503,279.472389044835));
#1208=CARTESIAN_POINT('',(-33.0000000000053,-0.747800902061117,279.431760225804));
#1209=CARTESIAN_POINT('',(-33.0000000000053,-0.754769919930253,279.350201523591));
#1210=CARTESIAN_POINT('',(-33.0000000000053,-0.754842419137764,279.308992141637));
#1211=CARTESIAN_POINT('',(-33.0000000000053,-0.748160356393263,279.227409659102));
#1212=CARTESIAN_POINT('',(-33.0000000000053,-0.741382956020525,279.186756973715));
#1213=CARTESIAN_POINT('',(-33.0000000000053,-0.72123967007688,279.107399940801));
#1214=CARTESIAN_POINT('',(-33.0000000000053,-0.707805041777099,279.068424016972));
#1215=CARTESIAN_POINT('',(-33.0000000000053,-0.674771040271489,278.993473201287));
#1216=CARTESIAN_POINT('',(-33.0000000000053,-0.655059228047004,278.957242498916));
#1217=CARTESIAN_POINT('',(-33.0000000000053,-0.61006439603559,278.888744771806));
#1218=CARTESIAN_POINT('',(-33.0000000000053,-0.584628780161672,278.856244816147));
#1219=CARTESIAN_POINT('',(-33.0000000000053,-0.528929173693141,278.796054994339));
#1220=CARTESIAN_POINT('',(-33.0000000000053,-0.49847707761895,278.768161316769));
#1221=CARTESIAN_POINT('',(-33.0000000000053,-0.433612627528457,278.717893270219));
#1222=CARTESIAN_POINT('',(-33.0000000000053,-0.39898216696886,278.695349429831));
#1223=CARTESIAN_POINT('',(-33.0000000000053,-0.326728428396875,278.656337386727));
#1224=CARTESIAN_POINT('',(-33.0000000000053,-0.288863168079469,278.639738190356));
#1225=CARTESIAN_POINT('',(-33.0000000000053,-0.211179920410293,278.613007986664));
#1226=CARTESIAN_POINT('',(-33.0000000000053,-0.171102605758675,278.602787518277));
#1227=CARTESIAN_POINT('',(-33.0000000000053,-0.0900813776589527,278.589036762735));
#1228=CARTESIAN_POINT('',(-33.0000000000053,-0.0488675633487051,278.585460554884));
#1229=CARTESIAN_POINT('',(-33.0000000000053,0.0333207382764462,278.585046372802));
#1230=CARTESIAN_POINT('',(-33.0000000000053,0.0745688061764249,278.588207022547));
#1231=CARTESIAN_POINT('',(-33.0000000000053,0.155725812643358,278.601140187013));
#1232=CARTESIAN_POINT('',(-33.0000000000053,0.195905079729282,278.610955899842));
#1233=CARTESIAN_POINT('',(-33.0000000000053,0.273856648882463,278.636900650816));
#1234=CARTESIAN_POINT('',(-33.0000000000053,0.311889129353778,278.653116516821));
#1235=CARTESIAN_POINT('',(-33.0000000000053,0.384537245209217,278.691396047922));
#1236=CARTESIAN_POINT('',(-33.0000000000053,0.419396127509962,278.71358822538));
#1237=CARTESIAN_POINT('',(-33.0000000000053,0.484771260759288,278.763196502999));
#1238=CARTESIAN_POINT('',(-33.0000000000053,0.515507278002845,278.790779810797));
#1239=CARTESIAN_POINT('',(-33.0000000000053,0.571820898375333,278.850400897904));
#1240=CARTESIAN_POINT('',(-33.0000000000053,0.597588631870238,278.882640509873));
#1241=CARTESIAN_POINT('',(-33.0000000000053,0.643284744868276,278.950676736001));
#1242=CARTESIAN_POINT('',(-33.0000000000053,0.663368066006764,278.986704653619));
#1243=CARTESIAN_POINT('',(-33.0000000000053,0.69717174783851,279.061314692496));
#1244=CARTESIAN_POINT('',(-33.0000000000053,0.711007153337385,279.100151408504));
#1245=CARTESIAN_POINT('',(-33.0000000000053,0.731967310972703,279.179298573207));
#1246=CARTESIAN_POINT('',(-33.0000000000053,0.739163596142722,279.219879843068));
#1247=CARTESIAN_POINT('',(-33.0000000000053,0.7466868231282,279.301389783132));
#1248=CARTESIAN_POINT('',(-33.0000000000053,0.747039483058316,279.342597776813));
#1249=CARTESIAN_POINT('',(-33.0000000000053,0.740910938697204,279.424238846305));
#1250=CARTESIAN_POINT('',(-33.0000000000053,0.734406188590387,279.464951627495));
#1251=CARTESIAN_POINT('',(-33.0000000000053,0.714778435617899,279.544517842161));
#1252=CARTESIAN_POINT('',(-33.0000000000053,0.701580433358093,279.58364218245));
#1253=CARTESIAN_POINT('',(-33.0000000000053,0.668950802730688,279.658988858271));
#1254=CARTESIAN_POINT('',(-33.0000000000053,0.649395828230682,279.69546461538));
#1255=CARTESIAN_POINT('',(-33.0000000000053,0.604601461708894,279.764536731809));
#1256=CARTESIAN_POINT('',(-33.0000000000053,0.5791952677917,279.797361463756));
#1257=CARTESIAN_POINT('',(-33.0000000000053,0.523405107216007,279.858244591656));
#1258=CARTESIAN_POINT('',(-33.0000000000053,0.49281707197745,279.886500224777));
#1259=CARTESIAN_POINT('',(-33.0000000000053,0.427515762884698,279.937475356359));
#1260=CARTESIAN_POINT('',(-33.0000000000053,0.392568086898858,279.960356476024));
#1261=CARTESIAN_POINT('',(-33.0000000000053,0.319528344927461,279.999956915189));
#1262=CARTESIAN_POINT('',(-33.0000000000053,0.281178703533352,280.016799265037));
#1263=CARTESIAN_POINT('',(-33.0000000000053,0.202429887990013,280.043862284457));
#1264=CARTESIAN_POINT('',(-33.0000000000053,0.161757678873394,280.054167341741));
#1265=CARTESIAN_POINT('',(-33.0000000000053,0.0795443413324496,280.06789104309));
#1266=CARTESIAN_POINT('',(-33.0000000000053,0.037721524965773,280.071356828596));
#1267=CARTESIAN_POINT('',(-33.0000000000053,-0.00399458570124801,280.071356828596));
#1268=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1188,#1189,#1190,#1191,#1192,#1193,#1194,#1195,#1196,
#1197,#1198,#1199,#1200,#1201,#1202,#1203,#1204,#1205,#1206,#1207,#1208,#1209,#1210,#1211,#1212,
#1213,#1214,#1215,#1216,#1217,#1218,#1219,#1220,#1221,#1222,#1223,#1224,#1225,#1226,#1227,#1228,
#1229,#1230,#1231,#1232,#1233,#1234,#1235,#1236,#1237,#1238,#1239,#1240,#1241,#1242,#1243,#1244,
#1245,#1246,#1247,#1248,#1249,#1250,#1251,#1252,#1253,#1254,#1255,#1256,#1257,#1258,#1259,#1260,
#1261,#1262,#1263,#1264,#1265,#1266,#1267),.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.0133979706526223,0.0267028078095297,
0.0527290187850871,0.0789879727401366,0.105247565644315,0.131507894097646,0.157768976639718,
0.1840307498104,0.210293073291658,0.236555744314771,0.262818520117495,0.289081173729038,
0.315343439696336,0.341605125018791,0.367866102381641,0.394126322944536,0.420385819802356,
0.446644702523157,0.472903144135697,0.499161362440358,0.525419597645838,0.551678088271652,
0.577937047178569,0.604196639596219,0.630456965101285,0.656718045547186,0.682979820775645,
0.709242153376611,0.735504842731934,0.761767647187701,0.788040265539663,0.814343517623258,
0.840694981057971,0.867107090312295,0.893585740518022,0.920129562594089,0.946729989175343,
0.973365110555998,1.),.UNSPECIFIED.);
#1269=CARTESIAN_POINT('',(-33.0000000000053,-0.00399458570124801,280.071356828596));
#1270=VERTEX_POINT('',#1269);
#1271=EDGE_CURVE('E67',#1270,#1270,#1268,.F.);
#1272=ORIENTED_EDGE('',*,*,#1019,.F.);
#1273=EDGE_LOOP('',(#1272));
#1274=FACE_BOUND('',#1273,.T.);
#1275=ORIENTED_EDGE('',*,*,#1271,.F.);
#1276=EDGE_LOOP('',(#1275));
#1277=FACE_BOUND('',#1276,.T.);
#1278=ADVANCED_FACE('F94',(#1274,#1277),#1187,.F.);
#1279=CARTESIAN_POINT('',(-33.0000000000053,0.,279.329081834845));
#1280=DIRECTION('',(-1.,0.,0.));
#1281=DIRECTION('',(0.,0.,1.));
#1282=AXIS2_PLACEMENT_3D('',#1279,#1280,#1281);
#1283=PLANE('',#1282);
#1284=CARTESIAN_POINT('',(-33.0000000000053,0.,279.329081834845));
#1285=DIRECTION('',(-1.,0.,0.));
#1286=DIRECTION('',(0.,0.,1.));
#1287=AXIS2_PLACEMENT_3D('',#1284,#1285,#1286);
#1288=CIRCLE('',#1287,1.69999999999998);
#1289=CARTESIAN_POINT('',(-33.0000000000053,0.,281.029081834845));
#1290=VERTEX_POINT('',#1289);
#1291=EDGE_CURVE('E62',#1290,#1290,#1288,.T.);
#1292=ORIENTED_EDGE('',*,*,#1291,.F.);
#1293=EDGE_LOOP('',(#1292));
#1294=FACE_BOUND('',#1293,.T.);
#1295=ORIENTED_EDGE('',*,*,#1271,.T.);
#1296=EDGE_LOOP('',(#1295));
#1297=FACE_BOUND('',#1296,.T.);
#1298=ADVANCED_FACE('F58',(#1294,#1297),#1283,.F.);
#1299=CARTESIAN_POINT('',(-30.6017455785178,0.,279.226756744909));
#1300=DIRECTION('',(0.,-1.,0.));
#1301=DIRECTION('',(0.,0.,1.));
#1302=AXIS2_PLACEMENT_3D('',#1299,#1300,#1301);
#1303=CIRCLE('',#1302,2.99999999999997);
#1304=TRIMMED_CURVE('',#1303,(PARAMETER_VALUE(-1.53668134651745)),
(PARAMETER_VALUE(1.53668134651745)),.T.,.PARAMETER.);
#1305=CARTESIAN_POINT('',(-30.6017455785178,0.,279.329081834845));
#1306=DIRECTION('',(-1.,0.,0.));
#1307=AXIS1_PLACEMENT('',#1305,#1306);
#1308=SURFACE_OF_REVOLUTION('',#1304,#1307);
#1309=CARTESIAN_POINT('',(-33.6000000000053,0.,279.329081834845));
#1310=VERTEX_POINT('',#1309);
#1311=VERTEX_LOOP('',#1310);
#1312=FACE_BOUND('',#1311,.T.);
#1313=ORIENTED_EDGE('',*,*,#1291,.T.);
#1314=EDGE_LOOP('',(#1313));
#1315=FACE_BOUND('',#1314,.T.);
#1316=ADVANCED_FACE('F55',(#1312,#1315),#1308,.T.);
#1317=CLOSED_SHELL('',(#125,#134,#1026,#1278,#1298,#1316));
#1318=MANIFOLD_SOLID_BREP('B2',#1317);
#1319=ADVANCED_BREP_SHAPE_REPRESENTATION('',(#18,#1318),#14);
#1320=SHAPE_DEFINITION_REPRESENTATION(#9,#1319);
ENDSEC;
END-ISO-10303-21;
